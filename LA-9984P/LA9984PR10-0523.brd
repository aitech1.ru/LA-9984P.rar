# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VCIN1_PH: length 165.8
  TOP w0.102: UE1.102 182.46,49.72 182.72,49.46 v2(188.71,49.46) ; PR26.2 v1(129.94,184.97)
  IN2 w0.254: v2(130.03,180.27) 129.2,179.44 129.2,171.82 132.32,168.7 132.32,148.49 139.47,141.34 139.47,140.13 149.86,129.75 149.86,122.3 152.78,119.37 152.78,114.19 154.86,112.11 154.86,109.91 158.98,105.79 159.87,105.79 161.47,104.19 162.03,104.19 163.06,103.16 163.06,102.31 182.7,82.67 183.14,82.67 187.98,77.83 187.98,68.47 189.13,67.32 189.13,51.39 188.71,50.98 v2(188.71,49.46)
VCOUT0_PH#: length 72.6
  TOP w0.102: v2(180.26,48.91) 181.55,48.91 UE1.104
  TOP w0.254: v2(166.68,48.42) 166.68,37.67 169.13,35.22 v1(171.76,35.22) 177.47,35.22 180.71,31.98 190.14,31.98 193.53,28.59 197.37,28.59 197.76,28.99 197.76,29.84 199.04,31.12 199.35,31.12 202.59,31.12 203.74,29.98 PC100.1 203.74,28.68 203.67,28.62 PR102.2 PR100.2 PR101.2
  IN3 w0.127: v2(180.26,48.91) 179.95,48.91 179.53,49.33 178.87,49.33 178.16,48.63 166.89,48.63 v2(166.68,48.42)
VCOUT1_PH: length 175.5
  TOP w0.102: v2(180.1,49.75) 180.54,49.32 UE1.103 ; UE2.2 178.78,53.71 v2(178.91,53.58) 178.6,53.28 RE47.2 ; v1(128.68,163.07) 128.22,163.53 v2(128.22,163.7)
  TOP w0.254: v2(128.22,163.7) 128.11,163.81 PR30.1
  IN1 w0.127: v2(187.61,50.34) 187.61,50.45 186.74,51.31 186.74,56.31 186.62,56.44 186.62,59.37 186.68,59.44 186.68,60.13 187.08,60.54 187.08,64.54 185.53,66.1 185.53,67.96 184.5,68.99 184.5,70.7 185.45,71.65 185.45,73.77 v2(184.93,74.29) ; v2(178.91,53.58) 178.91,50.92 179.75,50.07 179.78,50.07 v2(180.1,49.75)
  IN3 w0.127: v2(180.1,49.75) 187.01,49.75 v2(187.61,50.34) ; v2(128.22,163.7) 128.22,162.43 130.44,160.21 130.44,137.22 132.3,135.37 147.55,135.37 153.03,129.9 155.94,129.9 156.16,129.67 156.17,129.67 159.48,126.36 159.48,119.9 155.73,116.15 155.73,114.99 156.3,114.42 157.61,114.42 158.89,113.13 159.3,113.13 160.94,111.49 160.94,109.14 162.14,107.94 163.37,107.94 166.21,105.1 166.21,101.72 169.21,98.72 173.26,98.72 182.39,89.59 182.39,84.52 186.85,80.06 186.85,76.21 v2(184.93,74.29)
VGA_CLKREQ#_R: length 23.2
  TOP w0.102: QV28.3 182.2,95.8 RV199.2 182.13,96.88 182.91,96.88 183.35,97.33 v1(186.97,97.33) 187.29,97.33 v2(187.61,97.64)
  IN3 w0.102: 185.93,105.7 185.93,107.34 184.93,108.34 184.93,109.98 v2(184.49,110.41)
  IN3 w0.127: 185.93,105.7 185.93,102.04 187.61,100.36 v2(187.61,97.64)
  BOTTOM w0.102: v2(184.49,110.41) 184.79,110.7 UV1.AN13
VGA_SMB_CK2: length 21.4
  TOP w0.102: v2(181.32,93.96) 181.07,93.71 180.63,93.71 180.43,93.91 v1(180.43,94.22) 180.43,95.82 RV90.2 179.55,96.69 178.71,96.69 178.54,96.52 QV15.1
  IN3 w0.127: v2(181.32,93.96) 181.51,93.77 181.51,93.04 181.38,92.91 181.08,92.91 180.62,93.37 180.62,96.12 179.41,97.33 179.41,98.79 178.02,100.18 178.02,102.32 v2(178.16,102.45)
  BOTTOM w0.102: UV14.8 178.55,101.37 178.16,101.76 v2(178.16,102.45) 177.86,102.75 177.86,103.07 RV252.1
VGA_SMB_CK2_R: length 11.5
  IN3 w0.102: 176.09,109.61 175.65,110.05 175.65,113.21 v2(176.06,113.62)
  IN3 w0.127: 176.09,109.61 176.12,109.61 177.19,108.54 177.19,106.77 177.71,106.25 177.71,105.25 v2(177.92,105.04)
  BOTTOM w0.102: RV252.2 177.72,104.56 177.72,104.83 v2(177.92,105.04) ; v2(176.06,113.62) 176.34,113.9 UV1.AJ23
VGA_SMB_DA2: length 25.2
  TOP w0.102: v2(181.45,92.06) 177.83,92.06 177.26,92.63 v1(176.46,92.63) 176.16,92.63 RV91.2 176.11,93.63 176.61,93.14 177,93.14 177.24,93.38 QV15.4
  IN3 w0.127: v2(177.52,102.45) 177.76,102.21 177.76,100.08 179.16,98.68 179.16,97.22 180.37,96.02 180.37,93.26 180.97,92.66 181.29,92.66 181.45,92.5 v2(181.45,92.06)
  BOTTOM w0.102: UV14.7 177.9,102.08 177.52,102.45 v2(177.52,102.45) 177.64,102.57 177.64,102.78 RV251.1
VGA_SMB_DA2_R: length 12.1
  IN3 w0.102: 175.99,109.38 175.42,109.95 175.42,113.61 v2(176.02,114.21)
  IN3 w0.127: v2(177.29,105.04) 177.46,105.21 177.46,106.14 176.94,106.66 176.94,108.43 175.99,109.38
  BOTTOM w0.102: v2(177.29,105.04) 177.49,104.83 177.49,104.56 RV251.2 ; v2(176.02,114.21) 176.02,114.26 UV1.AH23
VGA_X1_R: length 6.8
  TOP w0.102: v1(60.67,51.06) 61.04,50.69 62.39,50.69 62.78,50.3 62.78,48.59 62.88,48.49 RG4.1 63.52,48.24 UG1.12
VL: length 2.7
  TOP w0.203: PU100.13 209.95,20.22 v2(210.17,20.44)
  BOTTOM w0.254: v2(210.17,20.44) 211.22,20.44 PC106.1
VR12.5_VR_ON_R: length 2.1
  TOP w0.089: R250.2 92.87,125.03 v1(92.95,124.95) 93.26,124.64 v2(93.26,124.56)
  BOTTOM w0.076: UC1.F60 93.6,124.21 93.26,124.55 v2(93.26,124.56)
VR_ENABLE: length 4
  BOTTOM w0.102: PC522.1 85.46,142.46 v1(84.94,142.98)
  BOTTOM w0.203: PU501.8 86.46,140.83 86.26,141.02 PR522.1 85.46,141.92 PC522.1
VR_HOT#: length 216.3
  TOP w0.102: v2(64.65,107.01) 63.85,107.81 63.85,114.42 74.73,125.3 83.24,125.3 84.13,126.19 85.91,126.19 86.69,126.98 86.69,133.21 85.45,134.46 v1(85.45,134.97) PR533.1 86.47,135.69 88.22,135.69 88.51,135.98 v2(88.51,136.58) 88.74,136.8 PC506.2 ; v2(180.18,57.58) 180.5,57.27 RE44.1
  IN3 w0.127: v2(180.18,57.58) 179.14,57.58 177.19,55.63 172.07,55.63 171.46,56.24 116.77,56.24 116.15,56.86 112.35,56.86 111.73,56.24 75.35,56.24 72.5,59.08 72.5,71.83 70.13,74.2 70.13,75.47 65.36,80.24 65.36,89.06 64.43,89.99 64.43,93.68 64.68,93.93 64.68,97.55 65.65,98.52 65.65,100.5 64.95,101.21 64.95,104.01 64.21,104.74 64.21,106.58 v2(64.65,107.01)
  BOTTOM w0.102: v2(88.51,136.58) 88.62,136.68 PU501.30
VR_ON: length 273.4
  TOP w0.089: RE1.2 92.55,124.12 R250.1 91.98,123.37 92.02,123.33 92.02,121.38 90.79,120.16 89.87,120.16 C80.1 89.36,119.75 v4(87.14,119.75) 86.76,119.75
  TOP w0.102: v2(170.58,47.93) 170.58,45.46 173.34,42.69 DE1.3 175.22,42.69 CE34.1 175.63,42.28 RE12.2 ; v2(79.98,117.79) 80.89,118.7 83.13,118.7 84.71,120.27 86.07,120.27 86.59,119.75 86.76,119.75
  IN3 w0.127: v2(170.58,47.93) 170.54,47.89 118.49,47.89 117.69,47.09 69.34,47.09 56.35,60.07 56.35,94.67 50.77,100.26 50.77,106.07 v2(62.09,117.4) 70.48,125.79 80.87,125.79 84.06,128.98 84.06,132.39 81.94,134.51 81.94,136.89 83.09,138.04 v2(83.09,140.05)
  BOTTOM w0.102: v2(79.98,117.79) 79.58,117.4 v2(62.09,117.4)
  BOTTOM w0.254: PR522.2 84.29,141.02 84.17,141.15 83.66,141.15 83.4,140.9 83.4,140.37 v2(83.09,140.05)
VR_ON_EC: length 2.1
  TOP w0.102: RE12.1 180.26,42.28 180.42,42.12 UE1.121
VR_READY_R: length 6.7
  BOTTOM w0.076: 92.44,128.44 93.32,128.44 93.88,127.88 93.88,127.15 94.09,126.94 94.09,126.8 94.25,126.64 94.25,126.4 UC1.C59
  BOTTOM w0.089: 91.57,129.38 91.57,129.31 92.44,128.44
  BOTTOM w0.102: 91.57,129.38 90.28,130.67 R251.2
VR_SVID_ALRT#: length 22
  IN3 w0.127: v2(86.9,136.12) 86.9,135.56 85.88,134.55 85.88,131.23 87.02,130.09 87.02,126.36 83.11,122.44 83.11,121.42 v2(82.39,120.7)
  BOTTOM w0.102: R254.2 v2(82.39,120.7) R252.2 ; PR528.2 v2(86.9,136.12) 86.95,136.12 87.82,136.99 PU501.32
VR_SVID_CLK: length 26.4
  IN3 w0.127: v2(79.34,120.19) 79.42,120.11 82.82,120.11 83.95,121.24 83.95,122.45 87.66,126.16 87.66,130.29 86.47,131.48 86.47,134.3 87.49,135.32 87.49,135.84 v2(87.85,136.2)
  BOTTOM w0.102: PR526.2 87.85,135.57 v2(87.85,136.2) 87.85,136.64 88.22,137.01 PU501.31 ; R248.1 v1(79.72,119.81) v2(79.34,120.19)
VR_SVID_DAT: length 24.7
  IN3 w0.127: v2(79.15,121.72) 79.94,121.72 84.27,126.05 85.37,126.05 86.39,127.07 86.39,129.89 85.29,130.98 85.29,134.79 86.07,135.57 v2(86.07,136.83)
  BOTTOM w0.102: v2(79.15,121.72) 79.01,121.86 R257.2 v1(77.82,122.54) ; PR530.2 85.94,136.7 v2(86.07,136.83) 86.45,137.21 86.45,137.72 86.76,138.03 PU501.1
VRAM_ID0: length 7.8
  BOTTOM w0.102: UV1.AU1 193.7,107.46 193.7,103.92 RV68.2 RV67.2 195.16,102.48 v1(195.51,102.14)
VRAM_ID1: length 7.4
  BOTTOM w0.102: v1(190.83,102.75) 191.1,102.48 RV69.2 RV70.2 191.29,103.86 191.29,105.33 191.61,105.65 191.61,107.84 UV1.AU3
VRAM_ID2: length 5.4
  BOTTOM w0.102: UV1.AW3 192.37,107.19 192.37,104.11 192.72,103.75 v1(192.72,103.38) 192.72,102.64 RV71.2
VREF_CPU: length 56
  TOP w0.102: v1(87.09,146.05) 87.72,145.42 v2(87.72,144.77)
  TOP w0.203: v2(90.03,136.45) 89.94,136.54 PC507.1
  IN3 w0.254: v2(111.76,146.8) 111.66,146.9 111.66,147.44 110.9,148.2 92.8,148.2 90.58,145.98 90.58,143.85 89.98,143.24 88.17,143.24 88.17,143.31 87.72,143.75 v2(87.72,144.77) 85.88,144.77 85.37,144.26 85.37,142.17 87.15,140.39 87.15,138.61 87.72,138.04 89.31,138.04 90.03,137.31 v2(90.03,136.45)
  BOTTOM w0.203: PU501.27 89.82,136.99 89.91,136.9 89.91,136.58 v2(90.03,136.45) 90.39,136.1 90.39,135.18 PR531.1
  BOTTOM w0.254: PR502.2 PR504.2 PR507.2 v2(87.72,144.77) 87.72,145.09 88.13,145.49 90.24,145.49 90.45,145.28 90.45,144.77 90.77,144.45 PR514.2 ; PH502.1 111.76,146.33 v2(111.76,146.8)
VREFC1: length 6.3
  BOTTOM w0.305: UV4.J14 168.48,144.25 168.48,142.78 168.11,142.42 v1(168.11,142.13) CV397.1 RV29.1 RV37.2 CV388.2
VREFC2: length 6.3
  TOP w0.305: CV328.2 RV183.2 CV399.1 RV184.1 168.11,141.7 v1(168.49,142.07) 168.49,144.26 UV5.J14
VREFC3: length 6.8
  TOP w0.305: CV350.2 RV193.2 CV349.1 RV194.1 187.35,141.54 v1(187.9,142.08) 189.2,143.38 UV3.J14
VREFC4: length 6.8
  BOTTOM w0.305: CV354.2 RV197.2 CV353.1 RV39.1 187.35,141.61 v1(187.88,142.13) 189.2,143.45 UV6.J14
VREFC5: length 6.3
  BOTTOM w0.305: CV21.2 RV6.2 CV22.1 RV5.1 v1(202.34,135.69) 202.91,135.12 UV8.J14
VREFC6: length 7.4
  TOP w0.305: UV7.J14 203.67,135.12 v1(202.43,133.87) RV11.1 CV27.1 201.58,132.87 201.58,131.8 RV12.2 CV28.2
VREFC7: length 6.8
  TOP w0.305: UV9.J14 203.54,114.72 v1(202.27,115.99) 201.7,116.56 CV34.2 RV19.2 CV33.1 RV17.1
VREFC8: length 6.8
  BOTTOM w0.305: UV10.J14 203.62,114.72 v1(202.23,116.11) 201.78,116.56 CV40.2 RV27.2 CV39.1 RV24.1
VREFD1_1: length 10.4
  TOP w0.254: v2(163.1,150.06) 162.55,150.61 162.44,150.61 160.72,152.33 v1(159.99,152.33) RV28.2 CV393.2 RV34.1 CV387.1
  BOTTOM w0.305: UV4.A10 163.1,148.47 v2(163.1,150.06)
VREFD1_2: length 14.4
  BOTTOM w0.254: UV4.U10 174.88,147.66 174.59,147.94 174.59,148.83 176.18,150.42 v1(176.18,157.44) CV394.2 RV35.2 CV395.1 RV36.1
VREFD2_1: length 15
  TOP w0.254: v2(178.84,157.57) RV181.1 CV398.1 RV38.2 CV396.2
  TOP w0.305: v2(175.08,148.23) 175.09,148.22 UV5.A10
  BOTTOM w0.254: v2(178.84,157.57) v1(178.1,156.83) 176.62,155.35 176.62,150.04 175.08,148.5 v2(175.08,148.23)
VREFD2_2: length 9
  TOP w0.254: CV400.1 159.05,148.79 RV186.1 CV330.2 RV185.2 159.91,150.57 v1(160.05,150.57) 161.29,150.57 161.8,150.06 v2(162.4,150.06)
  TOP w0.305: v2(162.4,148.77) 162.28,148.65 UV5.U10
  BOTTOM w0.102: 162.4,149.98 v2(162.4,150.06)
  BOTTOM w0.254: v2(162.4,148.77) 162.4,149.98
VREFD3_1: length 14.2
  TOP w0.254: CV389.2 RV32.2 CV390.1 RV33.1 v2(200.04,156.45)
  TOP w0.305: v2(195.59,148.16) 195.6,148.16 UV3.A10
  BOTTOM w0.254: v2(200.04,156.45) v1(200.04,154.05) 200.04,153.14 195.59,148.69 v2(195.59,148.16)
VREFD3_2: length 16.7
  TOP w0.254: v2(183.23,150.93) 182.78,150.48 182.08,150.48 180.77,151.8 180.77,154.71 179.73,155.74 v1(179.73,157.32) RV192.1 CV332.1 180.62,158.3 181.52,159.2 ; 181.52,159.2 CV401.2 ; 181.52,159.2 RV191.2 ; v2(183.1,148.03) 182.79,147.72 UV3.U10
  BOTTOM w0.254: v2(183.23,150.93) 183.23,148.15 v2(183.1,148.03)
VREFD4_1: length 14.1
  TOP w0.254: v2(180.62,157.53) 180.62,155.96 v1(181.14,155.44) 181.15,155.44 181.15,152.44 v2(182.46,151.12)
  BOTTOM w0.254: CV352.2 RV195.2 CV351.1 RV196.1 v2(180.62,157.53) ; v2(182.46,151.12) 182.46,147.92 UV6.A10
VREFD4_2: length 15.3
  BOTTOM w0.254: RV41.1 CV355.1 RV40.2 CV356.2 198.99,156.45 v1(198.47,156.45) 197.39,156.45 196.69,155.75 196.69,150.42 195.1,148.83 195.1,147.94 195.45,147.59 UV6.U10
VREFD5_1: length 17.2
  TOP w0.254: v2(217.01,144.71) v1(212.12,144.71) 210.98,143.56 210.98,140.83 210.72,140.58 v2(210.4,140.58)
  BOTTOM w0.254: v2(217.01,144.71) 217.71,144.71 218.23,144.18 RV1.2 ; CV18.2 RV1.2 ; RV1.2 218.52,144.11 CV13.1 RV2.1
  BOTTOM w0.305: UV8.A10 208.9,140.58 v2(210.4,140.58)
VREFD5_2: length 14.8
  BOTTOM w0.254: UV8.U10 208.42,129.17 209.49,129.17 211.55,127.12 215.8,127.12 216.25,126.67 v1(217.41,126.67) RV4.1 CV20.1 218.48,127.56 219.24,128.32 219.24,128.32 RV3.2 CV19.2
VREFD6_1: length 15.1
  TOP w0.254: v2(216.91,125.63) 217.95,126.67 RV7.1 CV23.1 RV8.2 CV24.2
  TOP w0.305: v2(208.62,128.72) UV7.A10
  BOTTOM w0.254: v2(208.62,128.72) 209.41,128.72 211.39,126.73 214.46,126.73 v1(215.56,125.63) v2(216.91,125.63)
VREFD6_2: length 11.5
  TOP w0.254: CV26.2 RV10.2 CV25.1 RV9.1 v1(208.42,144.63) 210.4,142.65 v2(210.4,141.21)
  TOP w0.305: v2(208.95,141.21) 208.65,141.52 UV7.U10
  BOTTOM w0.254: v2(208.95,141.21) v2(210.4,141.21)
VREFD7_1: length 11.1
  TOP w0.254: UV9.A10 209.9,108.32 210.21,108.64 v2(210.21,108.76)
  BOTTOM w0.254: v2(210.21,108.76) 210.21,107.43 v1(212.45,105.19) 212.64,105 RV13.1 CV29.1 RV14.2 CV30.2
VREFD7_2: length 23.5
  TOP w0.305: v2(208.31,120.7) 208.19,120.7 UV9.U10
  BOTTOM w0.305: CV32.2 RV16.2 CV31.1 RV15.1 v1(207.14,104.81) 209.35,107.02 209.35,118.7 210.15,119.5 210.15,120.32 209.78,120.69 208.32,120.69 v2(208.31,120.7)
VREFD8_1: length 27.1
  TOP w0.254: v2(215.01,102.83) 214.53,102.35 RV20.1 CV35.1 RV21.2 CV36.2
  BOTTOM w0.254: UV10.A10 207.81,121.16 210.14,121.16 210.66,120.64 210.66,119.11 209.76,118.21 209.76,110.29 210.72,109.33 210.72,107.62 v1(214.45,103.89) 215.01,103.34 v2(215.01,102.83)
VREFD8_2: length 26.5
  TOP w0.254: CV38.2 RV23.2 219.37,120.32 218.48,121.21 CV37.1 RV22.1 v1(217.49,122.1) 215.99,122.1 215.42,122.67 211.23,122.67 209.64,121.08 v2(209.64,119.94)
  BOTTOM w0.254: v2(209.64,119.94) 208.82,119.11 208.82,109.08 208.05,108.32 UV10.U10
VTTREF_1.35V: length 4.3
  BOTTOM w0.102: PC210.1 159.21,30.69 159.21,31.96 v1(159.08,32.08)
  BOTTOM w0.203: 159.23,29.59 159.23,29.27 158.91,28.95 PU200.4
  BOTTOM w0.254: 159.23,29.59 159.67,30.04 PC210.1
WCKA0_0: length 30.5
  TOP w0.102: UV5.P4 164.68,152.41 v2(165.05,152.05)
  TOP w0.109: v2(165.05,152.05) 165.12,151.98 165.12,151.49 164.8,151.17 164.8,149.66 164.45,149.32 161.64,149.32 159.94,147.62 159.94,141.44 v3(162.4,138.99) 164.11,137.27 164.11,136 165.57,134.54 165.57,133.97 166.27,133.27 166.67,133.27 167.2,133.8 167.9,133.8 168.36,134.26 168.99,134.26 169.14,134.42 v2(169.14,134.67)
  BOTTOM w0.102: v2(169.14,134.67) 169.46,134.99 UV1.A32 ; v2(165.05,152.05) 164.68,152.41 UV5.P4
WCKA0_1: length 30.7
  TOP w0.102: v2(172.31,152.07) 172.69,152.45 UV5.D4
  TOP w0.109: v2(176.94,134.29) 176.78,134.29 176.67,134.19 176.67,134.02 176.77,133.92 176.77,133.51 176.23,132.96 176.01,132.75 172.92,132.75 172.47,133.19 172.47,135.54 171.59,136.43 v3(171.59,138.03) 171.59,138.78 173.62,140.81 173.62,141.57 175.55,143.5 175.55,149.42 174.64,150.33 172.85,150.33 172.57,150.61 172.57,151.22 172.31,151.48 v2(172.31,152.07)
  BOTTOM w0.102: UV5.D4 172.69,152.45 v2(172.31,152.07) ; UV1.D23 176.66,134.01 v2(176.94,134.29)
WCKA0B_0: length 30.5
  TOP w0.102: v2(164.3,152.04) 164.31,152.04 UV5.P5
  TOP w0.109: v2(169.15,133.91) 169.01,134.05 168.44,134.05 167.99,133.59 167.29,133.59 166.76,133.06 166.18,133.06 165.36,133.89 165.36,134.46 163.9,135.92 163.9,137.19 162.46,138.63 162.43,138.63 162.03,139.02 162.03,139.05 159.73,141.36 159.73,147.7 161.56,149.53 164.36,149.53 164.59,149.75 164.59,151.24 164.3,151.52 v2(164.3,152.04)
  BOTTOM w0.102: UV5.P5 164.31,152.04 v2(164.3,152.04) ; v2(169.15,133.91) 169.46,134.23 UV1.C32
WCKA0B_1: length 30.8
  TOP w0.102: UV5.D5 173.08,152.05 v2(173.1,152.05)
  TOP w0.109: v2(176.18,133.91) 176.23,133.96 176.43,133.96 176.56,133.83 176.56,133.6 176.08,133.11 175.92,132.96 173,132.96 172.69,133.28 172.69,135.62 171.8,136.51 171.8,137.72 171.82,137.75 171.82,138.31 171.8,138.33 171.8,138.7 173.83,140.73 173.83,141.48 175.76,143.41 175.76,149.51 174.73,150.54 172.94,150.54 172.78,150.7 172.78,151.19 173.11,151.52 173.11,152.04 v2(173.1,152.05)
  BOTTOM w0.102: UV5.D5 172.71,151.66 v2(173.1,152.05) ; v2(176.18,133.91) 176.59,133.5 UV1.E22
WCKA1_0: length 24.8
  TOP w0.102: v2(185.56,151.99) 185.19,152.35 UV3.P4
  TOP w0.109: v2(180.88,137.15) 180.99,137.26 181.36,137.26 181.6,137.5 181.6,138.9 v3(181.21,139.3) 181.03,139.48 181.03,147.8 182.48,149.25 184.85,149.25 185.49,149.89 185.49,151.38 185.56,151.45 v2(185.56,151.99)
  BOTTOM w0.102: UV3.P4 185.19,152.35 v2(185.56,151.99)
  BOTTOM w0.109: UV1.C14 183.86,134.36 183.33,134.89 183.33,135.76 181.76,137.34 181.06,137.34 v2(180.88,137.15)
WCKA1_1: length 32.3
  TOP w0.102: v2(192.82,152.01) 193.2,152.38 UV3.D4 ; 186.2,133.52 v2(186.02,133.34)
  TOP w0.109: 186.2,133.52 186.2,134.68 186.51,134.98 186.51,137.07 186.64,137.2 186.64,138.63 186.75,138.75 186.75,138.78 187.15,139.17 187.18,139.17 187.32,139.31 191.67,139.31 193.25,140.89 193.25,141.05 192.92,141.37 192.92,141.7 193.28,142.06 193.61,142.06 193.93,141.73 194.09,141.73 196.38,144.03 196.38,148.59 196.03,148.93 193.48,148.93 193.01,149.4 193.01,151.18 192.82,151.37 v2(192.82,152.01)
  BOTTOM w0.102: UV1.E10 187.06,133.33 187.06,133.33 187.06,133.27 186.8,133.01 186.35,133.01 v2(186.02,133.34) ; UV3.D4 193.2,152.38 v2(192.82,152.01)
WCKA1B_0: length 24.9
  TOP w0.102: UV3.P5 184.82,151.97 v2(184.81,151.97)
  TOP w0.109: v2(180.88,137.73) 180.88,137.73 181.13,137.47 181.27,137.47 181.39,137.59 181.39,138.82 181.29,138.92 181.26,138.92 180.82,139.36 180.82,147.89 182.39,149.46 184.76,149.46 185.28,149.97 185.28,151.14 185.19,151.23 184.9,151.23 184.81,151.31 v2(184.81,151.97)
  BOTTOM w0.102: UV3.P5 184.82,151.97 v2(184.81,151.97)
  BOTTOM w0.109: UV1.A14 183.86,134.94 183.77,134.85 183.67,134.85 183.54,134.97 183.54,135.85 181.84,137.55 181.06,137.55 v2(180.88,137.73)
WCKA1B_1: length 32.4
  TOP w0.102: UV3.D5 193.59,151.99 v2(193.61,151.99)
  TOP w0.109: v2(186.59,133.39) 186.41,133.57 186.41,134.59 186.72,134.89 186.72,136.98 186.85,137.11 186.85,138.54 v3(187.11,138.81) 187.4,139.1 191.76,139.1 193.46,140.81 193.46,141.14 193.13,141.46 193.13,141.61 193.37,141.85 193.52,141.85 193.85,141.52 194.18,141.52 196.59,143.94 196.59,148.67 196.12,149.14 193.56,149.14 193.22,149.49 193.22,151.11 193.62,151.52 193.62,151.97 v2(193.61,151.99)
  BOTTOM w0.102: v2(186.59,133.39) 186.59,133.47 187.03,133.9 UV1.D9 ; v2(193.61,151.99) 193.22,151.59 UV3.D5
WCKB0_0: length 37.4
  TOP w0.102: UV7.P4 212.71,139.12 v2(212.35,138.75) ; v2(192.5,130.58) 192.65,130.58 192.9,130.32 192.9,130.18 192.81,130.09 192.31,130.09 191.21,131.18 190.82,131.18 190.42,131.58 190.42,132.62 190.57,132.77 190.57,133.99 190.93,134.35 193.23,134.35 193.29,134.42 193.61,134.42 193.88,134.69
  TOP w0.109: 193.88,134.69 193.97,134.78 194.73,134.78 203.52,143.56 v3(204.16,143.56) 208.21,143.56 209.49,142.28 209.49,140.1 210.3,139.29 211.46,139.29 211.57,139.18 211.57,138.84 211.69,138.72 212.32,138.72 v2(212.35,138.75)
  BOTTOM w0.102: v2(212.35,138.75) 212.71,139.12 UV7.P4 ; v2(192.5,130.58) 192.42,130.51 192.27,130.51 192.06,130.71 UV1.H3
WCKB0_1: length 29
  TOP w0.102: UV7.D4 212.74,131.12 v2(212.35,131.5) ; v2(190.97,124.89) 190.99,124.89 191.1,124.78 191.46,124.78 191.6,124.91 191.6,127.1 192.75,128.25 194.33,128.25 194.33,128.26 194.36,128.26
  TOP w0.109: 194.36,128.26 195.93,128.26 195.95,128.28 196.54,128.28 196.56,128.26 209.76,128.26 210.63,129.12 210.63,131.07 211.05,131.49 212.34,131.49 v2(212.35,131.5)
  BOTTOM w0.102: UV1.T3 191.69,124.5 191.3,124.89 v2(190.97,124.89) ; UV7.D4 212.74,131.12 v2(212.35,131.5)
WCKB0B_0: length 37.4
  TOP w0.102: UV7.P5 212.34,139.49 v2(212.34,139.5) ; 193.73,134.84 193.71,134.82 193.71,134.82 193.67,134.77 193.67,134.77 193.58,134.67 193.52,134.62 193.21,134.62 193.15,134.56 190.85,134.56 190.36,134.08 190.36,132.85 190.22,132.7 190.22,131.49 190.73,130.98 191.13,130.98 192.22,129.88 192.89,129.88 193.11,130.1 193.11,130.46 193.2,130.56 v2(193.2,130.56)
  TOP w0.109: v2(212.34,139.5) 210.39,139.5 209.7,140.19 209.7,142.37 208.3,143.77 204.46,143.77 204.44,143.79 203.88,143.79 203.85,143.77 203.43,143.77 194.65,134.99 193.88,134.99 193.73,134.84
  BOTTOM w0.102: UV7.P5 212.34,139.49 v2(212.34,139.5) ; v2(193.2,130.56) UV1.H1
WCKB0B_1: length 29
  TOP w0.102: v2(190.86,124.23) 191.21,124.58 191.54,124.58 191.8,124.83 191.8,127.02 192.83,128.05 194.27,128.05 194.27,128.05 194.33,128.05 194.34,128.05 194.36,128.05 ; UV7.D5 212.35,130.73 v2(212.35,130.7)
  TOP w0.109: 194.36,128.05 v3(196.26,128.05) 209.85,128.05 210.84,129.04 210.84,130.98 211.14,131.28 211.53,131.28 211.6,131.21 211.6,130.83 211.75,130.69 212.34,130.69 v2(212.35,130.7)
  BOTTOM w0.102: v2(190.86,124.23) 191.14,124.5 UV1.T5 ; v2(212.35,130.7) 212.35,130.73 UV7.D5
WCKB1_0: length 29.7
  TOP w0.102: v2(212.16,118.36) 212.52,118.72 UV9.P4 ; 194.2,119.63 194.14,119.63 194.14,119.63 192.5,119.63 191.61,118.74 191.61,118.15 191.29,117.83 191.29,117.29 191.68,116.9 v2(191.68,116.82)
  TOP w0.109: v2(212.16,118.36) 211.54,118.36 211.22,118.68 209.71,118.68 208.7,119.69 208.7,122.49 208.29,122.9 198.17,122.9 194.89,119.63 194.78,119.63 194.76,119.6 194.22,119.6 194.2,119.63
  BOTTOM w0.102: UV1.AE4 191.75,117.21 191.75,116.89 v2(191.68,116.82) ; v2(212.16,118.36) 212.52,118.72 UV9.P4
WCKB1_1: length 28
  TOP w0.102: UV9.D4 212.57,110.72 v2(212.16,110.31)
  TOP w0.109: v2(212.16,110.31) 211.03,110.31 210.84,110.12 210.84,108.23 209.93,107.32 203.31,107.32 198.09,112.54 198.06,112.54 197.74,112.86 194.2,112.86 v2(193.96,112.63)
  BOTTOM w0.102: v2(193.96,112.63) 193.77,112.82 193.18,112.82 193.12,112.75 192.64,112.75 192.59,112.81 192.34,112.81 192.28,112.75 191.84,112.75 191.79,112.81 191.54,112.81 191.48,112.75 191,112.75 190.83,112.92 190.79,113.08 190.67,113.15 UV1.AK6 ; v2(212.16,110.31) 212.57,110.72 UV9.D4
WCKB1B_0: length 29.7
  TOP w0.102: UV9.P5 211.77,118.73 v2(212.15,119.11) ; 194.08,119.84 194.08,119.83 192.41,119.83 191.41,118.82 191.41,118.23 191.09,117.92 191.09,117.01 v2(191.04,116.96)
  TOP w0.109: v2(212.15,119.11) 211.63,119.11 211.41,118.89 209.79,118.89 208.91,119.77 208.91,122.58 208.38,123.11 198.08,123.11 194.81,119.84 v3(194.48,119.84) 194.08,119.84
  BOTTOM w0.102: v2(212.15,119.11) 211.77,118.73 UV9.P5 ; UV1.AF5 191.26,116.73 v2(191.04,116.96)
WCKB1B_1: length 28.1
  TOP w0.102: UV9.D5 211.81,110.72 v2(212.19,111.09)
  TOP w0.109: v2(212.19,111.09) 211.41,111.09 211.31,110.99 211.31,110.64 211.18,110.52 210.94,110.52 210.63,110.21 210.63,108.32 209.84,107.53 203.4,107.53 v3(198.02,112.91) 197.86,113.07 194.1,113.07 v2(193.96,113.21)
  BOTTOM w0.102: UV1.AK5 191.06,113.25 190.99,113.13 191.01,113.03 191.08,112.96 191.4,112.96 191.45,113.01 191.87,113.01 191.93,112.96 192.2,112.96 192.25,113.01 192.67,113.01 192.73,112.96 193.03,112.96 193.09,113.02 193.77,113.02 v2(193.96,113.21) ; v2(212.19,111.09) 211.81,110.72 UV9.D5
WEA0#: length 32.1
  TOP w0.102: UV5.G12 170.26,146.06 v2(169.86,146.46)
  IN3 w0.102: 169.17,143.36 169.17,144.12 169.45,144.39 169.45,146.04 v2(169.86,146.46) ; v2(174.91,129.97) 174.05,130.83 173.22,130.83 172.9,131.15 172.9,132.3 172.43,132.77 172.43,133.66 170.65,135.43 170.65,136.07 170.21,136.51 169.32,136.51 168.93,136.9 168.93,137.4
  IN3 w0.157: 169.17,143.36 169.17,143.04 168.49,142.36 166,142.36 165.87,142.23 165.87,137.23 166,137.1 166.41,137.1 166.53,137.23 166.53,138.08 166.66,138.21 167.04,138.21 167.16,138.08 167.16,137.17 167.29,137.04 167.67,137.04 167.79,137.17 167.79,138.08 167.92,138.21 168.8,138.21 168.93,138.08 168.93,137.4
  BOTTOM w0.102: v2(174.91,129.97) 174.44,129.5 UV1.K26 ; UV5.G12 170.26,146.06 v2(169.86,146.46)
WEA1#: length 29.2
  TOP w0.102: UV3.G12 190.77,145.99 v2(190.37,146.39)
  IN3 w0.102: v2(184.12,128.26) 183.92,128.45 183.92,130.86 184.18,131.12 184.78,131.12 185,131.34 185,132.46 185.49,132.95 185.49,133.99 188.9,137.4 ; 189.13,143.3 189.13,144.72 188.41,145.44 188.41,146.55 188.67,146.81 189.95,146.81 v2(190.37,146.39)
  IN3 w0.157: 188.9,137.4 190.47,138.96 190.47,139.83 190.59,139.96 190.97,139.96 191.1,140.08 191.1,141.48 191.23,141.61 191.61,141.61 191.74,141.73 191.74,142.14 191.61,142.27 189.6,142.27 189.13,142.74 189.13,143.3
  BOTTOM w0.102: UV3.G12 190.77,145.99 v2(190.37,146.39) ; UV1.L15 183.67,128.7 v2(184.12,128.26)
WEB0#: length 34.5
  TOP w0.102: v2(206.76,133.94) 206.36,133.54 UV7.G12
  IN3 w0.102: 203.66,134.63 204.42,134.63 204.69,134.35 204.69,133.54 204.82,133.42 205.45,133.42 205.57,133.53 205.57,134.28 205.66,134.37 206.33,134.37 v2(206.76,133.94) ; 194.39,131.37 194.32,131.31 192.31,131.31 191.67,130.67 191.67,130.23 191.15,129.71 191.04,129.71 190.92,129.59 190.09,129.59 189.77,129.27 189.77,128.85 189.43,128.51 188.05,128.51 187.45,127.91 v2(187.45,126.72)
  IN3 w0.157: 203.66,134.63 203.36,134.63 203.23,134.5 203.23,133.76 203.1,133.64 202.66,133.64 202.53,133.76 202.53,135.64 202.34,135.83 201.96,135.83 201.7,135.56 201.7,134.12 201.57,134 201.19,134 201.07,134.12 201.07,134.99 200.94,135.12 196.02,135.12 195.7,134.8 195.7,132.69 194.39,131.37
  BOTTOM w0.102: v2(187.45,126.72) 187.26,126.91 UV1.N10 ; UV7.G12 206.36,133.54 v2(206.76,133.94)
WEB1#: length 31.8
  TOP w0.102: v2(206.57,113.54) 206.17,113.14 UV9.G12
  IN3 w0.102: 194.39,113.39 194.19,113.59 193.31,113.59 193.01,113.9 193.01,114.66 191.6,116.07 191.38,116.07 190.52,116.93 190.52,117.34 190.31,117.55 188.31,117.55 187.88,117.97 187.61,117.97 187.45,118.13 187.45,119.1 v2(187.07,119.48) ; 203.47,114.86 204.97,114.86 205.61,115.5 206.73,115.5 206.99,115.24 206.99,113.96 v2(206.57,113.54)
  IN3 w0.157: 203.47,114.86 203.41,114.86 202.25,113.69 201.51,113.69 201.32,113.5 201.32,111.56 200.43,110.67 197.23,110.67 194.5,113.39 194.39,113.39
  BOTTOM w0.102: v2(187.07,119.48) 186.85,119.7 UV1.AB11 ; UV9.G12 206.17,113.14 v2(206.57,113.54)
WL_BT_LED: length 146.6
  TOP w0.102: v2(63.53,17.99) v1(62.87,18.64) 62.18,19.33 59.81,19.33 RD50.1 QD20.2 ; v2(183.37,34.44) 183.37,35.07 182.85,35.59 182.85,35.85 182.97,35.98 182.97,36.71 183.19,36.92 UE1.1
  IN1 w0.127: v2(63.53,17.99) 63.53,18.16 66.04,20.68 82.19,20.68 106.75,45.24 133.06,45.24 136.51,41.79 159.99,41.79 166.53,35.25 181.16,35.25 182.46,33.95 182.87,33.95 v2(183.37,34.44)
WL_BT_LED#: length 11.2
  TOP w0.102: RD18.1 52.15,14.09 v1(52.6,13.64) 53.14,13.1 58.04,13.1 58.27,13.32 QD20.1 56.96,14.89 56.72,14.65 RD51.2
WL_BT_LED#_EC: length 203.6
  TOP w0.102: UE1.64 198.2,51.72 198.26,51.78 198.26,52.11 198.15,52.22 v2(197.86,52.22) ; RD51.1 54.42,14.01 54.21,14.23 QD19.1 53,14.89 52.89,15 RD46.2 50.36,15 49.44,14.09 v1(48.44,14.09) 47.97,14.56 QD18.1 47.97,16.59 48.17,16.79 51.71,16.79 53.33,18.42 RD52.1 53.33,19.74 RD49.2 53.28,20.98 53.56,21.26 UD1.4 55.52,21.26 56.01,21.76 60.99,21.76 v2(64.7,18.05)
  IN1 w0.127: v2(64.7,18.05) 64.7,18.6 66.27,20.17 82.4,20.17 106.96,44.73 132.85,44.73 136.3,41.28 159.78,41.28 166.32,34.74 180.95,34.74 182.25,33.44 188.22,33.44 189.47,32.2 192.64,32.2 v2(193.13,32.69)
  IN2 w0.127: v2(197.86,52.22) 197.86,36.16 197.11,35.41 193.96,35.41 193.13,34.58 v2(193.13,32.69)
WL_BT_LED#_EC2: length 178.8
  TOP w0.102: RD48.2 v1(60.95,19.79) 62.34,19.79 v2(64.11,18.01) ; UE1.74 191.99,54.41 v2(192.14,54.56)
  IN1 w0.127: v2(64.11,18.01) 64.11,18.39 66.15,20.42 82.3,20.42 106.86,44.99 132.95,44.99 136.41,41.53 159.89,41.53 166.43,34.99 181.06,34.99 182.35,33.7 188.33,33.7 189.57,32.45 192.18,32.45 v2(192.41,32.68)
  IN2 w0.127: v2(192.41,32.68) 192.41,34.23 194.06,35.88 195.95,35.88 196.66,36.59 196.66,40.85 192.73,44.78 192.73,46.32 191.9,47.14 191.9,48.83 192.14,49.07 v2(192.14,54.56)
WL_LED#: length 221.8
  TOP w0.102: UD1.1 57.54,19.96 57.71,19.79 RD48.1 58.21,19.48 v2(57.84,19.12) ; v2(85.69,150.1) 85.12,149.53 85.12,141.27 83.04,139.19 82.51,139.19 81.56,138.24 81.56,136.53 82.07,136.02 83.02,136.02 86.08,132.96 86.08,129.1 82.89,125.91 74.14,125.91 62.28,114.05 53.94,114.05 52.73,112.84 52.73,108.02 53.85,106.9 v1(53.85,93.42) 53.85,86.77 48.18,81.09 45.64,81.09 39.61,75.07 39.61,75.07 38.64,74.1 38.64,60.57 53.88,45.33 53.88,26.36 48.92,21.4 RD45.2 47.01,18.78 QD18.3 47.01,16.7 v2(46.85,16.55)
  IN2 w0.127: v2(57.84,19.12) 56.39,19.12 53.83,16.55 v2(46.85,16.55)
  IN3 w0.127: v2(112.31,148.93) 111.93,149.32 91.28,149.32 90.49,150.1 v2(85.69,150.1)
  BOTTOM w0.102: v2(112.31,148.93) 112.7,149.32 JMINI.44
WL_OFF#: length 85.4
  TOP w0.089: RP54.3 132.7,117.14 v2(132.82,117.02)
  TOP w0.102: v2(97.07,148.89) 97.09,148.89 v1(97.45,148.53) 97.61,148.37 QM30.3
  IN2 w0.089: 124.97,135.15 124.97,131.63 129.91,126.69 129.91,121.12 131.41,119.62 131.41,118.61 132.82,117.2 v2(132.82,117.02) 132.31,116.51 130.33,116.51 129.89,116.07 129.89,114.93 131.41,113.41 131.41,113.41 131.43,113.39 132.76,113.39 133,113.16 133,112.7 130.27,109.97 130.27,108.89 129.93,108.56 129.93,107.55 129.06,106.68 127.9,106.68 v2(127.87,106.71)
  IN2 w0.127: v2(97.07,148.89) 98.06,148.89 99.09,149.91 122.52,149.91 125.63,146.8 125.63,135.81 124.97,135.15
  BOTTOM w0.089: v2(127.87,106.71) 127.38,107.2 UC1.AT5
WLAN_CLKREQ#: length 109.9
  TOP w0.089: v2(127.82,116.95) 128.25,116.52 128.25,115.37 128.74,114.88 129.27,114.88 129.51,115.12 131.51,115.12 131.51,115.12 131.82,115.12 132.04,115.34 132.04,115.43 132.3,115.69 133.12,115.69 133.5,115.31 134.87,115.31 136.15,114.03 137.92,114.03
  TOP w0.102: 137.92,114.03 138.29,114.03 138.89,114.63 v1(140.61,114.63) 143.31,114.63 143.91,114.03 144.3,114.03 145.52,115.25 RP42.7 ; JMINI.7 94.7,151.97 94.34,151.62 90.98,151.62 90.6,151.24 v2(90.6,149.33)
  IN1 w0.084: v2(127.82,116.95) 128.4,117.53 130.46,117.53 131.28,118.35 131.28,120.19 v2(132.24,121.15)
  IN2 w0.089: v2(127.82,116.95) 127.38,116.51 125.62,116.51 125.11,117.02 125.11,121.86 125.76,122.51 125.76,130.59 124.9,131.45 124.72,131.63 124.72,135.05 124.72,135.15
  IN2 w0.127: 124.72,135.15 124.72,135.26 125.38,135.92 125.38,146.7 122.44,149.63 100.49,149.63 99.31,148.45 96.84,148.45 95.96,149.33 v2(90.6,149.33)
  BOTTOM w0.089: v2(132.24,121.15) 132.16,121.15 131.36,120.35 UC1.N1
WLAN_RADIO_DIS#_R: length 5.3
  TOP w0.102: v2(103.1,148.78) 103.17,148.85 RM110.2 ; v2(103.1,148.78) 103.1,148.53 v1(103.58,148.05) ; v2(103.1,148.78) 102.55,149.33 QM30.1
  BOTTOM w0.102: JMINI.20 v2(103.1,148.78)
WOL_EN: length 198.6
  TOP w0.102: v2(182.85,51.42) 182.74,51.32 UE1.98
  IN3 w0.127: v2(182.85,51.42) 182.2,50.78 178.84,50.78 178.15,50.09 176.75,50.09 175.98,50.86 69.32,50.86 61.18,59 61.18,74.5 59.04,76.64 59.04,94.39 55.59,97.83 v2(55.59,99.05)
  BOTTOM w0.102: v2(55.59,99.05) 55.29,98.75 54.13,98.75 52.1,96.71 v1(52.1,90.39) 52.1,86.93 50.18,85.02 UL2.3 49.51,83.7 48.8,82.98 43.86,82.98 RL27.2 43.79,82.58 43.32,82.1 41.94,82.1 41.43,82.62 RL38.1
XDP_DBRESET#: length 7.7
  BOTTOM w0.102: JXDP1.48 61.7,102.92 CC17.1 RC362.2 59.71,104.04 59.71,104.17 59.6,104.27 59.6,105.79 RC26.1 v1(61.14,106.16)
XDP_OBS0_R: length 67.2
  IN3 w0.127: v2(57.76,100) 57.77,99.99 57.77,109.3 68.72,120.26 78.41,120.26 79.15,119.52 83.07,119.52 85.47,121.92 v2(85.47,122.13)
  BOTTOM w0.076: 88.41,122.68 90.37,122.68 90.56,122.48 90.56,122.48 90.86,122.18 91.34,122.18 91.34,122.18 91.84,122.18 92,122.35 92.79,122.35 92.83,122.31 93.31,122.31 UC1.J60
  BOTTOM w0.102: RC141.1 85.37,122.04 v2(85.47,122.13) v1(86.05,122.71) 86.65,122.71 86.73,122.63 88.37,122.63 88.41,122.68 ; JXDP1.21 68.2,98.06 67.51,98.75 58.88,98.75 57.76,99.87 v2(57.76,100)
XDP_OBS1_R: length 68
  TOP w0.102: v2(82.52,121.72) v1(81.82,121.72)
  IN1 w0.127: v2(93.31,122.99) 92.93,122.61 91.53,122.61 90.64,121.71 82.52,121.71 v2(82.52,121.72)
  IN3 w0.127: v2(57.25,99.49) 57.25,109.51 69.73,122 78.03,122 78.9,121.12 81.92,121.12 v2(82.52,121.72)
  BOTTOM w0.089: v2(93.31,122.99) 93.6,123.28 UC1.H60
  BOTTOM w0.102: JXDP1.23 67.72,95.46 67.72,97.84 67.3,98.27 58.48,98.27 v2(57.25,99.49) ; RC141.2 83.01,121.85 82.64,121.85 v2(82.52,121.72)
XDP_PRDY#: length 47
  TOP w0.102: v2(74.44,104.64) 74.15,104.93 74.15,106.29 72.54,107.9 72.54,110.9 72.3,111.14 72.3,116.32 76.36,120.37 v1(77.16,120.37) 78.94,120.37 79.68,121.11 83.69,121.11 85.56,122.98 86.2,122.98 86.83,123.61 87.37,123.61 87.66,123.32 v2(87.66,123.14)
  BOTTOM w0.076: UC1.J62 92.06,122.64 91.77,122.35 91.27,122.35 91.27,122.35 90.93,122.35 90.73,122.55 90.73,122.55 90.44,122.84 90.43,122.84 90.38,122.9 88.96,122.9
  BOTTOM w0.102: v2(74.44,104.64) 74.26,104.46 74.26,98.48 73.45,97.68 72.57,97.68 72.2,97.31 JXDP1.5
  BOTTOM w0.109: 88.96,122.9 88.72,123.14 v2(87.66,123.14)
XDP_PREQ#: length 49.4
  TOP w0.102: v2(86.45,122.23) 85.6,121.37 84.49,121.37 83.15,120.03 v1(80.79,120.03) 80.21,120.03 79.87,119.7 76.01,119.7 72.53,116.22 72.53,111.23 72.77,110.99 72.77,107.99 74.73,106.03 v2(74.73,105.17)
  IN3 w0.127: v2(87.14,124.78) 87.14,124.3 86.45,123.62 v2(86.45,122.23)
  BOTTOM w0.076: 86.95,121.73 86.96,121.72 90.62,121.72 90.66,121.69 91.09,121.69 91.35,121.43 91.84,121.43 91.85,121.44 91.85,121.44 UC1.K62
  BOTTOM w0.102: JXDP1.3 72.7,97.29 72.86,97.45 73.55,97.45 74.49,98.39 74.49,103.71 74.84,104.07 74.84,105.05 v2(74.73,105.17) ; 86.95,121.73 v2(86.45,122.23) ; RP44.3 87.06,124.71 v2(87.14,124.78)
XDP_RST#_R: length 2.7
  BOTTOM w0.102: JXDP1.46 62.2,103.31 RC51.2
XDP_TCK: length 27.4
  TOP w0.089: v2(93.37,125.35) 93.18,125.53 91.41,125.53 91.23,125.35 91.23,123.86 91.84,123.25 91.84,121.45 90.72,120.33 87.37,120.33 87.19,120.51 86.76,120.51
  TOP w0.102: RP45.2 75.85,113.91 v4(77.54,115.6) 79.24,117.3 79.24,117.81 80.36,118.93 83.04,118.93 84.62,120.51 86.76,120.51
  BOTTOM w0.076: UC1.E60 93.6,125.11 v2(93.37,125.35)
XDP_TCLK: length 55.9
  IN3 w0.127: v2(77.24,113.65) 76.64,113.65 71.6,108.62 71.6,105.01 70.88,104.29 70.88,101.94 67.88,98.94 67.88,95.15 66.51,93.78 66.51,91.86 v2(66.76,91.62)
  BOTTOM w0.102: v2(77.24,113.65) v1(80.09,113.65) 82.76,113.65 RC59.2 RC65.1 ; JXDP1.57 59.2,93.95 59.1,93.84 RP46.5 59.1,92.27 58.58,91.75 58.58,87.87 60.1,86.35 64.85,86.35 67.26,88.76 67.26,90.94 66.76,91.44 v2(66.76,91.62)
XDP_TDI: length 37.2
  TOP w0.102: v2(87.79,124.83) 87.76,124.83 87.3,124.37 85.97,124.37 85.13,123.54 82.05,123.54 80.87,122.35 77.69,122.35 71.68,116.35 71.68,108.18 v4(72.38,107.48) 72.38,106.6 v2(72.96,106.03)
  BOTTOM w0.076: UC1.F63 91.52,124.01 91.01,124.01 90.66,124.36 90.41,124.36 90.14,124.63
  BOTTOM w0.102: v2(72.96,106.03) 72.92,106.07 UC4.6
  BOTTOM w0.109: 90.14,124.63 89.94,124.83 89.17,124.83 89.01,124.67 87.94,124.67 v2(87.79,124.83) 87.41,125.21 RP44.2
XDP_TDO: length 31
  TOP w0.102: v2(85.67,119.26) 85.29,118.89 84.24,118.89 83.43,118.07 81.98,118.07 81.05,117.15 79.91,117.15 76.18,113.41 RP45.1 74.55,113.41 74.34,113.2 v4(74.34,111.41) 74.34,109.24 v2(73.41,108.31)
  IN3 w0.127: v2(85.67,119.26) 85.67,119.36 88.28,121.97 88.28,123.43 89.28,124.44 v2(89.7,124.44)
  BOTTOM w0.076: v2(89.7,124.44) 90.01,124.44 90.25,124.19 90.6,124.19 90.94,123.85 91.77,123.85 92.06,124.14 UC1.F62
  BOTTOM w0.102: UC4.3 72.91,107.57 73.41,108.06 v2(73.41,108.31)
XDP_TMS: length 51.8
  TOP w0.102: v2(88.05,125.71) v4(87.25,125.71) 86.05,125.71 85.59,125.26 84.44,125.26 83.47,124.28 82.02,124.28 80.57,122.84 72.59,122.84 64.16,114.41 64.16,108.08 65.43,106.81 65.43,105.83 v2(65.79,105.46)
  BOTTOM w0.076: 89.41,125.37 89.79,125.75 90.55,125.75 91.03,125.26 91.79,125.26 91.85,125.2 92.4,125.2 92.67,124.92 UC1.E61
  BOTTOM w0.089: 89.41,125.37 88.94,124.91 88.91,124.91
  BOTTOM w0.102: UC4.8 70.6,105.23 70.45,105.08 70.26,105.08 70.07,105.27 70.07,105.59 69.9,105.76 66.57,105.76 66.27,105.46 v2(65.79,105.46) ; RP44.1 v2(88.05,125.71) 88.2,125.56 88.2,125.12 88.41,124.91 88.91,124.91
XDP_TRST#: length 47.3
  TOP w0.089: v2(93.95,125.39) 93.56,125.78 91.41,125.78 91.05,125.42 91.05,123.79 91.65,123.19 91.65,121.52 90.64,120.51 87.61,120.51 87.38,120.74 86.76,120.74
  TOP w0.102: RP45.3 75.59,114.41 v2(75.66,114.48) 75.66,115.13 75.29,115.5 R2341.1 RC57.1 77.75,116.96 v4(79.28,118.48) 79.95,119.16 82.92,119.16 84.5,120.74 86.76,120.74
  BOTTOM w0.076: UC1.E59 94.25,125.09 v2(93.95,125.39)
  BOTTOM w0.102: UC4.11 68.55,107.07 68.47,106.99 67.58,106.99 67.47,106.87 66.64,106.87 66.25,107.26 66.25,109.84 68.82,112.41 70.04,112.41 71.15,113.53 74.7,113.53 v2(75.66,114.48)
XTAL24_IN: length 18.1
  TOP w0.102: v2(116.26,130.2) 116.54,130.48 116.76,130.48 116.93,130.66 116.93,133.11 116.46,133.58 116.46,135.78 RC12.2 CC6.2 118.01,136.88 117.88,137 116.89,137 116.74,137.15 116.74,138.49 YC2.3 118.21,139.47 RG6.2
  BOTTOM w0.076: v2(116.26,130.2) 116.51,130.45 116.55,130.45 116.69,130.32 116.69,129.24 115.69,128.24 115.69,127.7 UC1.A25
XTAL24_OUT: length 13.5
  TOP w0.102: YC2.1 115.37,137.62 CC7.2 RC12.1 116.23,133.06 v1(116.51,132.79) 116.74,132.55 116.74,130.74 116.68,130.67 116.42,130.67 v2(116.26,130.84)
  BOTTOM w0.076: UC1.B25 115.56,127.16 115.86,127.45 115.86,128.17 116.85,129.17 116.85,130.39 116.62,130.62 116.48,130.62 v2(116.26,130.84)
XTALIN: length 11.6
  BOTTOM w0.102: RG7.2 172.39,100.23 YV1.1 171.4,101.21 CV95.1 171.43,103.19 RV97.1 v1(171.43,105.13) 171.14,105.41 170.44,105.41 169.76,106.09 169.47,106.09 168.47,107.09 168.47,107.7 UV1.AV33
XTALIN_R: length 169.8
  TOP w0.102: v2(174.65,100.4) 172.71,98.45 169.24,98.45 168.34,97.55 v1(168.34,96.89) 168.34,93.07 175.5,85.91 175.5,74.49 177.57,72.42 177.57,65.64 178.32,64.89 v2(178.32,61.36) ; v2(63.9,50.02) 63.61,50.31 CG11.1 RG4.2
  BOTTOM w0.102: v2(178.32,61.36) 178.27,61.41 165.04,61.41 159.89,56.26 135.32,56.26 129.29,50.23 64.41,50.23 64.19,50.02 v2(63.9,50.02) ; RG7.1 174.31,101.15 174.65,100.8 v2(174.65,100.4)
XTALOUT: length 7.6
  BOTTOM w0.102: UV1.AU34 168.24,107.93 168.24,107 169.88,105.36 v1(169.88,105.01) 169.88,104.69 RV97.2 170.54,104.03 CV94.1 170.54,102.27 YV1.3
XTLI: length 7.3
  BOTTOM w0.102: UL1.29 37.55,85.27 37.75,85.07 37.75,83.76 CL36.2 36.77,82.79 YL2.1 35.87,81.81 35.78,81.9 35.3,81.9 v1(35.17,81.78) 35.03,81.64 35.03,80.93 RG8.2
XTLI_R: length 63.8
  TOP w0.102: RG5.2 CG7.1 67.94,41.61 68.29,41.96 v1(68.29,42.53) v2(68.29,43.51)
  IN3 w0.127: v2(35.83,78.84) 35.7,78.72 35.7,61.15 52,44.86 62.26,44.86 62.87,44.25 65.64,44.25 66.37,43.51 v2(68.29,43.51)
  BOTTOM w0.102: RG8.1 35.16,79.52 v2(35.83,78.84)
XTLO: length 6.5
  BOTTOM w0.102: UL1.28 37.95,85.19 38.57,84.56 CL37.2 38.57,83.97 38,83.4 38,81.19 YL2.3
N197804: length 3.2
  BOTTOM w0.102: RV98.1 175.36,95.14 175.68,94.82 v1(176,94.82) 176.29,94.82 176.6,95.13 UV14.4
N14128350: length 2.6
  TOP w0.102: PR1110.2 v1(187.3,171.69)
  TOP w0.254: PR1110.2 188.26,171.73 PU1100.1
N16944150: length 6.6
  TOP w0.102: v1(35.61,116.78) 36.14,116.26 QE4.2 38.58,115.75 38.7,115.64 RE58.1 39.38,115.19 39.53,115.33 JKBBL.2
N16988653: length 2.4
  BOTTOM w0.254: 217.83,91.24 218.09,90.98 v1(218.81,90.98) 219.04,91.22 PU600.3
N16988706: length 2
  BOTTOM w0.102: PR605.2 215.56,95.75 215.41,95.6 215.01,95.6 v1(214.39,96.22)
N17002462: length 5.9
  TOP w0.102: PR1206.1 186.72,181.37 v1(186.25,180.9)
  TOP w0.254: PC1200.1 PR1201.1 185.08,181.68 v2(185.84,182.44) 186.17,182.11 PR1206.1
  BOTTOM w0.254: v2(185.84,182.44) 185.99,182.29 PU1200.1
N17002482: length 7.4
  BOTTOM w0.102: v1(187.27,183.45) 186.88,183.07 185.93,183.07 185.7,182.84 185.67,182.84 185.08,182.25 PR1204.1
  BOTTOM w0.254: PU1200.4 186.21,180.94 185.83,180.56 185.83,180.41 185.26,179.83 PR1211.1 PR1209.1 PR1204.1
N17002518: length 4.7
  BOTTOM w0.254: PR1209.2 v1(182.07,180.72) 181.26,180.72 181.13,180.6 PR1210.1 PR1208.2
N17002625: length 2.6
  TOP w0.102: PR1200.2 v1(190.08,180.22)
  TOP w0.508: PC1210.1 188.69,181.23 PR1200.2
N17045846: length 1
  BOTTOM w0.102: PR802.2 v1(201.39,64.53)
N17045965: length 3.4
  BOTTOM w0.102: PR842.1 208.99,57.11 208.17,56.29 v1(208.04,56.29)
  BOTTOM w0.203: 208.18,57.67 208.18,57.71 207.67,58.22 PU800.28
  BOTTOM w0.254: PR842.1 208.66,57.47 208.39,57.47 208.18,57.67
N17045986: length 11.4
  TOP w0.254: v2(202.59,56.43) 203.52,55.5 v1(203.95,55.5) PR820.1 PC813.2
  BOTTOM w0.203: PU800.7 204.19,56.95 203.99,56.76 203.67,56.76
  BOTTOM w0.254: 203.29,56.38 202.64,56.38 v2(202.59,56.43) 202.25,56.43 201.55,55.73 PC809.2 ; 203.29,56.38 203.37,56.3 PR846.1 203.29,55.67 203.29,54.8 PR813.2 202.44,53.98 PC817.2 ; 203.29,56.38 203.67,56.76
N17046050: length 4.1
  TOP w0.102: PR824.2 200.97,61.76 v1(200.63,62.11)
  TOP w0.254: PR824.2 202.1,61.76 202.52,61.34 v2(202.52,60.52)
  BOTTOM w0.203: v2(202.52,60.52) 202.58,60.52 202.87,60.22 PU800.13
N17046121: length 8.1
  TOP w0.102: v2(205.39,62.28) v1(206.02,62.28)
  IN3 w1.016: 206.28,62.66 206.59,62.66 209.71,65.77 212.5,65.77
  vias: v2(205.39,62.87) v2(215.1,66.04) v2(215.1,65.46) v2(215.27,72.1) v2(215.27,71.51)
N17046167: length 7.1
  TOP w0.254: v2(202.34,58.03) 201.95,58.42 PC816.2 PR833.1
  BOTTOM w0.102: PR845.1 v1(199.27,56.64)
  BOTTOM w0.203: v2(202.34,58.03) 202.54,58.22 PU800.8
  BOTTOM w0.254: PR845.1 PC809.1 201.72,56.64 202.15,57.08 202.15,57.84 v2(202.34,58.03)
N17159315: length 12.5
  TOP w0.102: v1(165.71,119.32) 165.53,119.14 v2(165.21,119.14)
  IN3 w0.102: v2(165.21,119.14) 164.73,118.66 164.36,118.66
  IN3 w0.127: 164.36,118.66 160.68,114.98 160.68,114.54 v2(160.17,114.03)
  BOTTOM w0.102: v2(160.17,114.03) 159.02,114.03 RV84.1 ; v2(165.21,119.14) 165.43,119.35 167.52,119.35 UV1.AB34
N17216117: length 10.1
  TOP w0.102: v1(181.83,104.16) v2(181.83,104.83) 181.64,105.02 RV89.2
  IN3 w0.102: 181.83,105.87 181.83,106.31 180.39,107.75 180.39,111.59 180.62,111.82 v2(180.87,111.82)
  IN3 w0.127: v2(181.83,104.83) 181.83,105.87
  BOTTOM w0.102: UV1.AM17 181.11,111.86 180.91,111.86 v2(180.87,111.82)
N17407779: length 1.9
  TOP w0.102: v1(186.43,33.83) CE12.1 187.42,33.85 R2354.1
N17434554: length 4.5
  TOP w0.102: v1(177.47,47.75) 177.85,47.37 179,47.37 RE36.2 180.35,47.87 180.5,47.72 UE1.107
N17434577: length 9
  TOP w0.102: UE1.66 195.19,54.54 195.75,55.11 v2(196.37,55.11) ; v2(192.14,55.15) 192.05,55.23 RE7.2
  IN3 w0.127: v2(196.37,55.11) 195.84,55.64 192.63,55.64 v2(192.14,55.15)
  BOTTOM w0.102: v1(195.9,56) 196.37,55.53 v2(196.37,55.11)
N17438484: length 4.1
  TOP w0.102: v1(49.09,24.83) 47.15,24.83 CA21.1 46.37,24.69 R2355.2
N17494823: length 1.3
  BOTTOM w0.102: RA3.2 v1(25.62,24.51)
N17607640: length 6.6
  BOTTOM w0.203: PU300.1 145.84,155.64 146.74,154.74 v1(146.74,154.54) 146.74,153.92 147.68,152.98 147.68,152.39 147.95,152.13 PC300.1
  BOTTOM w0.254: PR300.1 PR301.1 PC300.1
N17607660: length 5.9
  BOTTOM w0.102: PR307.1 v1(150.64,157.51)
  BOTTOM w0.254: PU300.4 146.24,156.99 146.58,156.65 PC307.2 PR305.2 149.15,156.65 149.39,156.89 PR307.1
N17608587: length 1.3
  BOTTOM w0.102: PC302.1 v1(149.75,160.06)
N17777752: length 31.9
  TOP w0.102: RV244.1 RV245.1 153.38,117.59 152.9,118.07 152.9,124.8 153.44,125.34 155.48,125.34 155.92,124.89 v1(161.76,124.89) 171.92,124.89 172.91,123.91 v2(172.91,123.23)
  BOTTOM w0.102: UV1.W29 172.26,122.5 UV1.V28 172.46,122.79 v2(172.91,123.23)
N17839157: length 5.9
  TOP w0.102: RV246.1 171.36,112.87 170.91,113.33 v1(170.91,114.14) 170.71,114.33 170.71,115.09 170.65,115.15 170.65,116.82 171.04,117.21 v2(171.2,117.21)
  BOTTOM w0.102: v2(171.2,117.21) 170.86,116.87 UV1.AF30
N17841799: length 10.2
  TOP w0.102: RV247.1 167.62,111.01 v1(167.62,112.8) 167.62,113.11 168.54,114.04 170.07,114.04 170.51,114.48 170.51,114.86 170.09,115.28 170.09,116.86 v2(170.4,117.17)
  BOTTOM w0.102: v2(170.4,117.17) 170.06,116.83 UV1.AF31
N17860472: length 5.8
  BOTTOM w0.102: RV26.2 171.63,141.59 171.16,141.59 v1(170.61,142.14) 169.13,143.63 169.13,144.81 UV4.J13
N18009245: length 4.8
  TOP w0.254: PC717.2 166.83,168.5 v2(166.98,168.65) 166.99,168.65 PU701.1
  BOTTOM w0.102: PR704.1 v1(165.6,167.96)
  BOTTOM w0.254: PR704.1 166.78,168.45 v2(166.98,168.65) 166.4,169.22 PC708.1
N18009258: length 32.5
  TOP w0.254: PC719.1 169.52,175.96 PR710.2 168.56,177.06 PC722.2 168.62,177.18 168.62,178.07 168.14,178.55 163.48,178.55 159.72,182.31 151.87,182.31 v1(150.35,180.79) 149.83,180.27 144.68,180.27 144.05,180.9 144.05,181.09 v2(144.11,181.15)
  BOTTOM w0.254: PR716.3 143.73,181.54 v2(144.11,181.15)
N18009264: length 0.9
  TOP w0.102: v2(145.69,163.67) 146.08,163.67 v1(146.43,163.31)
N18009271: length 5
  TOP w0.254: PC717.1 167.75,168.46 v2(167.56,168.64) 167.49,168.72 PU701.2
  BOTTOM w0.102: PR717.1 v1(169,167.96)
  BOTTOM w0.254: PC707.1 167.41,169.1 167.56,168.96 v2(167.56,168.64) 167.67,168.53 PR717.1
N18009295: length 31.4
  TOP w0.254: v2(143.48,181.09) 143.67,180.9 143.67,180.74 144.52,179.88 150.31,179.88 v1(152.09,181.67) 152.35,181.93 159.56,181.93 163.32,178.17 167.98,178.17 168.24,177.91 168.24,177.66 PC722.1 167.67,177.09 PR708.2
  BOTTOM w0.254: v2(143.48,181.09) 143.48,181.03 143.73,180.77 PR716.2
N18009369: length 2
  TOP w0.254: PR714.2 171.01,172.77 v2(170.72,172.48) 170.17,171.94 PU701.9
N18009411: length 1.5
  BOTTOM w0.102: PR706.1 v1(147.36,187.38)
N18009417: length 1.8
  TOP w0.102: PR722.1 v1(157,180.95)
N18009452: length 4.2
  TOP w0.102: v1(170.2,179.77) 171.34,179.77 PC723.1
  TOP w0.254: PQ708.2 172.13,178.1 PR724.2 PC723.1
N18009461: length 2.3
  TOP w0.254: PU701.8 v2(170.68,171.44) 170.89,171.44 PR715.2
  BOTTOM w0.102: v2(170.68,171.44) v1(170.68,170.91)
N18107051: length 6.2
  BOTTOM w0.102: v1(160.04,109.26) 161.15,109.26 161.73,109.84 RV127.1 163.4,109.84 UV1.AM39
N18262754: length 4.7
  TOP w0.102: RV207.1 v1(167.67,115.54) 168.17,116.05 v2(168.17,117.16)
  BOTTOM w0.102: UV1.AF33 168.17,116.79 v2(168.17,117.16)
N18284053: length 1.2
  TOP w0.102: v2(134.5,169.38) 134.5,169.31 134.04,168.85 v1(134.04,168.35)
N18386761: length 5
  TOP w0.102: UV3.J13 189.62,144.77 189.62,142.78 v1(190.4,142) RV31.2
N18923200: length 2.5
  BOTTOM w0.102: RC10.1 v1(110.7,17.1)
  BOTTOM w0.508: RC10.1 110.7,14.82 DC1.2
N19505504: length 1.1
  TOP w0.089: v2(128.63,113.98) 128.25,114.36 T117.1
  BOTTOM w0.076: UC1.AD4 128.33,114.28 v2(128.63,113.98)
N19607621: length 5
  BOTTOM w0.102: v1(13.9,117.52) 14.18,117.23 QX5.2 15.64,116.36 15.09,115.81 RX15.1
N19636635: length 5.3
  BOTTOM w0.254: QA6.2 15.09,23.36 14.82,23.62 14.82,25.1 v1(15.17,25.44) 15.78,26.05 RA6.2 15.78,26.58 RA7.2
N19792982: length 1.3
  BOTTOM w0.102: RA2.2 23.41,27.82 v1(22.8,27.21)
N19794620: length 6.2
  BOTTOM w0.254: RA5.2 17.62,26.21 v1(19.08,24.75) 19.08,23.93 18.51,23.36 ; QA6.5 18.51,23.36 ; 18.51,23.36 18.51,22.9 18.32,22.71 QA6.6
N20014303: length 4.5
  BOTTOM w0.254: PD1.6 140.56,187.06 140.69,187.19 140.69,187.52 141.07,187.9 PD2.3 141.07,188.72 v1(140.07,188.72) PR17.1
N21178712: length 1.5
  TOP w0.102: PR5.2 v1(132.78,174.93)
N21178859: length 4.3
  TOP w0.254: PC1302.1 194.67,64.05 v1(195.3,63.41) v2(196.29,63.41)
  BOTTOM w0.254: v2(196.29,63.41) 195.81,63.41 195.16,64.07 PU1300.7
N21219517: length 17.3
  TOP w0.102: RV64.2 179.24,106.96 179.25,106.95 v4(179.25,106.45) 179.57,106.13 v2(180.31,105.4)
  IN3 w0.102: 180.01,105.7 179.93,105.78 179.93,106.39 179.71,106.61 179.71,112.14 179.22,112.63 179.22,114.22 180.14,115.14 v2(183.03,115.14)
  IN3 w0.127: 180.01,105.7 v2(180.31,105.4)
  BOTTOM w0.102: v2(183.03,115.14) 182.91,115.14 UV1.AH16
N21220354: length 31.7
  TOP w0.102: RV203.1 164.49,101.59 v1(165.11,102.21) 166.1,103.19 v2(167.64,103.19)
  IN3 w0.102: 164.11,115.36 164.3,115.55 165.44,115.55 166.21,116.31 168.59,116.31 169.25,116.98 169.25,117.52 169.55,117.81 170.05,117.81 171.03,118.79 171.48,118.79 171.92,119.23 171.92,120.18 v2(171.35,120.75)
  IN3 w0.127: v2(167.64,103.19) 167.64,105.03 162.27,110.4 162.27,111.4 163.38,112.51 163.38,114.63 164.11,115.36
  BOTTOM w0.102: v2(171.35,120.75) 171.66,121.06 UV1.Y29
N21246320: length 9.3
  BOTTOM w0.254: PR1211.2 184.05,179.83 183.58,180.3 181.92,180.3 180.81,179.2 v1(178.27,179.2) 177.09,180.38 PQ1201.1
N21246524: length 3.9
  BOTTOM w0.102: v1(174.91,178.42) 175.24,178.76 PR1212.2
  BOTTOM w0.254: PR1212.2 175.24,180.11 175.49,180.37 PQ1201.2 174.35,180.85 PC1214.1
N22321388: length 90.7
  TOP w0.089: v2(129.51,101.17) 128.76,100.42 RE37.2
  TOP w0.102: UE1.82 v1(188.79,54.88) 188.79,55.82 188.26,56.35 v2(188.19,56.35)
  IN1 w0.084: 131.57,99.61 130.92,99.61 130.56,99.96 130.56,100.56 129.95,101.17 v2(129.51,101.17)
  IN1 w0.127: 131.57,99.61 132.54,99.61 136.35,95.8 139.71,95.8 147.62,87.88 149.64,87.88 159.86,77.67 169.49,77.67 174.32,72.83 174.32,66.43 174.87,65.89 174.87,62.75 177.41,60.21 177.41,58.88 177.87,58.42 177.87,56.47 v2(179.16,55.17)
  IN3 w0.127: v2(179.16,55.17) 179.36,55.37 183.34,55.37 184.32,56.35 v2(188.19,56.35)
N22702729: length 2.9
  TOP w0.102: v1(32.42,13.04) LED2.1 RD15.2
N22702890: length 2.8
  TOP w0.102: v1(43.34,13.24) RD16.2 42.22,12.56 LED3.2
N22702897: length 2.8
  TOP w0.102: RD17.2 40.9,13.24 LED3.3 v1(40.03,13.57)
N22703004: length 2.8
  TOP w0.102: LED1.1 24.16,11.94 24.22,11.88 RD14.2 24.91,12.4 v1(25.48,12.97)
N22795339: length 2.2
  TOP w0.102: RD18.2 50.46,13.12 v1(50.43,13.08) LED4.1
N25368131: length 6
  TOP w0.102: UV5.J13 169.11,144.83 169.11,143.33 169.7,142.74 170.48,142.74 v1(171.1,142.12) RV25.2
N25669355: length 5
  BOTTOM w0.102: UV6.J13 189.64,144.75 189.64,142.89 v1(190.15,142.38) 190.15,142.25 RV30.2
N26889205: length 1.7
  TOP w0.102: v2(170.66,120.71) 171.22,121.27 RV198.1
  BOTTOM w0.102: v2(170.66,120.71) 170.86,120.91 UV1.Y30
N32320781:
  vias: v1(138.47,165.69)
N32936693: length 3.6
  TOP w0.102: v1(134.04,170.23) PQ706.1
  TOP w0.254: PQ706.1 135.79,171.69 PR720.2
N39186606: length 2.3
  TOP w0.102: v1(178.01,111.24) 178.4,111.64 v2(178.4,111.88) 178.07,112.21 RV125.1
  BOTTOM w0.102: v2(178.4,111.88) 178.34,111.88 177.91,112.3 UV1.AL21
N39195318: length 2.7
  TOP w0.102: v1(172.24,105.35) 173.11,106.22 RV123.1 173.11,106.86 v2(173,106.98)
  BOTTOM w0.102: v2(173,106.98) 172.66,107.32 UV1.AW28
N39348342: length 5
  BOTTOM w0.102: UV1.AW18 181.28,106.89 182.47,106.89 182.97,106.39 v1(182.97,105.37) 182.97,104.52 RV122.1
N39890903: length 23
  TOP w0.102: v1(195.9,97.01) v2(195.23,97.01) 194.77,97.01 194.35,96.59 CV218.1
  IN3 w0.102: v2(187.65,112.7) 187.2,112.25 187.2,109.44 189.47,107.17 189.47,105.7
  IN3 w0.127: 189.47,105.7 189.47,103.64 190.06,103.05 190.06,100.08 193.13,97.01 v2(195.23,97.01)
  BOTTOM w0.102: UV1.AK10 187.26,113.09 v2(187.65,112.7)
N39890907: length 2.5
  TOP w0.102: RV137.1 CV219.2 192.44,95.27 v1(191.9,95.81)
N39890909: length 2.4
  TOP w0.102: RV136.1 CV218.2 193.43,97.35 v1(193.15,97.64)
N39890911: length 3.7
  TOP w0.102: CV222.1 207.93,101.06 RV144.1 ; CV222.1 v1(209.07,99.81) ; CV222.1 RV143.2
N39890927: length 22.4
  TOP w0.102: v1(190.08,94.82) v2(190.87,94.82) 191.22,94.47 CV219.1
  IN3 w0.102: v2(186.88,112.71) 187,112.59 187,109.36 189.19,107.16 189.19,105.7
  IN3 w0.127: 189.19,105.7 189.19,103.47 189.8,102.86 189.8,99.98 191.03,98.75 191.03,97.65 191.67,97.02 191.67,95.62 v2(190.87,94.82)
  BOTTOM w0.102: UV1.AL10 187.26,112.33 186.89,112.71 v2(186.88,112.71)
