# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_LANRX_P3: length 12.8
  BOTTOM w0.102: UL1.13 37.95,90.59 38.04,90.68 38.04,94.22 38.03,94.24 38.03,94.77 38.04,94.78 38.04,98.02 39.37,99.35 v3(39.37,100.18) 39.37,101.66 CC40.1
PCIE_PTX_LANRX_P3_C: length 95.9
  IN1 w0.084: v2(112.55,129.83) 112.66,129.72 113.04,129.72 113.34,129.41 113.34,127.1 111.67,125.43 95.74,125.43 94.36,124.06 94.36,123.66 94.62,123.4 94.62,122.79 93.77,121.94 92.31,121.94 90.88,120.52 86.79,120.52 86.77,120.49 86.76,120.49
  IN1 w0.127: 86.76,120.49 84.53,120.49 83.52,119.48 74.65,119.48 69.53,114.36 50.63,114.36 46.11,109.84 43.17,109.84 40.03,106.7 40.03,104.83 39.53,104.32 38.62,104.32 v2(38.51,104.21)
  BOTTOM w0.076: UC1.B30 112.57,126.68 112.57,127.41 111.96,128.02 111.96,129.37 112.22,129.62 112.34,129.62 v2(112.55,129.83)
  BOTTOM w0.102: CC40.2 39.27,103.19 39.27,104.2 39.09,104.38 38.68,104.38 v2(38.51,104.21)
PCIE_PTX_WLANRX_N4: length 39.9
  TOP w0.102: CM49.1 107.69,149.48 107.69,149.19 108.72,148.16 116.53,148.16 116.82,148.45 116.82,148.8 v2(116.97,148.95)
  IN3 w0.127: v2(113.97,129.57) 114.05,129.57 114.18,129.69 114.38,129.69 114.8,130.11 114.8,134.94 120.74,140.88 120.74,146.37 119.42,147.69 117.07,147.69 116.81,147.96 116.81,148.79 v2(116.97,148.95)
  BOTTOM w0.076: v2(113.97,129.57) 113.81,129.72 113.47,129.72 113.4,129.64 113.4,128.64 113.51,128.52 113.51,127.46 113.06,127.01 UC1.B29
PCIE_PTX_WLANRX_N4_C: length 2.3
  TOP w0.102: JMINI.31 107.5,151.86 107.78,151.58 107.78,150.98 CM49.2
PCIE_PTX_WLANRX_P4: length 39.8
  TOP w0.102: CM44.1 108.09,149.97 107.99,149.97 107.9,149.87 107.9,149.28 108.81,148.38 116.44,148.38 116.61,148.54 116.61,148.73 v2(116.38,148.95)
  IN3 w0.127: v2(116.38,148.95) 116.55,148.78 116.55,147.85 116.97,147.44 119.32,147.44 120.49,146.27 120.49,140.99 114.54,135.04 114.54,130.22 114.27,129.94 114.1,129.94 113.97,130.07 v2(113.97,130.22)
  BOTTOM w0.076: UC1.A29 113.06,127.57 113.27,127.57 113.35,127.64 113.35,127.82 113.27,127.9 113.17,127.9 113.1,127.98 113.1,128.13 113.17,128.2 113.27,128.2 113.35,128.28 113.35,128.45 113.21,128.6 113.21,129.72 113.39,129.91 113.82,129.91 113.97,130.06 v2(113.97,130.22)
PCIE_PTX_WLANRX_P4_C: length 2.3
  TOP w0.102: CM44.2 108,150.98 108,151.5 108.3,151.81 JMINI.33
PCIE_WAKE#: length 307.6
  TOP w0.089: v2(132.55,110.67) 132.36,110.48 RC97.2
  TOP w0.102: v2(194.84,39.04) 194.39,38.59 UE1.29 ; v2(41.3,87.62) v1(41.3,88.42)
  IN1 w0.084: v2(132.55,110.67) 133.81,109.41 137.89,109.41
  IN1 w0.127: 137.89,109.41 137.93,109.41 138.88,110.35 143.96,110.35 144.37,109.95 146.88,109.95 147.64,109.19 147.64,108.35 152.43,103.56 152.43,103.41 159.96,95.88 159.96,93.42 166.81,86.56 168.96,86.56 169.85,85.68 174.39,85.68 177.83,82.24 179.65,82.24 186.83,75.05 186.83,66.82 188.05,65.6 188.05,57.16 187.51,56.62 187.51,54.28 190.01,51.78 190.01,45.52 v2(190.38,45.15)
  IN3 w0.127: v2(194.84,39.04) 195.53,39.74 196.4,39.74 196.59,39.93 196.59,43.28 195.37,44.5 192.37,44.5 191.72,45.15 v2(190.38,45.15) 189.87,44.64 188.81,44.64 187.2,46.26 185.09,46.26 183.5,44.68 179.35,44.68 178.21,43.53 164.46,43.53 163.31,44.68 69.98,44.68 69.69,44.97 63.14,44.97 62.6,45.51 55.11,45.51 42.76,57.86 42.76,86.16 v2(41.3,87.62)
  BOTTOM w0.102: UL1.21 41.19,87.74 v2(41.3,87.62) 41.49,87.43 RL34.2
PCIE_WAKE#_R: length 5.4
  TOP w0.089: v2(127.84,110.58) 127.94,110.48 128.21,110.48 128.49,110.2 v1(129.84,110.2) 130.28,110.2 130.56,110.48 RC97.1 130.89,110.99 130.9,111 RC34.2
  BOTTOM w0.076: v2(127.84,110.58) 127.84,111.51 UC1.AJ5
PECI_EC: length 214.3
  TOP w0.102: v2(172.17,53.39) 172.17,51.13 172.69,50.61 172.69,48.14 v1(173.54,47.28) 177.08,43.74 RE43.2
  IN3 w0.127: v2(172.17,53.39) 171.5,52.72 117.16,52.72 116.74,53.14 111.89,53.14 111.63,52.89 69.43,52.89 65.88,56.44 65.88,72.32 61.94,76.25 61.94,89.94 60.65,91.23 60.65,98.07 61.36,98.78 61.36,109.85 61.93,110.42 61.93,111.9 69.18,119.15 77.95,119.15 78.69,118.41 85.09,118.41 85.35,118.67 87.28,118.67 v2(87.91,119.31)
  BOTTOM w0.076: UC1.N62 92.3,120.22 92.01,119.93 91.46,119.93 91.43,119.96 91.28,120.11 90.81,120.11 90.52,119.81 88.42,119.81 v2(87.91,119.31)
PECI_KB9012: length 4.4
  TOP w0.102: v1(177.5,43.25) 178.94,43.25 RE43.1 179.75,43.42 180.58,43.42 180.69,43.32 UE1.118
PEG_CLKREQ#: length 95.8
  TOP w0.089: 137.92,114.26 137.04,114.26 136.12,115.18 135.45,115.18 v2(134.84,115.79)
  TOP w0.102: 137.92,114.26 138.13,114.26 139.04,115.18 144.3,115.18 144.87,115.75 RP42.6 ; v2(180.24,90.73) v1(180.93,90.73) 182.08,90.73 183.16,91.81 QV28.1
  IN3 w0.084: 137.92,116.3 135.36,116.3 v2(134.84,115.79) 134.24,116.38 125.44,116.38 125.12,116.7 125.12,118.04 125.55,118.46 126.69,118.46 127.15,118.92 v2(127.24,118.92)
  IN3 w0.127: 137.92,116.3 138.7,116.3 139.18,115.83 140.85,115.83 142.04,117.02 144.18,117.02 144.33,117.17 147.5,117.17 147.68,117.35 150.61,117.35 151.63,116.33 151.63,111.65 155,108.27 159.26,108.27 162.2,105.34 163.16,105.34 164.68,103.81 164.68,102.05 168.78,97.95 172.94,97.95 174.37,96.52 174.37,92.47 176.11,90.73 v2(180.24,90.73)
  BOTTOM w0.089: v2(127.24,118.92) 127.64,118.52 UC1.U5
PEG_CRX_GTX_N0: length 40.5
  TOP w0.102: v2(153.89,122.04) 154.04,121.9 154.04,120.62 155.6,119.06 158.74,119.06 CV44.1
  IN3 w0.084: 137.92,123.49 137.75,123.49 137.73,123.51 137.66,123.51 137.64,123.54 136.9,123.54 134.79,125.64 131.4,125.64 130.71,126.33 128.83,126.33 128.32,125.83 126.73,125.83 125.91,125.01 125.91,124.6 125.37,124.05 v2(125.37,123.92)
  IN3 w0.127: 137.92,123.49 139.15,123.49 139.67,124 150.49,124 152.02,122.48 153.97,122.48 154.05,122.39 154.05,122.21 v2(153.89,122.04)
  BOTTOM w0.089: v2(125.37,123.92) 124.99,124.3 UC1.F10
PEG_CRX_GTX_N1: length 40.6
  TOP w0.102: CV46.1 160.59,120.22 158.76,120.22 158.29,120.69 157.58,120.69 157.43,120.53 157.43,120.38 v2(157.59,120.22)
  IN3 w0.084: v2(126.31,124) 126.42,124.11 126.53,124.11 126.64,124 126.64,123.83 126.98,123.48 134.13,123.48 135.69,121.93 137.55,121.93 137.58,121.91 137.64,121.91 137.66,121.88 137.67,121.88
  IN3 w0.127: v2(157.59,120.22) 157.38,120.01 157.38,119.67 157.08,119.37 155.78,119.37 155.53,119.62 155.53,119.91 155.42,120.02 154.45,120.02 154.32,119.89 154.32,119.51 154.04,119.23 153.42,119.23 153.14,119.51 153.14,119.89 153.01,120.02 152.3,120.02 149.85,122.47 148.27,122.47 148.21,122.41 140.68,122.41 140.15,121.88 137.67,121.88
  BOTTOM w0.089: UC1.F8 126.01,124.3 v2(126.31,124)
PEG_CRX_GTX_N2: length 41.1
  TOP w0.102: CV48.1 158.74,121.41 157.32,121.41 156.98,121.07 155.99,121.07 155.78,121.28 155.78,121.6 v2(155.59,121.78)
  IN3 w0.084: v2(124.42,123.32) 124.43,123.32 124.77,123.66 124.77,123.8 124.98,124.01 124.98,124.91 125.33,125.26 125.33,125.5 126.69,126.86 127.15,126.86 127.64,126.37 128.23,126.37 128.64,126.78 131.34,126.78 131.78,126.34 134.9,126.34 136.45,124.78 137.92,124.78
  IN3 w0.127: v2(155.59,121.78) 155.78,121.97 155.78,122.22 154.74,123.25 153.01,123.25 151.49,124.78 137.92,124.78
  BOTTOM w0.089: UC1.H10 124.74,123 v2(124.42,123.32)
PEG_CRX_GTX_N3: length 39.7
  TOP w0.102: v2(157.14,122.92) 157.37,123.15 157.37,123.53 157.56,123.72 158.48,123.72 159.42,122.78 160.59,122.78 CV50.1
  IN3 w0.084: v2(127.22,124.7) 127.44,124.48 127.7,124.48 128.31,125.08 133.99,125.08 136.16,122.92 137.82,122.92 137.85,122.95 137.92,122.95
  IN3 w0.127: v2(157.14,122.92) 157.3,122.76 157.3,121.35 157.17,121.21 152.54,121.21 150.26,123.5 140.32,123.5 139.77,122.95 137.92,122.95
  BOTTOM w0.089: UC1.E6 126.97,124.95 v2(127.22,124.7)
PEG_CRX_GTX_P0: length 40.3
  TOP w0.102: v2(154.48,122.04) 154.25,121.82 154.25,120.71 155.69,119.28 158.74,119.28 CV43.1
  IN3 w0.084: 137.92,123.75 136.98,123.75 134.88,125.85 131.49,125.85 130.79,126.54 128.74,126.54 128.24,126.04 126.64,126.04 125.7,125.09 125.7,124.68 125.59,124.58 125.47,124.58 v2(125.37,124.68)
  IN3 w0.127: 137.92,123.75 139.05,123.75 139.56,124.26 150.6,124.26 152.12,122.73 154.07,122.73 154.31,122.5 154.31,122.21 v2(154.48,122.04)
  BOTTOM w0.089: UC1.E10 124.82,124.9 125.04,124.68 v2(125.37,124.68)
PEG_CRX_GTX_P1: length 40.7
  TOP w0.102: CV45.1 160.59,120.43 158.85,120.43 158.38,120.9 157.49,120.9 157.21,120.62 157.21,120.43 v2(157.01,120.22)
  IN3 w0.084: 137.67,122.14 135.78,122.14 134.22,123.7 127.07,123.7 126.85,123.91 126.85,124.09 126.61,124.32 126.52,124.32 126.31,124.53 v2(126.31,124.7)
  IN3 w0.127: 137.67,122.14 140.04,122.14 140.57,122.66 148.11,122.66 148.16,122.72 149.95,122.72 152.4,120.27 153.12,120.27 153.39,119.99 153.39,119.62 153.53,119.49 153.93,119.49 154.07,119.62 154.07,119.99 154.34,120.27 155.53,120.27 155.78,120.01 155.78,119.72 155.89,119.62 156.97,119.62 157.13,119.78 157.13,120.09 v2(157.01,120.22)
  BOTTOM w0.089: v2(126.31,124.7) 126.06,124.95 UC1.E8
PEG_CRX_GTX_P2: length 40.9
  TOP w0.102: v2(156.18,121.78) 155.99,121.6 155.99,121.37 156.08,121.28 156.89,121.28 157.23,121.63 158.74,121.63 CV47.1
  IN3 w0.084: v2(124.42,123.94) 124.49,123.94 124.49,123.94 124.61,123.94 124.77,124.1 124.77,125 125.12,125.35 125.12,125.59 126.6,127.07 127.24,127.07 127.73,126.58 128.14,126.58 128.55,126.99 131.43,126.99 131.87,126.55 134.98,126.55 136.54,124.99 137.8,124.99 137.83,125.01 137.89,125.01 137.91,125.03 137.92,125.03
  IN3 w0.127: 137.92,125.03 151.59,125.03 153.11,123.51 154.85,123.51 156.03,122.33 156.03,121.93 v2(156.18,121.78)
  BOTTOM w0.089: v2(124.42,123.94) 124.71,123.65 UC1.G10
PEG_CRX_GTX_P3: length 39.7
  TOP w0.102: CV49.1 160.59,122.57 159.33,122.57 158.39,123.51 157.65,123.51 157.58,123.44 157.58,123.06 v2(157.72,122.92)
  IN3 w0.084: 137.92,122.69 137.84,122.69 137.82,122.71 136.07,122.71 133.91,124.87 128.39,124.87 127.79,124.27 127.42,124.27 v2(127.22,124.07)
  IN3 w0.127: 137.92,122.69 139.88,122.69 140.43,123.24 150.15,123.24 152.44,120.96 157.27,120.96 157.56,121.24 157.56,122.76 v2(157.72,122.92)
  BOTTOM w0.089: v2(127.22,124.07) 126.98,124.3 UC1.F6
PEG_CTX_GRX_C_N0: length 61.2
  IN3 w0.084: v2(119.17,130.87) 119.39,130.65 120.06,130.65 121.94,128.77 124.41,128.77 125.11,129.47 130.64,129.47 130.67,129.5
  IN3 w0.127: 130.67,129.5 133.95,129.5 138.99,134.55 147.3,134.55 153.8,128.04 153.8,127.49 v2(153.97,127.32)
  BOTTOM w0.076: UC1.C23 117.12,126.37 116.98,126.52 116.98,126.64 117.17,126.83 117.17,127.24 117.44,127.51 117.44,128.36 117.68,128.6 117.68,128.96 118.09,129.37 118.09,130.1 118.42,130.43 118.72,130.43 v2(119.17,130.87)
  BOTTOM w0.102: v2(153.97,127.32) 153.77,127.12 153.77,126.71 152.2,125.14 152.2,121.59 154.18,119.61 158.54,119.61 CC18.1
PEG_CTX_GRX_C_N1: length 58.3
  IN3 w0.084: 137.92,127.45 137.91,127.45 137.89,127.42 137.83,127.42 137.8,127.4 136.81,127.4 135.57,128.64 125.3,128.64 124.85,128.2 121.65,128.2 120.11,129.73 118.96,129.73 118.65,130.05 118.65,130.8 118.46,130.99 118.09,130.99 v2(117.95,131.13)
  IN3 w0.127: 137.92,127.45 152.53,127.45 153.23,126.75 154.45,126.75 154.71,126.48 154.71,126.15 v2(154.82,126.05)
  BOTTOM w0.089: UC1.B23 116.89,127.07 116.84,127.19 116.79,127.21 116.75,127.21 116.54,127.42 116.54,127.77 116.98,128.21 116.98,129 117.24,129.25 117.24,130.74 117.48,130.99 117.81,130.99 v2(117.95,131.13)
  BOTTOM w0.102: v2(154.82,126.05) 154.71,125.94 154.71,125.59 152.9,123.78 152.9,121.88 153.64,121.14 160.32,121.14 CC20.1
PEG_CTX_GRX_C_N2: length 47.2
  IN3 w0.084: 137.92,125.55 136.75,125.55 134.95,127.35 125.83,127.35 125.45,126.97 120.9,126.97 119.63,125.7 117.99,125.7 117.57,125.29 v2(117.57,125.27)
  IN3 w0.127: v2(155.15,124.7) 154.94,124.5 154.94,124.21 154.77,124.03 153.33,124.03 151.81,125.55 137.92,125.55
  BOTTOM w0.089: v2(117.57,125.27) 118.01,125.71 UC1.B21
  BOTTOM w0.102: v2(155.15,124.7) 154.96,124.52 154.96,123.69 156.24,122.41 158.54,122.41 CC22.1
PEG_CTX_GRX_C_N3: length 47.6
  IN3 w0.084: 137.92,126.34 136.88,126.34 135.3,127.92 125.68,127.92 125.24,127.48 119.51,127.48 118.69,128.3 118.45,128.3 v2(118.25,128.1)
  IN3 w0.127: v2(156.09,124) 156.23,124.14 156.23,124.62 155.59,125.26 153.28,125.26 152.2,126.34 137.92,126.34
  BOTTOM w0.089: UC1.B22 117.83,126.93 118.33,127.43 118.33,128.02 v2(118.25,128.1)
  BOTTOM w0.102: CC24.1 160.32,124.18 158.26,124.18 157.71,124.74 156.51,124.74 156.26,124.48 156.26,124.17 v2(156.09,124)
PEG_CTX_GRX_C_P0: length 61.1
  IN3 w0.084: 130.75,129.25 130.73,129.25 130.72,129.26 125.19,129.26 124.5,128.56 121.85,128.56 119.97,130.44 119.39,130.44 119.18,130.24 v2(119.17,130.24)
  IN3 w0.127: v2(153.39,127.32) 153.55,127.48 153.55,127.94 147.19,134.29 139.09,134.29 134.05,129.25 130.75,129.25
  BOTTOM w0.076: UC1.C22 117.6,126.39 117.36,126.62 117.36,127.16 117.63,127.43 117.63,128.28 117.87,128.53 117.87,128.88 118.28,129.29 118.28,130.02 118.5,130.24 v2(119.17,130.24)
  BOTTOM w0.102: v2(153.39,127.32) 153.56,127.15 153.56,126.8 151.99,125.23 151.99,121.5 154.09,119.4 158.54,119.4 CC19.1
PEG_CTX_GRX_C_P1: length 57.9
  IN3 w0.084: v2(117.95,130.54) 117.95,130.63 118.1,130.78 118.37,130.78 118.44,130.71 118.44,129.96 118.88,129.52 120.02,129.52 121.56,127.98 124.94,127.98 125.39,128.43 135.48,128.43 136.72,127.19 137.92,127.19
  IN3 w0.127: 137.92,127.19 152.43,127.19 153.12,126.49 154.34,126.49 154.46,126.38 154.46,126.27 v2(154.23,126.05)
  BOTTOM w0.089: UC1.A23 117.03,127.43 116.92,127.38 116.83,127.41 116.74,127.5 116.74,127.68 117.19,128.12 117.19,128.91 117.44,129.17 117.44,130.66 117.57,130.79 117.76,130.79 117.95,130.6 v2(117.95,130.54)
  BOTTOM w0.102: CC21.1 160.32,120.92 153.55,120.92 152.69,121.79 152.69,123.87 154.5,125.68 154.5,125.78 v2(154.23,126.05)
PEG_CTX_GRX_C_P2: length 47.2
  IN3 w0.084: 137.92,125.8 137.89,125.8 137.87,125.78 137.8,125.78 137.78,125.76 136.84,125.76 135.04,127.56 125.74,127.56 125.36,127.18 120.81,127.18 119.54,125.92 118.44,125.92 118.39,125.96 118.39,126.12 118.62,126.35 v2(119.28,126.35)
  IN3 w0.127: 137.92,125.8 151.91,125.8 153.43,124.28 154.66,124.28 154.69,124.31 154.69,124.57 v2(154.56,124.7)
  BOTTOM w0.089: v2(119.28,126.35) 118.71,125.79 UC1.C21
  BOTTOM w0.102: CC23.1 158.54,122.19 156.15,122.19 154.75,123.6 154.75,124.52 v2(154.56,124.7)
PEG_CTX_GRX_C_P3: length 47.6
  IN3 w0.084: 137.92,126.59 137.91,126.59 137.89,126.57 137.83,126.57 137.8,126.55 136.97,126.55 135.39,128.13 125.6,128.13 125.15,127.69 119.6,127.69 118.77,128.52 118.47,128.52 v2(118.25,128.74)
  IN3 w0.127: 137.92,126.59 152.3,126.59 153.38,125.52 155.7,125.52 156.48,124.73 156.48,124.2 v2(156.68,124)
  BOTTOM w0.089: UC1.A21 118.01,127.69 117.82,127.88 117.82,128.21 118.25,128.64 v2(118.25,128.74)
  BOTTOM w0.102: CC25.1 160.32,123.97 158.17,123.97 157.62,124.52 156.6,124.52 156.48,124.39 156.48,124.2 v2(156.68,124)
PEG_CTX_GRX_N0: length 7.1
  BOTTOM w0.102: CC18.2 160.13,119.61 162.68,119.61 v3(163.02,119.96) 163.61,120.55 164.5,120.55 164.77,120.82 165.18,120.82 165.36,121 165.39,121 165.45,121.06 165.82,121.06 UV1.Y37
PEG_CTX_GRX_N1: length 6
  BOTTOM w0.102: UV1.W36 166.62,121.94 166.62,121.81 166.54,121.73 166.38,121.73 166.27,121.83 165.83,121.83 165.79,121.8 165.79,121.8 165.75,121.75 165.58,121.75 165.45,121.88 165.36,121.88 164.55,121.88 164.27,121.6 163.59,121.6 163.13,121.14 v3(162.54,121.14) 161.91,121.14 CC20.2
PEG_CTX_GRX_N2: length 6.7
  BOTTOM w0.102: UV1.V37 165.82,122.66 165.82,122.66 165.47,122.66 165.14,122.33 164.64,122.33 164.56,122.41 164.12,122.41 164.11,122.42 163.47,122.42 163.45,122.41 v3(161.14,122.41) 160.13,122.41 CC22.2
PEG_CTX_GRX_N3: length 6
  BOTTOM w0.102: UV1.U36 166.59,123.58 166.59,123.38 166.53,123.32 166.38,123.32 166.27,123.43 165.85,123.43 165.78,123.36 165.6,123.36 165.56,123.4 165.54,123.4 165.5,123.43 164.51,123.43 164.45,123.38 163.78,123.38 162.97,124.18 162.85,124.18 162.84,124.2 162.31,124.2 162.3,124.18 161.91,124.18 CC24.2
PEG_CTX_GRX_P0: length 7.1
  BOTTOM w0.102: CC19.2 160.13,119.4 162.76,119.4 162.97,119.61 162.99,119.61 163.37,119.98 163.37,120 163.7,120.33 164.59,120.33 164.86,120.6 165.27,120.6 165.45,120.78 165.48,120.78 165.54,120.84 165.76,120.84 165.82,120.78 165.82,120.65 165.67,120.5 UV1.AA38
PEG_CTX_GRX_P1: length 6
  BOTTOM w0.102: UV1.Y35 166.86,121.37 166.72,121.51 166.29,121.51 166.18,121.62 165.92,121.62 165.88,121.58 165.84,121.54 165.49,121.54 165.36,121.67 165.27,121.67 164.64,121.67 164.36,121.38 163.68,121.38 163.22,120.92 162.82,120.92 162.8,120.91 162.27,120.91 162.26,120.92 161.91,120.92 CC21.2
PEG_CTX_GRX_P2: length 6.7
  BOTTOM w0.102: CC23.2 160.13,122.19 160.86,122.19 160.88,122.18 161.41,122.18 161.42,122.19 v3(163.73,122.19) 164.47,122.19 164.55,122.11 165.23,122.11 165.29,122.17 165.56,122.44 165.73,122.44 165.83,122.35 165.83,122.26 UV1.W38
PEG_CTX_GRX_P3: length 6
  BOTTOM w0.102: UV1.V35 166.86,122.96 166.71,123.11 166.29,123.11 166.18,123.22 165.94,123.22 165.87,123.14 165.51,123.14 165.47,123.18 165.45,123.18 165.41,123.22 164.6,123.22 164.54,123.16 163.69,123.16 162.88,123.97 v3(162.58,123.97) 161.91,123.97 CC25.2
PLT_RST#: length 425.3
  TOP w0.102: CE36.1 188.31,36.2 187.99,36.52 UE1.13 187.99,40.31 189.07,41.39 v2(189.07,45.15) ; v2(160.11,110.8) 160.08,110.84 157.28,110.84 156.66,110.22 155.77,110.22 v1(154.29,108.73) 152.75,107.19 151.78,107.19 151.41,107.56 151.41,108.45 150.93,108.93 149.42,108.93 148.89,108.4 148.89,106.94 148.56,106.61 147.35,106.61 147.14,106.4 UC3.4 147.16,105.68 147.16,104.94 R159.1
  IN1 w0.127: v2(103.74,148.76) 104.1,148.4 114.07,148.4 115.48,146.99 125.5,146.99 v2(129.51,142.99)
  IN3 w0.127: v2(129.51,142.99) 130.18,142.32 130.18,137.11 132.19,135.11 147.46,135.11 152.92,129.64 155.83,129.64 159.22,126.26 159.22,120.01 155.47,116.26 155.47,114.88 156.19,114.15 157.5,114.15 159.48,112.18 159.48,111.44 v2(160.11,110.8) ; v2(189.07,45.15) 187.55,46.67 185.09,46.67 183.36,44.94 179.48,44.94 179.47,44.93 179.25,44.93 178.1,43.79 164.56,43.79 163.41,44.94 70.14,44.94 66.97,48.11 55.16,48.11 47.18,56.08 47.18,86.56 v2(43.51,90.24)
  BOTTOM w0.102: UL1.19 40.57,88.54 41.81,89.78 43.05,89.78 v2(43.51,90.24) 55.4,102.12 55.4,106.75 56.48,107.83 60.35,107.83 60.75,108.22 ; v2(160.11,110.8) 159.6,111.31 159.6,111.56 159.41,111.75 UV13.2 ; JMINI.22 103.9,148.92 v2(103.74,148.76) 103.74,148.35 103.39,148.01 85.63,148.01 84.8,147.18 84.8,143.37 83.98,142.55 83.98,141.9 83.1,141.02 83.1,140.64 83,140.54 83,140.53 82.68,140.22 82.68,139.66 82.2,139.18 82.2,139.18 82.2,138.8 81.63,138.23 81.63,136.58 82.2,136.01 82.86,136.01 83.52,135.35 83.52,135.35 84.78,135.35 85.41,134.72 85.41,133.2 86.08,132.53 86.08,128.77 84.67,127.36 84.29,127.36 82.93,126 77.21,126 76.36,125.15 68.1,125.15 66.32,123.37 62.96,123.37 60.75,121.16 60.75,108.22 ; 60.75,108.22 61.59,107.38 61.76,107.38 CC30.1 61.69,106.44 61.69,105.17 61.82,105.03 RC51.1
PM_APWROK_R: length 5.2
  TOP w0.089: v2(127.17,115.99) 127.67,115.5 127.87,115.5 128.66,114.7 v1(129.68,114.7) 130.04,114.7 130.39,114.35 RP50.6
  BOTTOM w0.089: v2(127.17,115.99) 127.64,115.52 UC1.AB5
PROC_OPI_RCOMP: length 6.5
  BOTTOM w0.076: 122.37,102.7 122.37,102.83 122.2,103 122.2,103.19 122.13,103.26 122.13,103.41 122.02,103.51 122.02,104.11 121.74,104.39 121.74,104.86 UC1.AY15
  BOTTOM w0.305: 122.37,102.7 122.37,102.26 122.43,102.2 v1(122.43,101.92) 122.43,100.31 123.39,99.34 RC134.1
PROJECT_ID: length 9.5
  TOP w0.089: RC113.1 RC112.2 133.51,121.34 v2(132.74,122.1) v1(132.74,122.74)
  IN1 w0.084: v2(132.74,122.1) 131.73,122.1 130.84,121.21 127.79,121.21 v2(127.28,120.7)
  BOTTOM w0.089: UC1.L5 127.64,121.06 v2(127.28,120.7)
PS_0: length 14.3
  TOP w0.102: v2(165.66,111.4) v1(164.6,111.4) 163.55,111.4 162.61,112.34 161.8,112.34 161.19,112.95 157.42,112.95 156.87,112.4 RV243.2 CV335.1 RV201.1
  BOTTOM w0.102: v2(165.66,111.4) 165.71,111.35 166.14,111.35 166.36,111.57 166.36,111.63 166.74,112.01 166.99,112.01 167.49,111.5 UV1.AM34
PS_1: length 28.8
  TOP w0.102: v2(167.67,102.53) v1(166.88,102.53) 166.36,102.53 165.91,102.09 165.91,100.55 RV237.2 CV329.1 RV238.1
  IN3 w0.102: v2(169.7,117.14) 169.7,116.95 168.78,116.03 166.69,116.03
  IN3 w0.127: 166.69,116.03 165.69,115.04 164.44,115.04 163.63,114.23 163.63,112.41 162.52,111.3 162.52,110.51 168.24,104.79 168.24,103.11 v2(167.67,102.53)
  BOTTOM w0.102: UV1.AD31 170.06,117.5 v2(169.7,117.14)
PS_2: length 16
  TOP w0.102: RV239.2 RV240.1 160.05,112.2 160.37,112.52 CV331.1 161.05,112.52 161.82,111.75 v1(162.25,111.75) 162.88,111.75 163.84,110.79 165.7,110.79 166.07,111.16 166.07,112.71 168.41,115.06 169.68,115.06 v2(170.06,114.68)
  BOTTOM w0.102: UV1.AG31 170.06,115.3 v2(170.06,114.68)
PS_3: length 15.1
  TOP w0.102: v2(168.83,117.13) 168.83,116.83 168.94,116.72 v1(168.94,116.54) ; v2(162.22,113.02) 161.61,113.63 RV241.2 160.63,113.46 159.59,113.46 CV333.1 RV242.1
  IN3 w0.102: v2(168.83,117.13) 168.15,117.81 166.79,117.81 165.11,116.13 164.11,116.13
  IN3 w0.127: 164.11,116.13 164.07,116.13 162.22,114.29 v2(162.22,113.02)
  BOTTOM w0.102: v2(168.83,117.13) 168.46,117.5 UV1.AD33
PS_ID: length 178.2
  TOP w0.102: v2(132.35,186.63) 132.35,186.45 v1(131.99,186.1) ; v2(189.46,39.56) 189.07,39.17 189.07,38.81 189.19,38.69 UE1.16
  TOP w0.254: PR4.2 PR3.1 v2(132.35,186.63)
  IN2 w0.254: v2(189.46,39.56) 189.58,39.68 189.58,50.41 190.31,51.14 190.31,55.45 189.51,56.25 189.51,76.83 183.54,82.8 183.54,83.82 171.87,95.49 170.41,95.49 163.44,102.47 163.44,103.42 162.29,104.57 161.63,104.57 160.03,106.17 159.14,106.17 155.25,110.07 155.25,112.27 153.17,114.35 153.17,119.53 150.24,122.45 150.24,129.91 139.86,140.29 139.86,141.5 132.71,148.65 132.71,169.69 133.19,170.17 133.19,181.47 132.35,182.31 v2(132.35,186.63)
PSID: length 1.2
  TOP w0.102: v4(139.11,181.69) 139.02,181.78 v2(137.96,181.78)
PSID-1: length 6
  TOP w0.102: v2(133.38,185.47) 133.38,185.79 133.87,186.29 v1(134.42,186.29)
  TOP w0.254: v2(133.38,185.47) 133.38,184.72 PR9.2 PR6.1
  BOTTOM w0.254: PQ5.2 134.54,187.46 133.38,186.3 v2(133.38,185.47)
PSID-2: length 4.3
  TOP w0.102: v2(132.48,189.55) v1(131.93,189.55)
  TOP w0.254: v2(132.48,189.55) 132.55,189.47 PR8.2
  BOTTOM w0.254: PQ6.2 v2(132.48,189.55) 132.64,189.38 PQ5.1
PSID-3: length 3.5
  TOP w0.102: v1(129.32,187.63) PR4.1
  TOP w0.254: PR4.1 130.57,187.07 v2(131.03,186.62)
  BOTTOM w0.254: PQ6.3 131.03,187.59 v2(131.03,186.62)
PWM1: length 50.4
  IN1 w0.254: v2(115.41,140.96) 115.41,146.61 113.95,148.07 88.55,148.07 85.14,144.67 85.14,142.03 84.42,141.31 83.69,141.31 83.43,141.05 83.43,140.43 83.91,139.94 v2(86.13,139.94)
  BOTTOM w0.102: v1(114.2,140.17) 114.99,140.96 v2(115.41,140.96)
  BOTTOM w0.203: PU502.8 115.77,141.64 115.92,141.5 115.92,141.06 115.81,140.96 v2(115.41,140.96) ; PU501.6 86.22,140.03 v2(86.13,139.94)
PWR_PWM_LED#: length 196.7
  TOP w0.102: UE1.92 184.79,54.29 v2(185.18,54.69) ; RD14.1 27.52,11.88 29.11,13.46 32.67,13.46 33.18,12.96 34.26,12.96 36.1,14.8 v1(38.65,14.8) v2(40.54,14.8)
  IN1 w0.127: v2(40.54,14.8) 41.11,15.37 56.83,15.37 63.09,21.64 81.8,21.64 106.31,46.15 133.36,46.15 136.72,42.79 160.27,42.79 166.97,36.08 182.15,36.08 v2(182.57,36.5)
  IN2 w0.127: v2(185.18,54.69) 185.07,54.58 185.07,51.17 182.36,48.46 182.36,36.7 v2(182.57,36.5)
PWR_SRC_ON: length 9.1
  TOP w0.102: QX2.3 229.25,179.65 229.02,179.89 228.47,179.89 CX4.2 RX2.2 RX3.1 226.09,179.45 226.09,179.87 225.68,180.28 222.19,180.28 221.9,179.99 v1(221.89,179.99)
PXS_PWREN: length 464.8
  TOP w0.089: v2(133.38,118.16) 132.86,117.64 RP54.4
  TOP w0.254: v2(211.99,97.02) v1(213.64,95.37) PR601.2 ; PR1103.1 v2(189.89,175.88) ; PR1206.2 186.72,183.58 v2(186.78,183.64)
  IN1 w0.127: v2(211.99,97.02) 209.6,99.4 201.3,99.4 196.3,94.4 190.7,94.4 189.59,95.5 175.14,95.5 v2(174.82,95.18) ; v2(156.3,155.88) 156.3,155.44 159.65,152.09 159.65,139.2 156.18,135.73 156.18,130.95 154.84,129.62 154.84,127.15 155.96,126.04 156.87,126.04 v2(157.45,125.46)
  IN2 w0.254: v2(190.59,166.36) 193.76,166.36 198.82,161.3 208.87,161.3 222.73,147.44 222.73,127.38 221.33,125.97 221.33,106.86 214.72,100.26 214.72,98.62 213.12,97.02 v2(211.99,97.02)
  IN3 w0.084: 137.9,117.93 137.68,117.72 133.82,117.72 v2(133.38,118.16)
  IN3 w0.127: v2(157.45,125.46) 158.95,123.96 158.95,120.12 155.21,116.37 155.21,114.77 156.09,113.89 157.39,113.89 159.22,112.07 159.22,111.33 159.67,110.88 159.67,110.2 160.68,109.19 160.68,109.04 162.04,107.68 163.26,107.68 165.95,105 165.95,101.61 169.1,98.46 173.15,98.46 175.92,95.68 v2(175.92,92.19) ; 137.9,117.93 138.19,118.23 139.28,118.23 139.98,117.53 143.96,117.53 144.26,117.82 146.72,117.82 147.29,118.39 151.23,118.39 155.98,113.64 157.29,113.64 158.96,111.96 158.96,111.23 159.41,110.77 159.41,110.1 160.43,109.09 160.43,108.43 164.6,104.26 164.94,103.92 164.94,102.16 168.89,98.21 173.04,98.21 174.82,96.43 v2(174.82,95.18)
  IN3 w0.254: v2(186.78,183.64) 186.78,182.95 189.89,179.83 v2(189.89,175.88) 190.97,174.8 190.97,166.74 v2(190.59,166.36) 190.67,166.28 190.67,163.81 188.55,161.7 165.14,161.7 158.62,155.17 157.01,155.17 v2(156.3,155.88) ; v2(210.53,57.71) 216.31,57.71 218.74,60.14 218.74,63.71 219.38,64.35 219.38,74.36 216.31,77.44 216.31,86.3 217.06,87.05 217.06,88.62 215.53,90.15 214.6,90.15 212.68,92.08 212.68,96.33 v2(211.99,97.02)
  BOTTOM w0.076: UC1.P4 128.62,119.27 129.04,119.27 129.16,119.14 130.3,119.14 130.39,119.24 131.66,119.24 131.72,119.31
  BOTTOM w0.089: v2(133.38,118.16) 133.63,118.16 133.95,118.48 133.95,119.11 133.7,119.37 131.78,119.37 131.72,119.31
  BOTTOM w0.102: v2(156.3,155.88) 156.3,157.28 160.95,161.93 170.18,161.93 v2(171.58,163.32) 173.51,163.32 175.41,161.42 RV105.2 ; QV25.2 174.82,91.09 v2(175.92,92.19) 176.83,91.28 QV24.2
  BOTTOM w0.254: PR1300.1 198.78,68 199.23,67.55 199.23,66.34 196.82,63.93 196.82,62.88 196.69,62.76 196.69,61.81 197.26,61.24 197.26,56 201.36,51.91 207.2,51.91 210.53,55.23 v2(210.53,57.71) 210.21,58.03 PR803.1
PXS_PWREN#: length 3.7
  BOTTOM w0.102: v1(174.22,95.69) RV109.2 174.36,94.46 QV25.1
RASA0#: length 33.7
  TOP w0.102: UV5.L3 167.09,153.26 v2(167.48,153.65)
  IN3 w0.102: v2(167.48,153.65) 167.87,153.27 167.87,151.84 168.37,151.33 168.37,150.93 169.32,149.98 174.15,149.98 175.49,148.63 175.49,143.49 175.36,143.36 ; v2(176.05,129.21) 176.43,129.59 176.43,132.06 175.83,132.66 175.83,133.43 175.59,133.67 175.59,137.13 175.4,137.32 175.4,137.4
  IN3 w0.157: 175.36,143.36 174.61,142.61 174.61,140.92 175.4,140.13 175.4,137.4
  BOTTOM w0.102: v2(176.05,129.21) 176.34,129.5 UV1.K23 ; v2(167.48,153.65) 167.09,153.26 UV5.L3
RASA1#: length 32.2
  TOP w0.102: UV3.L3 187.6,153.02 187.23,152.66 v2(187.23,151.94)
  IN3 w0.102: 181.32,137.4 181.32,137.05 180.91,136.64 179.78,136.64 179.39,136.25 179.39,135.43 179.25,135.3 179.25,130.3 v2(179.69,129.87) ; 182.13,150.28 182.34,150.48 184.29,150.48 185.32,151.51 186.8,151.51 v2(187.23,151.94)
  IN3 w0.157: 181.32,137.4 181.32,138.05 180.82,138.55 180.82,148.97 182.13,150.28
  BOTTOM w0.102: v2(187.23,151.94) 187.23,152.66 187.6,153.02 UV3.L3 ; UV1.K19 180.05,129.5 v2(179.69,129.87)
RASB0#: length 36.7
  TOP w0.102: v2(213.95,136.32) 213.56,136.71 UV7.L3
  IN3 w0.102: 203.66,128.4 203.75,128.31 208.93,128.31 210.28,129.66 210.28,134.48 211.23,135.43 211.64,135.43 212.14,135.93 213.57,135.93 v2(213.95,136.32) ; v2(187.49,124.26) 187.49,124.52 187.93,124.96 187.93,125.5 188.62,126.19 189.51,126.19 189.98,126.66 191.42,126.66 192.39,127.62 194.39,127.62
  IN3 w0.157: 194.39,127.62 200.52,127.62 201.3,128.4 203.66,128.4
  BOTTOM w0.102: UV7.L3 213.56,136.71 v2(213.95,136.32) ; v2(187.49,124.26) 187.49,124.67 UV1.T10
RASB1#: length 34.7
  TOP w0.102: UV9.L3 213.37,116.31 v2(213.76,115.92)
  IN3 w0.102: 194.39,122.82 194.35,122.82 194.12,122.58 193.25,122.58 193.23,122.61 193.23,122.61 193.06,122.77 191.55,122.77 191.34,122.57 188.36,122.57 v2(187.7,121.9) ; 211.94,121.79 212.56,121.16 212.56,117.12 v2(213.76,115.92)
  IN3 w0.157: 211.94,121.79 209.75,123.98 202.45,123.98 201.29,122.82 194.39,122.82
  BOTTOM w0.102: v2(213.76,115.92) 213.37,116.31 UV9.L3 ; UV1.Y10 187.26,121.47 v2(187.7,121.9)
REGN: length 16.4
  TOP w0.254: v2(170.27,173.28) 170.65,173.66 PR713.1 ; v2(169.07,166.3) PR707.1
  IN1 w0.254: v2(169.07,166.3) 167.99,166.3 166.34,167.95 166.34,171.88 v2(165.45,172.77)
  IN3 w0.254: v2(165.45,172.77) 165.64,172.58 169.57,172.58 v2(170.27,173.28)
  BOTTOM w0.102: v2(165.45,172.77) v1(166.12,172.77)
RF_+1.2VSP: length 2.6
  TOP w0.254: PU1100.5 188.73,175.3 188.9,175.46 v2(189.13,175.46)
  BOTTOM w0.102: v1(189.39,175.96) 189.13,175.71 v2(189.13,175.46)
  BOTTOM w0.254: v2(189.13,175.46) 188.78,175.82 PR1105.1
RING2: length 20.5
  TOP w0.102: v1(24.1,23.31) 23.52,23.88 v2(23.21,23.88)
  IN3 w1.016: 24.35,24.32 24.35,25.85 26.19,27.69 29.18,27.69 29.87,28.39 35.08,28.39 36.86,30.17 40.41,30.17
  vias: v2(23.21,24.46) v2(40.1,29.28) v2(40.07,28.69)
RING2_R: length 26.2
  TOP w1.016: JHP.3 5.04,8.58 13.68,8.58 14.57,9.46 14.57,19.67 v1(15.9,21) 16.6,21.71 16.6,22.93
RREF: length 2.3
  TOP w0.305: RR1.1 175.03,21.25 v1(175.49,21.7) 175.82,22.03 UR1.1
RSVD_AL1: length 1.6
  BOTTOM w0.076: UC1.AL1 131.46,110.61 T136.1
RSVD_AM11: length 1.3
  TOP w0.089: T137.1 123.39,109.49 v2(123.66,109.49)
  BOTTOM w0.076: v2(123.66,109.49) 123.73,109.49 UC1.AM11
RSVD_AP7: length 14.3
  TOP w0.089: 132.85,103.45 132.24,104.07 129.98,104.07 126.2,107.84 126.2,108.23 v2(125.59,108.84)
  TOP w0.102: T139.1 134.62,101.68 132.85,103.45
  BOTTOM w0.089: UC1.AP7 v2(125.59,108.84)
RSVD_AT2: length 5.7
  BOTTOM w0.076: T128.1 134.96,107.37 131.19,107.37 130.65,107.9 129.91,107.9 129.63,107.62 UC1.AT2
RSVD_AU10: length 9.8
  TOP w0.089: T141.1 124.65,101.03 124.49,101.03 122.88,102.64 122.88,106.46 123.41,106.99 124.55,106.99 v2(125,106.54)
  BOTTOM w0.076: v2(125,106.54) 124.64,106.89 UC1.AU10
RSVD_AU15: length 6.4
  TOP w0.089: v2(123.53,106.56) 123.09,106.12 123.09,103.69 T142.1
  BOTTOM w0.076: UC1.AU15 121.68,106.89 122,107.21 123.33,107.21 123.53,107.01 v2(123.53,106.56)
RSVD_AU44: length 5.1
  BOTTOM w0.076: UC1.AU44 102.94,106.75 102.94,106.68 102.67,106.42 102.67,101.94 T132.1
RSVD_AV44: length 6
  BOTTOM w0.076: UC1.AV44 102.84,105.95 102.84,103.62 103.53,102.92 103.86,102.92 104.55,102.24 105.5,102.24 T134.1
RSVD_AW14: length 6.1
  BOTTOM w0.076: UC1.AW14 122.11,105.3 122.11,104.82 122.62,104.32 122.62,103.67 123.44,102.85 123.44,101.73 124.27,100.89 T144.1
RSVD_AY14: length 3.8
  BOTTOM w0.076: T145.1 124.23,102.29 122.78,103.74 122.78,104.43 122.41,104.81 UC1.AY14
RSVD_D15: length 3
  TOP w0.089: T135.1 122.14,127.79 122.14,126.64 v2(121.85,126.34)
  BOTTOM w0.076: v2(121.85,126.34) UC1.D15
RSVD_F22: length 1.3
  TOP w0.089: v2(118.19,124.29) 118.08,124.41 T138.1
  BOTTOM w0.089: UC1.F22 117.97,124.51 v2(118.19,124.29)
RSVD_H22: length 1.5
  TOP w0.089: v2(118.19,123.07) 117.64,123.62 T140.1
  BOTTOM w0.089: v2(118.19,123.07) 118.11,122.99 UC1.H22
RSVD_J21: length 1.6
  TOP w0.089: v2(118.09,121.73) 118.48,121.34 T143.1
  BOTTOM w0.076: UC1.J21 118.18,121.83 v2(118.09,121.73)
RSVD_N23: length 1.9
  TOP w0.109: v2(116.14,120.55) 115.96,120.55 T129.1
  BOTTOM w0.076: v2(116.14,120.55) 116.55,120.15 UC1.N23
RSVD_R23: length 4.4
  TOP w0.089: T130.1 114.93,118.77 115.89,119.74 v2(116.14,119.74)
  BOTTOM w0.076: v2(116.14,119.74) 116.55,119.33 UC1.R23
RSVD_T23: length 8.2
  TOP w0.089: v2(116.14,118.93) 116.14,118.78 115.22,117.86 111.08,117.86 T131.1
  BOTTOM w0.076: UC1.T23 116.55,118.52 v2(116.14,118.93)
RSVD_U10: length 3.7
  TOP w0.089: T133.1 124.54,119.47 123.9,118.83 v2(123.84,118.83)
  BOTTOM w0.089: v2(123.84,118.83) 123.78,118.77 123.78,118.13 123.97,117.94 124.47,117.94 124.8,118.27 UC1.U10
RTC_VOUT: length 4.9
  TOP w0.102: UG1.14 62.72,47 62.14,47.58 CG6.1 RG2.2 v4(59.54,48.52)
RUNPWROK: length 224.8
  TOP w0.203: UE1.36 196.31,40.52 196.18,40.64 195.72,40.64 195.37,40.29 v2(195.37,40.12)
  TOP w0.254: v2(70.96,109.4) 70.5,109.86 v1(70.02,109.86) 69.45,109.86 v2(68.24,108.65) 68.24,107.88 68.42,107.7 v2(68.42,106.57)
  IN1 w0.254: v2(192.5,61.72) 192.5,60 194.88,57.62 194.88,56.42 195.72,55.58 195.72,54.93 196.73,53.92 196.73,47.78 195.37,46.42 v2(195.37,40.12) ; v2(68.42,106.57) 72,106.57 72.34,106.91 v2(72.94,106.91)
  IN3 w0.254: v2(70.96,109.4) 70.24,108.68 70.24,106.17 70.48,105.93 70.48,104.71 70.31,104.54 70.31,102.21 65.92,97.82 65.92,93.82 65,92.9 65,90.75 65.68,90.07 65.68,80.37 70.45,75.6 70.45,74.35 72.82,71.98 72.82,59.22 75.48,56.56 111.6,56.56 112.28,57.23 116.23,57.23 116.91,56.56 171.59,56.56 172.19,55.96 175.01,55.96 177.77,58.71 180.47,58.71 185.24,63.48 185.24,64.37 185.56,64.7 189.53,64.7 v2(192.5,61.72)
  BOTTOM w0.254: CC29.1 68.18,108.59 v2(68.24,108.65) 68.83,108.07 UC4.13 ; UC4.10 v2(68.42,106.57) ; UC4.1 71.1,109.26 v2(70.96,109.4) ; v2(72.94,106.91) 72.86,106.91 72.7,107.07 UC4.4
SATA_ACT#: length 215.3
  TOP w0.102: v1(33.67,73.87) 33.24,73.43 v2(33.24,73.15) ; RD15.1 v2(35.03,12.63)
  IN2 w0.089: v2(132.87,118.78) 132.87,118.01 133.37,117.5 133.37,116.73 132.8,116.16 131.74,116.16 131.28,115.7 131.28,115.13 131.66,114.75 133.44,114.75 133.82,114.37 133.82,113.95 133.35,113.48 133.35,112.56 131.63,110.83 131.63,109.75 130.33,108.46 130.33,102.6 129.95,102.22 128.3,102.22 124.68,98.6 124.41,98.6 121.43,95.62
  IN2 w0.127: 121.43,95.62 112.98,87.17 58.13,87.17 44.79,73.84 33.92,73.84 v2(33.24,73.15)
  IN3 w0.127: v2(33.24,73.15) 33.24,61.61 44.72,50.12 44.72,33.26 50.83,27.16 50.83,22.01 42.47,13.66 36.99,13.66 35.96,12.63 v2(35.03,12.63)
  BOTTOM w0.076: v2(132.87,118.78) 132.52,119.13 132.04,119.13 131.18,118.27 130.53,118.27 130.4,118.39 130.16,118.39 129.99,118.22 129.99,118.05 129.75,117.81 129.23,117.81 UC1.U3
SATA_IREF: length 5.1
  BOTTOM w0.254: UC1.A12 123.16,128.76
  BOTTOM w0.305: RC126.1 123.35,130.86 123.16,130.68 v1(123.16,130.48) 123.16,128.76
SATA_PRX_DTX_N0: length 6.2
  TOP w0.102: CS109.1 224.72,32.14 225.22,32.14 v3(225.46,32.38) 225.77,32.69 225.77,33.28 226.05,33.56 226.07,33.56 226.53,34.01 226.53,34.03 226.7,34.2 228.57,34.2 JHDD.5
SATA_PRX_DTX_N0_C: length 156.4
  TOP w0.102: CS109.2 223.14,32.14 222.76,32.14 222.27,32.63 222.27,36.36 223.21,37.3 223.21,41.38 222.1,42.48 219.1,42.48 v2(218.91,42.3)
  IN1 w0.084: 137.92,123.5 137.88,123.54 135.52,123.54 134.7,122.73 131.94,122.73 131.57,122.35 127.5,122.35 v2(127.19,122.05)
  IN1 w0.127: 137.92,123.5 143.74,123.5 151.07,116.17 151.07,115.28 154.79,111.56 154.79,109.21 156.11,107.88 156.11,105.15 170.06,91.21 174.43,91.21 179.47,86.17 184.61,86.17 191.57,79.22 191.57,68.56 192.62,67.5 192.62,64.42 193.43,63.62 193.43,60.05 195.58,57.91 195.58,56.71 197.45,54.84 197.66,54.84 210.04,42.45 218.76,42.45 v2(218.91,42.3)
  BOTTOM w0.076: UC1.J5 127.57,122.35 127.27,122.05 v2(127.19,122.05)
SATA_PRX_DTX_N1: length 3.1
  BOTTOM w0.102: CS14.1 225.15,108.78 225.26,108.78 225.42,108.94 226,108.94 226.29,109.23 JBTB.5 JBTB1.7
SATA_PRX_DTX_N1_C: length 129.1
  IN1 w0.084: 137.92,125.67 132.42,125.67 131.82,126.27 128.09,126.27 127.59,125.77 126.79,125.77 125.94,124.92 125.94,123.49 125.82,123.37 125.82,123.12 v2(125.37,122.67)
  IN1 w0.127: v2(220.69,104.71) 220.49,104.51 220.49,104.23 216.01,99.75 215.22,99.75 213.96,98.49 213.96,97.73 208.51,92.28 185.63,92.28 185.41,92.06 182.57,92.06 182.14,92.49 177.95,92.49 177.16,93.28 170.49,93.28 162.47,101.3 162.47,102.52 159.59,105.41 159.59,106.62 157.05,109.16 157.05,110.12 156.6,110.57 156.6,112.03 152.86,115.78 152.86,116.64 143.82,125.67 137.92,125.67
  BOTTOM w0.089: v2(125.37,122.67) 125.69,122.35 UC1.J8
  BOTTOM w0.102: CS14.2 223.64,108.95 223.19,108.95 222.95,108.71 222.95,105.82 221.34,104.21 220.78,104.21 220.69,104.3 v2(220.69,104.71)
SATA_PRX_DTX_P0: length 6.2
  TOP w0.102: JHDD.6 228.47,34.42 226.61,34.42 v3(226.11,33.92) 225.56,33.37 225.56,32.8 225.11,32.35 224.72,32.35 CS108.1
SATA_PRX_DTX_P0_C: length 156.3
  TOP w0.102: v2(218.91,42.88) 219.09,42.7 222.19,42.7 223.42,41.47 223.42,37.21 222.48,36.27 222.48,32.72 222.85,32.35 223.14,32.35 CS108.2
  IN1 w0.084: 137.92,123.77 135.42,123.77 134.61,122.96 131.84,122.96 131.47,122.58 127.33,122.58 v2(127.22,122.7)
  IN1 w0.127: 137.92,123.77 143.85,123.77 151.34,116.28 151.34,115.39 155.06,111.67 155.06,109.32 156.38,107.99 156.38,105.27 170.17,91.48 174.54,91.48 179.58,86.45 184.72,86.45 191.84,79.33 191.84,68.67 192.9,67.61 192.9,64.54 193.7,63.73 193.7,60.16 195.85,58.02 195.85,56.82 197.56,55.11 197.77,55.11 210.15,42.72 218.76,42.72 v2(218.91,42.88)
  BOTTOM w0.076: UC1.H5 127.59,123 127.28,122.7 v2(127.22,122.7)
SATA_PRX_DTX_P1: length 3.1
  BOTTOM w0.102: CS15.1 225.06,108.56 225.35,108.56 225.51,108.72 226,108.72 226.29,108.43 JBTB.3 JBTB1.9
SATA_PRX_DTX_P1_C: length 128.9
  IN1 w0.084: v2(125.37,123.33) 125.45,123.33 125.74,123.61 125.74,125.04 126.7,126 127.5,126 127.99,126.5 131.91,126.5 132.51,125.9 137.8,125.9 137.82,125.92 137.89,125.92 137.91,125.94 137.92,125.94
  IN1 w0.127: v2(220.1,104.71) 220.22,104.59 220.22,104.34 215.9,100.02 215.1,100.02 213.69,98.6 213.69,97.84 208.4,92.55 185.51,92.55 185.29,92.33 182.68,92.33 182.25,92.76 178.06,92.76 177.28,93.55 170.61,93.55 162.75,101.41 162.75,102.64 159.87,105.52 159.87,106.73 157.32,109.28 157.32,110.24 156.87,110.68 156.87,112.14 153.13,115.89 153.13,116.75 143.94,125.94 137.92,125.94
  BOTTOM w0.089: UC1.H8 125.7,123 v2(125.37,123.33)
  BOTTOM w0.102: CS15.2 223.39,108.73 223.28,108.73 223.17,108.62 223.17,105.73 221.43,103.99 220.69,103.99 220.47,104.21 220.47,104.34 v2(220.1,104.71)
SATA_PTX_DRX_N0: length 5
  TOP w0.102: CS106.1 224.69,30.61 225.14,30.61 225.15,30.62 225.68,30.62 225.69,30.61 v3(227.54,30.61) 228.47,30.61 JHDD.3
SATA_PTX_DRX_N0_C: length 179.7
  TOP w0.102: CS106.2 223.11,30.55 222.65,30.55 221.78,31.41 221.78,36.78 222.72,37.72 222.72,41.15 222.09,41.79 221.46,41.79 v2(221.26,41.98)
  IN1 w0.084: v2(121.72,129.57) 121.52,129.76 120.32,129.76 119.31,128.75 119.31,128.27 120.01,127.57 121.63,127.57 122.19,127.02 124.61,127.02 124.97,126.66 124.97,122.46 125.17,122.26 125.85,122.26 127.25,123.66 133.63,123.66 134.89,124.92 137.89,124.92 137.91,124.95 137.92,124.95
  IN1 w0.127: 137.92,124.95 143.78,124.95 152.16,116.57 152.16,115.74 155.86,112.04 155.86,109.62 157.16,108.32 157.16,105.68 170.58,92.26 174.87,92.26 179.9,87.22 186.47,87.22 192.65,81.04 192.65,68.98 193.68,67.94 193.68,65.3 194.52,64.47 194.52,61.28 197.16,58.64 197.16,56.82 209.14,44.84 219,44.84 220.44,43.4 220.44,42.13 220.7,41.87 221.15,41.87 v2(221.26,41.98)
  BOTTOM w0.076: v2(121.72,129.57) 121.72,129.76 121.62,129.86 121.42,129.86 121.31,129.75 121.31,128.23 121.52,128.03 121.52,127.8 121.63,127.69 121.63,127.45 121.1,126.93 UC1.B15
SATA_PTX_DRX_N1: length 12.5
  BOTTOM w0.102: CS9.1 225.1,103.38 225.64,103.38 225.9,103.63 v3(225.9,104) 225.9,105.63 225.91,105.64 225.91,106.17 225.9,106.19 225.9,106.63 226.05,106.78 229.04,106.78 230.97,108.72 231.65,108.72 231.95,108.43 JBTB1.10 JBTB.4
SATA_PTX_DRX_N1_C: length 130.9
  IN1 w0.084: v2(120.36,128.52) 120.21,128.67 120.21,128.81 120.29,128.9 121.2,128.9 122.64,127.46 134.26,127.46 135.18,126.54 137.92,126.54
  IN1 w0.127: v2(210.59,96.13) 210.37,95.91 210.37,95.33 208.17,93.13 190.42,93.13 189.73,93.81 183.05,93.81 182.51,93.27 178.93,93.27 178.14,94.06 170.82,94.06 163.38,101.49 163.38,102.75 160.37,105.76 160.37,107.3 158.13,109.54 158.13,112.56 153.91,116.78 153.91,118.45 145.83,126.54 137.92,126.54
  BOTTOM w0.089: UC1.A17 120.58,127.39 120.48,127.28 120.32,127.28 120.2,127.4 120.2,128.36 v2(120.36,128.52)
  BOTTOM w0.102: v2(210.59,96.13) 210.39,96.32 210.39,96.62 211.42,97.65 212.44,97.65 217.53,102.74 222.13,102.74 222.93,103.53 223.29,103.53 CS9.2
SATA_PTX_DRX_P0: length 5
  TOP w0.102: JHDD.2 228.57,30.39 227.85,30.39 227.84,30.38 227.27,30.38 227.26,30.39 v3(225.42,30.39) 224.76,30.39 CS105.1
SATA_PTX_DRX_P0_C: length 179.4
  TOP w0.102: v2(221.26,41.4) 221.44,41.57 222,41.57 222.51,41.06 222.51,37.81 221.57,36.87 221.57,31.32 222.56,30.33 223.17,30.33 CS105.2
  IN1 w0.084: v2(121.72,130.22) 121.43,129.93 120.25,129.93 119.14,128.83 119.14,128.2 119.94,127.4 121.56,127.4 122.11,126.85 124.54,126.85 124.8,126.59 124.8,122.39 125.1,122.09 126.01,122.09 127.35,123.43 133.72,123.43 134.99,124.69 137.89,124.69 137.91,124.67 137.92,124.67
  IN1 w0.127: v2(221.26,41.4) 221.07,41.59 220.59,41.59 220.17,42.01 220.17,43.29 218.89,44.57 209.03,44.57 196.88,56.71 196.88,58.53 194.24,61.17 194.24,64.35 193.41,65.19 193.41,67.83 192.38,68.87 192.38,80.93 186.36,86.95 179.79,86.95 174.75,91.99 170.47,91.99 156.89,105.57 156.89,108.2 155.59,109.51 155.59,111.93 151.88,115.63 151.88,116.46 143.67,124.67 137.92,124.67
  BOTTOM w0.076: UC1.A15 121.33,127.72 121.32,127.72 121.32,127.95 121.12,128.15 121.12,129.83 121.34,130.05 121.55,130.05 v2(121.72,130.22)
SATA_PTX_DRX_P1: length 12.5
  BOTTOM w0.102: CS8.1 225,103.6 225.55,103.6 225.67,103.71 225.67,104.27 225.68,104.28 v3(225.68,105.91) 225.68,106.72 225.96,107 228.95,107 230.88,108.94 231.65,108.94 231.95,109.23 JBTB1.8 JBTB.6
SATA_PTX_DRX_P1_C: length 130.9
  IN1 w0.084: v2(119.78,128.39) 119.98,128.59 119.98,128.91 120.2,129.13 121.29,129.13 122.73,127.69 134.36,127.69 135.28,126.77 137.81,126.77 137.83,126.79 137.89,126.79 137.91,126.81 137.92,126.81
  IN1 w0.127: 137.92,126.81 145.94,126.81 154.19,118.56 154.19,116.89 158.4,112.67 158.4,109.65 160.65,107.41 160.65,105.87 163.66,102.86 163.66,101.6 170.93,94.33 178.25,94.33 179.04,93.54 182.4,93.54 182.94,94.08 189.84,94.08 190.53,93.4 208.05,93.4 210.1,95.44 210.1,96.03 v2(210,96.13)
  BOTTOM w0.089: UC1.B17 120.23,127.09 120,127.32 120,128.17 v2(119.78,128.39)
  BOTTOM w0.102: CS8.2 223.65,103.75 222.84,103.75 222.05,102.96 217.44,102.96 212.35,97.87 211.33,97.87 210.18,96.71 210.18,96.3 v2(210,96.13)
SATA_RCOMP: length 6.8
  BOTTOM w0.203: 123.56,128.6 123.56,127.43 123.18,127.06 123.18,126.4 UC1.C12
  BOTTOM w0.305: 123.56,128.6 123.56,130.34 124.43,131.21 v1(124.43,131.51) RC131.1
SD_CD#: length 11.8
  TOP w0.102: CR9.1 179.49,28.63 179.2,28.34 179.2,28.02 v1(179.09,27.9) 178.81,27.63 v2(178.61,27.63) 178.32,27.33 UR1.13
  BOTTOM w0.102: JREAD.20 171.71,26.71 172.3,27.31 174.97,27.31 176.43,28.77 177.47,28.77 v2(178.61,27.63)
SD_CMD: length 27.8
  TOP w0.102: v2(186.91,29.02) 186.67,29.26 185.98,29.26 185.88,29.16 185.88,28.17 185.78,28.07 185.57,28.07 185.47,28.17 185.47,29.16 185.37,29.26 185.17,29.26 185.07,29.16 185.07,27.73 184.96,27.62 184.76,27.62 184.66,27.73 184.66,29.16 184.56,29.26 184.35,29.26 184.25,29.16 v1(184.25,28.74) 184.25,27.73 184.15,27.62 183.95,27.62 183.85,27.73 183.85,29.16 183.75,29.26 181.93,29.26 181.83,29.36 181.83,30.47 181.73,30.57 177.12,30.57 175.71,29.15 175.57,29.15 CR11.1 175.16,27.66 175.29,27.53 175.68,27.53 175.82,27.4 UR1.18
  BOTTOM w0.102: JREAD.6 v2(186.91,29.02)
SD_D0: length 27.9
  TOP w0.102: UR1.11 180.28,25.57 180.74,25.11 181.34,25.11 181.44,25.01 181.44,24.57 181.56,24.45 181.72,24.45 181.84,24.57 181.84,25.01 181.94,25.11 182.15,25.11 182.25,25.01 182.25,24.54 182.37,24.42 182.54,24.42 182.66,24.54 182.66,25.01 182.76,25.11 182.96,25.11 183.06,25.01 183.06,24.54 183.18,24.42 183.35,24.42 183.47,24.54 183.47,25.01 183.57,25.11 183.77,25.11 183.88,25.01 183.88,24.82 183.99,24.7 184.16,24.7 184.28,24.82 184.28,25.01 184.38,25.11 185.68,25.11 185.78,25.21 185.78,25.47 185.68,25.57 v1(182.16,25.57) v2(180.89,25.57)
  BOTTOM w0.102: JREAD.18 174.75,26.94 174.85,27.04 175.47,27.04 175.57,26.94 175.57,23.6 175.67,23.5 177.74,23.5 178.69,24.45 180.18,24.45 180.5,24.77 180.5,25.18 v2(180.89,25.57)
SD_D1: length 27.9
  TOP w0.102: v2(180.89,24.64) 180.46,25.07 v1(180.24,25.07) UR1.10
  BOTTOM w0.102: JREAD.19 172.47,26.98 172.57,27.08 173.23,27.08 173.33,26.98 173.33,24.07 173.43,23.97 173.65,23.97 173.75,24.07 173.75,26.98 173.85,27.08 174.06,27.08 174.16,26.98 174.16,23.37 174.26,23.27 174.46,23.27 174.57,23.37 174.57,24.08 174.67,24.18 175.14,24.18 175.24,24.08 175.24,23.37 175.34,23.27 178.29,23.27 178.39,23.37 178.39,23.6 178.49,23.7 178.69,23.7 178.8,23.6 178.8,23.37 178.9,23.27 179.1,23.27 179.2,23.37 179.2,24.06 179.3,24.16 179.51,24.16 179.61,24.06 179.61,23.37 179.71,23.27 179.91,23.27 180.01,23.37 180.01,24.03 180.12,24.13 180.32,24.13 180.42,24.03 180.42,23.37 180.52,23.27 180.73,23.27 180.89,23.43 v2(180.89,24.64)
SD_D2: length 28
  TOP w0.102: UR1.21 174.62,25.07 174.12,25.57 174.12,29.75 175.44,31.07 178.82,31.07 v2(179.27,31.53)
  BOTTOM w0.102: JREAD.1 191.47,28.85 188.42,31.9 v1(186.44,31.9) 179.65,31.9 v2(179.27,31.53)
SERIRQ: length 138.7
  TOP w0.102: UE1.3 183.99,38.91 184.13,39.05 184.13,43.75 184.95,44.57 187.73,44.57 188.75,45.59 v2(193.4,45.59)
  IN1 w0.127: v2(146.43,118.39) 146.43,117.89 153.9,110.42 153.9,107.58 154.97,106.5 154.97,104.68 165.5,94.15 165.5,92.35 167.78,90.06 173.96,90.06 178.99,85.03 183.01,85.03 190.06,77.98 190.06,67.95 191.13,66.87 191.13,59.84 192.62,58.34 192.62,57.32 193.8,56.14 193.8,55.97 194.06,55.71 194.06,52.62 193.86,52.42 193.86,46.05 v2(193.4,45.59)
  IN3 w0.084: 137.63,119.13 134.24,119.13 133.69,119.69 130.77,119.69 130.19,119.11 129.28,119.11 v2(128.65,118.49)
  IN3 w0.127: v2(146.43,118.39) 146.29,118.26 144.33,118.26 143.92,117.85 142.2,117.85 141.31,118.74 139.67,118.74 139.28,119.13 137.63,119.13
  BOTTOM w0.076: v2(128.65,118.49) 128.33,118.82 UC1.T4
  BOTTOM w0.102: RC102.2 146.43,120.01 v1(146.43,119.59) v2(146.43,118.39)
SIO_EXT_SCI#: length 2.6
  TOP w0.089: v2(127.92,120.7) 128.54,121.32 RC98.1 127.6,121.46 v1(127.54,121.4)
  BOTTOM w0.089: UC1.N5 127.64,120.43 v2(127.92,120.7)
SIO_SLP_S0#: length 105.1
  TOP w0.102: v2(170.08,97.53) 170.08,97.25 169.57,96.74 v1(169.57,94.31) 169.57,92.83 175.91,86.49 175.91,74.73 178.04,72.6 178.04,66.25 178.99,65.3 178.99,60.74 181.32,58.41 183.86,58.41 185.32,56.95 185.32,55.17 185.99,54.51 UE1.89
  IN3 w0.084: 137.82,109.78 136.24,109.78 135.77,110.25 133.23,110.25 133.04,110.44 133.04,111.25 133.38,111.6 v2(133.38,114.03)
  IN3 w0.127: v2(170.08,97.53) 169.92,97.69 168.69,97.69 164.29,102.09 164.29,102.87 159.15,108.01 154.9,108.01 152.49,110.42 149.63,110.42 149.23,110.01 138.43,110.01 138.2,109.78 137.82,109.78
  BOTTOM w0.076: v2(133.38,114.03) 133.28,114.13 132.95,114.47 132.54,114.47 132.12,114.05 130.62,114.05 130.47,113.9 130.16,113.9 129.99,113.73 129.99,113.55 129.75,113.31 129.23,113.31 UC1.AF3
SIO_SLP_S3#: length 128.5
  TOP w0.089: v1(128.98,108.51) 128.66,108.19 v2(128.66,107.99)
  TOP w0.102: UE1.6 185.19,36.7 184.95,36.46 v2(184.69,36.46) 184.62,36.4 CE27.1
  IN1 w0.084: v2(128.66,107.99) 129.1,108.42 133.68,108.42 135.32,106.78 137.92,106.78
  IN1 w0.127: v2(190.02,34.74) 187.83,36.93 187.83,42.37 188.1,42.64 188.1,47.13 188.1,47.13 188.1,50.45 187.55,50.99 187.42,50.99 187,51.41 187,56.83 187.54,57.37 187.54,65.39 186.28,66.66 186.28,74.89 179.44,81.73 177.62,81.73 174.18,85.17 169.64,85.17 168.75,86.06 166.6,86.06 160.61,92.04 156.61,92.04 151.67,96.97 148.48,96.97 144.22,101.23 144.22,106.86 142.44,108.64 139.96,108.64 138.1,106.78 137.92,106.78
  IN3 w0.127: v2(190.02,34.74) 189.53,35.23 185.89,35.23 184.69,36.44 v2(184.69,36.46)
  BOTTOM w0.089: UC1.AT4 128.33,107.65 v2(128.66,107.99)
SIO_SLP_S4#: length 103
  TOP w0.089: v2(127.27,112.17) 126.9,111.8 T104.1
  TOP w0.102: UE1.84 187.99,54.16 187.79,54.35 187.79,54.71 v2(188.2,55.12)
  IN1 w0.084: 137.92,110.94 137.89,110.97 136.97,110.97 136.86,110.86 135.18,110.86 134.43,111.61 129.82,111.61 129.62,111.81 127.68,111.81 127.61,111.88 127.57,111.88 v2(127.27,112.17)
  IN1 w0.127: 137.92,110.94 138.33,110.94 138.51,111.12 141.74,111.12 141.91,111.29 144.23,111.29 144.32,111.38 147.2,111.38 148.76,109.82 148.76,108.31 153.19,103.88 153.19,103.73 160.73,96.19 160.73,93.72 167.12,87.33 171.78,87.33 172.42,86.68 174.47,86.68 178.15,83 180.49,83 184.33,79.17 184.33,78.66 187.4,75.58 187.4,66.97 188.56,65.82 188.56,58.81 188.79,58.58 188.79,55.59 188.32,55.12 v2(188.2,55.12)
  BOTTOM w0.089: UC1.AJ6 126.99,111.89 v2(127.27,112.17)
SIO_SLP_S5#: length 134.6
  TOP w0.089: v2(127.83,108.48) 128.24,108.07 128.24,107.68 131.47,104.45 132.49,104.45 133.48,103.45 133.61,103.45
  TOP w0.102: v2(188.79,40.25) 188.39,39.84 UE1.14 188.39,36.82 189.51,35.69 189.51,34.24 CE28.1 ; T103.1 136.3,100.94 133.79,103.45 133.61,103.45
  IN1 w0.084: v2(127.83,108.48) 127.95,108.59 133.8,108.59 135.35,107.05 138.01,107.05
  IN1 w0.127: 138.01,107.05 139.86,108.9 142.54,108.9 144.48,106.96 144.48,101.33 148.59,97.22 151.83,97.22 156.68,92.37 160.64,92.37 166.7,86.31 168.86,86.31 169.75,85.42 174.29,85.42 177.73,81.98 179.55,81.98 186.53,74.99 186.53,66.76 187.8,65.5 187.8,57.27 187.25,56.72 187.25,54.17 189.75,51.67 189.75,41.21 v2(188.79,40.25)
  BOTTOM w0.076: v2(127.83,108.48) 127.46,108.84 UC1.AP5
SKIP#: length 1.8
  BOTTOM w0.203: PR535.1 85.74,140.43 PU501.7
SKIP#1: length 46.3
  TOP w0.102: v2(111.9,141.16) v1(111.9,141.77)
  IN1 w0.254: v2(83.91,140.64) 84.29,140.64 85.53,141.87 85.53,144.51 88.71,147.69 113.79,147.69 115.03,146.45 115.03,141.42 114.77,141.16 v2(111.9,141.16)
  BOTTOM w0.203: PU502.1 v2(111.9,141.16)
  BOTTOM w0.254: PR535.2 84.42,140.13 v2(83.91,140.64)
SLATE_MODE_R: length 21.5
  TOP w0.102: v2(143.04,111.7) 143.34,111.7 v1(143.55,111.91)
  IN3 w0.084: v2(128.63,110.98) 128.63,111.23 131.81,114.41 133.96,114.41 135.35,113.02 137.82,113.02
  IN3 w0.127: 137.82,113.02 138.84,113.02 139.72,112.14 142.61,112.14 v2(143.04,111.7)
  BOTTOM w0.076: UC1.AL4 128.33,110.68 v2(128.63,110.98)
  BOTTOM w0.102: v2(143.04,111.7) 143.04,112.32 143.62,112.9 144.08,112.9 144.49,113.31 144.49,113.33 144.58,113.42 144.58,113.52 RC110.1
SLEWA_CPU: length 4.3
  TOP w0.102: PR513.2 v1(92.47,141.86)
  TOP w0.254: v2(90.77,142.67) 91.15,142.29 PR513.2
  BOTTOM w0.203: v2(90.77,142.67) 90.77,142.51 90.22,141.96 PU501.15
  BOTTOM w0.254: PR514.1 v2(90.77,142.67)
SM_RCOMP0: length 9.6
  TOP w0.305: RC68.1 89.32,103.22 v1(90.18,104.08) v2(93.5,107.4)
  BOTTOM w0.229: v2(93.5,107.4) 93.71,107.19 UC1.AU60
SM_RCOMP1: length 7.7
  TOP w0.305: v2(93.24,106.06) v1(92.43,105.25) 90.21,103.03 RC69.1
  BOTTOM w0.229: UC1.AV60 93.42,106.24 v2(93.24,106.06)
SM_RCOMP2: length 9.5
  TOP w0.305: v2(92.53,107.36) 92.5,107.36 88.36,103.23 v1(88.36,102.19) 88.36,100.23 RC70.1
  BOTTOM w0.229: v2(92.53,107.36) 92.72,107.17 UC1.AU61
SML0CLK: length 9.1
  BOTTOM w0.076: UC1.AN1 130.49,109.11 130.58,109.02 131.47,109.02
  BOTTOM w0.089: 131.47,109.02 v1(134.36,109.02) 135.41,109.02 137.64,111.25 137.92,111.25
  BOTTOM w0.102: RP49.1 137.92,111.25
