# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO0: length 138
  TOP w0.102: UE1.39 198.16,41.72 198.28,41.84 198.69,41.84 199.14,42.29 201.22,42.29 201.34,42.18 201.9,42.18 v2(202.89,43.17) 202.89,42.89 v1(203.44,42.33) ; v2(227.62,152.39) 227.78,152.23 JKB.13
  IN3 w0.127: v2(202.89,43.17) 209,43.17 210.66,44.83 217.19,44.83 224.84,52.49 224.84,76.74 221.71,79.88 221.71,84 222.51,84.8 222.51,89.59 224.05,91.13 224.05,97.49 224.04,97.5 224.04,124.08 224.62,124.66 224.62,130.9 226.41,132.68 226.41,151.08 227.62,152.3 v2(227.62,152.39)
KSO1: length 138.1
  TOP w0.102: JKB.15 227.33,150.63 227.1,150.86 227.1,151.18 v2(227.61,151.69) ; v2(202.3,43.17) v1(201.65,42.52) 199.05,42.52 198.64,42.12 UE1.40
  IN3 w0.127: v2(227.61,151.69) 227.61,151.68 226.67,150.73 226.67,132.58 224.89,130.79 224.89,123.66 224.3,123.07 224.3,91.02 222.76,89.48 222.76,84.69 221.96,83.89 221.96,80.75 225.12,77.59 225.12,73.1 225.11,73.09 225.11,72.89 225.11,72.88 225.11,52.38 217.3,44.58 210.77,44.58 208.91,42.72 202.73,42.72 202.3,43.15 v2(202.3,43.17)
KSO2: length 137.9
  TOP w0.102: v1(202.64,44.15) 201.72,43.22 v2(201.72,43.17) 201.3,42.75 198.95,42.75 198.72,42.52 UE1.41 ; v2(227.59,151.06) 227.96,151.43 JKB.14
  IN3 w0.127: v2(201.72,43.17) 201.72,43.15 202.41,42.46 209.01,42.46 210.05,43.5 216.59,43.5 225.37,52.27 225.37,72.99 225.38,73 225.38,77.49 227.99,80.11 227.99,87.55 224.56,90.99 224.56,96.13 224.56,96.14 224.56,122.96 225.15,123.55 225.15,130.69 226.93,132.47 226.93,150.4 v2(227.59,151.06)
KSO3: length 136
  TOP w0.102: UE1.42 198.8,42.92 199.05,43.17 v4(199.41,43.17) v2(201.13,43.17) ; JKB.16 227.89,149.83 227.61,150.11 v2(227.61,150.22)
  IN3 w0.127: v2(227.61,150.22) 227.19,149.8 227.19,132.36 225.41,130.58 225.41,123.44 224.82,122.86 224.82,113.48 224.82,113.47 224.82,94.62 228.31,91.12 228.31,80.06 225.63,77.38 225.63,52.16 216.71,43.25 210.16,43.25 209.11,42.2 202.09,42.2 201.13,43.15 v2(201.13,43.17)
KSO4: length 140.2
  TOP w0.102: v2(199.05,43.87) 198.5,43.32 UE1.43 ; v2(225.98,149.47) 225.96,149.47 225.45,148.95 225.45,147.26 226.08,146.63 JKB.20 231.09,146.63 v1(231.63,147.17)
  IN3 w0.127: v2(225.98,149.47) 225.98,149.44 225.43,148.89 225.43,132.45 225.32,132.34 224.1,131.12 224.1,124.88 223.52,124.29 223.52,91.41 222,89.9 222,85.01 221.2,84.21 221.2,79.66 224.32,76.54 224.32,52.7 217.95,46.33 211.44,46.33 209.8,44.68 201.08,44.68 200.69,44.29 199.46,44.29 199.05,43.88 v2(199.05,43.87)
KSO5: length 140
  TOP w0.102: UE1.44 198.32,43.72 v2(198.47,43.87) ; v1(230.18,146.03) 229.98,145.83 JKB.21 226.55,145.83 225.22,147.16 225.22,149.31 v2(225.96,150.05)
  IN3 w0.127: v2(225.96,150.05) 225.86,149.95 225.86,149.95 225.17,149.25 225.17,132.56 224.95,132.34 223.84,131.23 223.84,124.99 223.25,124.4 223.25,91.52 221.75,90.01 221.75,85.11 220.95,84.31 220.95,79.54 224.07,76.42 224.07,62.47 223.38,61.79 223.38,52.13 217.84,46.58 211.34,46.58 209.69,44.94 200.85,44.94 200.5,44.59 199.17,44.59 198.47,43.88 v2(198.47,43.87)
KSO6: length 137
  TOP w0.102: v2(227.61,148.71) 227.61,148.64 228.03,148.23 JKB.18 v1(230.18,148.23) ; UE1.45 198.1,44.12 198.28,44.29 199.21,44.29 v2(199.63,43.87)
  IN3 w0.127: v2(199.63,43.87) 199.63,43.85 201.55,41.94 209.21,41.94 210.26,42.99 216.83,42.99 225.89,52.06 225.89,77.28 228.57,79.96 228.57,91.23 225.08,94.72 225.08,113.58 225.09,113.59 225.09,122.75 225.67,123.33 225.67,130.47 227.61,132.41 v2(227.61,148.71)
KSO7: length 134.7
  TOP w0.102: JKB.19 227.39,147.43 v2(225.98,148.84) ; v1(200.88,44.16) 200.59,43.87 v2(200.22,43.87) 199.57,44.52 UE1.46
  IN3 w0.127: v2(225.98,148.84) 225.94,148.8 225.94,132.59 225.58,132.23 224.36,131.01 224.36,124.77 223.78,124.19 223.78,91.3 222.26,89.78 222.26,84.9 221.45,84.1 221.45,79.77 224.58,76.64 224.58,52.59 218.07,46.07 211.55,46.07 209.34,43.87 v2(200.22,43.87)
KSO8: length 141.2
  TOP w0.102: v1(230.57,150.07) 229.54,149.03 JKB.17 227.92,149.03 227.62,149.33 v2(227.62,149.5) ; v2(198.47,45.01) 198.37,44.92 UE1.47
  IN3 w0.127: v2(227.62,149.5) 228.18,148.94 228.18,132.61 225.93,130.36 225.93,123.22 225.35,122.64 225.35,113.7 225.34,113.7 225.34,94.81 228.82,91.33 228.82,79.85 226.18,77.21 226.18,62.28 226.15,62.25 226.15,51.95 216.94,42.74 210.37,42.74 209.31,41.68 200.06,41.68 198.04,43.69 198.04,44.59 v2(198.47,45.01)
KSO9: length 143.5
  TOP w0.102: UE1.48 198.14,45.32 198.28,45.45 198.61,45.45 v2(199.05,45.01) ; v1(230.42,157.76) 229.69,157.03 JKB.7 227.05,157.03 v2(225.97,158.1)
  IN3 w0.127: v2(199.05,45.01) 199.05,45.02 199.73,45.71 208.25,45.71 210,47.46 217.61,47.46 222.62,52.47 222.62,62.1 223.3,62.79 223.3,76.07 220.18,79.19 220.18,84.63 220.99,85.43 220.99,90.36 222.47,91.85 222.47,124.73 223.05,125.31 223.05,131.55 224.15,132.65 224.15,149.94 225.97,151.76 v2(225.97,158.1)
KSO10: length 141.3
  TOP w0.102: JKB.5 227.08,158.63 v2(226.56,158.1) ; UE1.49 198.93,45.72 v1(199.08,45.57) v2(199.63,45.01)
  IN3 w0.127: v2(226.56,158.1) 226.73,157.93 226.73,152.15 224.41,149.83 224.41,132.54 223.32,131.44 223.32,125.2 222.73,124.62 222.73,91.74 221.24,90.25 221.24,85.33 220.44,84.52 220.44,79.31 223.56,76.19 223.56,62.68 222.87,62 222.87,52.37 217.59,47.09 211.08,47.09 209.44,45.45 200.07,45.45 199.63,45.02 v2(199.63,45.01)
KSO11: length 142.3
  TOP w0.102: v2(227.14,158.04) 227.35,157.83 JKB.6 ; UE1.50 199.11,46.12 v2(200.22,45.01) 200.23,45.01 201.03,45.81 v1(201.03,45.98)
  IN3 w0.127: v2(200.22,45.01) 200.4,45.19 209.59,45.19 211.23,46.84 217.72,46.84 223.13,52.24 223.13,61.89 223.81,62.58 223.81,76.3 220.69,79.43 220.69,84.42 221.49,85.22 221.49,90.13 222.99,91.63 222.99,124.51 223.58,125.1 223.58,131.34 224.67,132.43 224.67,149.72 227.14,152.18 v2(227.14,158.04)
KSO12: length 141.5
  TOP w0.102: v2(198.47,46.6) 198.39,46.52 UE1.51 ; v2(223.61,153.03) JKB.12 229.39,153.03 v1(230.15,152.26)
  IN3 w0.127: v2(223.61,153.03) 223.61,151.46 222.91,150.75 222.91,133.26 221.42,131.77 221.42,118.05 220.7,117.33 220.7,113.19 221.42,112.47 221.42,104.48 219.23,102.29 217.89,102.29 216.74,101.14 216.74,92.99 219.97,89.76 219.97,85.85 219.17,85.05 219.17,78.73 222.26,75.64 222.26,63.18 221.6,62.52 221.6,52.94 217.14,48.48 204.84,48.48 204.12,47.76 199.62,47.76 198.47,46.61 v2(198.47,46.6)
KSO13: length 143.3
  TOP w0.102: UE1.52 198.13,46.92 198.21,47 198.64,47 v2(199.05,46.6) ; v2(224.03,154.67) 224.79,155.43 JKB.9 v1(230.22,155.43)
  IN3 w0.127: v2(199.05,46.6) 199.05,46.61 199.8,47.36 204.08,47.36 204.94,48.22 217.26,48.22 221.86,52.82 221.86,62.42 222.52,63.08 222.52,75.75 219.42,78.84 219.42,84.94 220.22,85.75 220.22,89.86 216.99,93.09 216.99,101.03 217.99,102.03 219.33,102.03 221.68,104.39 221.68,112.57 220.96,113.3 220.96,117.22 221.68,117.95 221.68,131.67 223.32,133.3 223.32,150.64 224.03,151.35 v2(224.03,154.67)
KSO14: length 142.5
  TOP w0.102: v2(225.07,156.23) JKB.8 231.41,156.23 v1(231.77,156.58) ; UE1.53 198.91,47.32 v2(199.63,46.6)
  IN3 w0.127: v2(199.63,46.6) 199.63,46.61 200.07,47.04 204.12,47.04 205.05,47.97 217.37,47.97 222.11,52.71 222.11,62.31 222.78,62.98 222.78,75.86 219.68,78.96 219.68,84.84 220.48,85.64 220.48,90.59 221.95,92.06 221.95,112.68 221.22,113.41 221.22,117.11 221.95,117.84 221.95,131.56 223.58,133.19 223.58,150.33 224.56,151.31 224.56,155.72 v2(225.07,156.23)
KSO15: length 139.8
  TOP w0.102: v1(202.35,47.23) 201.72,46.6 v2(200.22,46.6) 199.1,47.72 UE1.54 ; JKB.10 v2(225.01,154.63)
  IN3 w0.127: v2(200.22,46.6) 200.35,46.72 204.16,46.72 205.15,47.72 217.49,47.72 222.36,52.59 222.36,62.21 223.04,62.88 223.04,75.97 219.93,79.08 219.93,84.73 220.73,85.54 220.73,90.48 222.21,91.95 222.21,124.84 222.79,125.42 222.79,131.66 223.49,132.36 223.49,132.73 223.89,133.13 223.89,150.19 225.01,151.31 v2(225.01,154.63)
KSO16: length 150
  TOP w0.102: UE1.81 189.19,51.94 190.19,50.94 191.65,50.94 193.01,49.58 v2(195.1,49.58) ; v2(223.59,153.63) 223.78,153.83 JKB.11 v1(231.13,153.83)
  IN3 w0.127: v2(223.59,153.63) 222.64,152.69 222.64,145.13 221.05,143.54 221.05,141.67 218.46,139.08 218.46,124.28 218.34,124.16 218.34,107.88 213.48,103.01 213.48,95.18 213.34,95.05 213.34,92.31 214.93,90.73 215.77,90.73 217.64,88.85 217.64,86.82 216.88,86.06 216.88,77.68 219.96,74.61 219.96,64.11 219.32,63.47 219.32,54 217.77,52.45 212.29,52.45 210.95,51.11 198.97,51.11 197.44,49.58 v2(195.1,49.58)
LAN_CLKREQ#: length 166
  TOP w0.089: 137.92,113.65 136.49,113.65
  TOP w0.102: 137.92,113.65 143.12,113.65 143.59,113.18 144.38,113.18 145.94,114.75 RP42.8 ; 136.49,113.65 136.27,113.65 135.15,114.77 v1(133.72,114.77) 133.01,114.77 v2(132.48,115.3)
  IN2 w0.089: 123.75,95.62 125.19,97.06 125.19,98.16 126.65,99.62 129.87,99.62 130.47,100.22 130.47,100.71 130.65,100.89 130.65,104.65 131.36,105.36 131.36,109.23 131.8,109.68 131.8,110.76 133.53,112.48 133.53,113.4 134.22,114.09 134.22,114.67 133.76,115.13 132.65,115.13 v2(132.48,115.3)
  IN2 w0.127: 123.75,95.62 123.64,95.51 121.73,95.51 113.15,86.92 58.23,86.92 44.85,73.54 34.67,73.54 v2(34.3,73.17)
  IN3 w0.127: v2(34.3,73.17) 34.2,73.26 34.2,78.57 34,78.78 34,86.93 37.24,90.17 v2(37.24,90.98)
  BOTTOM w0.089: v2(132.48,115.3) 131.65,114.48 130.4,114.48 UC1.AD1
  BOTTOM w0.102: UL1.12 37.55,90.67 v2(37.24,90.98) 37.05,91.17 RL37.1
LAN_X1_R: length 2.9
  TOP w0.102: RG5.1 64.49,42.52 64.3,42.71 v1(64.3,42.89) 64.58,43.17 64.58,43.66 64.32,43.92 UG1.6
LCD_CBL_DET#: length 7.1
  BOTTOM w0.076: UC1.J3 129.47,123.06 130.4,123.06 130.57,123.23 130.57,123.4 130.83,123.66 132.54,123.66 132.78,123.9 134.49,123.9 134.59,124 RC106.2
LCD_TEST: length 166
  TOP w0.102: v2(193.48,55.21) 193.45,55.21 192.79,54.55 UE1.72
  IN2 w0.127: v2(217.19,55.11) 217.19,56.43 222.41,61.65 222.41,79.76 222.41,79.82 220.84,81.39 220.84,89.39 224.18,92.74 224.18,122.66 225.34,123.82 225.34,148.05 222.02,151.37 222.02,163.97 221.52,164.47 221.52,172.98 222.02,173.48 222.02,175.78 v2(222.96,176.72)
  BOTTOM w0.102: v2(217.19,55.11) v1(215.89,55.11) 214.89,54.1 214.77,54.1 213.88,53.21 213.88,52.51 212.58,51.21 204.28,51.21 204.12,51.37 200.09,51.37 197.08,54.38 194.31,54.38 v2(193.48,55.21) ; v2(222.96,176.72) 223.49,177.24 223.49,177.73 223.99,178.23 225.64,178.23 226.6,177.28 227.69,177.28 228.51,176.46 JLVDS.33
LDO_3V: length 6
  TOP w0.102: v3(146.34,157.52) v1(146.34,158.24)
  IN3 w0.254: v3(146.34,157.52) 149.07,154.79 149.53,154.79 v2(149.7,154.97)
  BOTTOM w0.254: PR304.1 149.53,154.79 v2(149.7,154.97)
LDO_3V_VDDCI: length 6.2
  BOTTOM w0.102: v1(182.03,177.71) 182.12,177.62 183.12,177.62 PR1203.1
  BOTTOM w0.254: PR1203.1 184.1,178.04 PC1213.1 185.36,179.3 185.44,179.3 185.84,179.7 185.84,179.84 186.21,180.22 186.21,180.41 186.3,180.49 PU1200.5
LG_3V: length 5.4
  TOP w0.635: 210.19,18.4 211.32,17.27 v1(213.06,17.27) 215.17,17.27
  vias: v2(215.8,17.54) v2(215.8,16.96)
LG_5V: length 6.7
  TOP w0.102: v2(212.69,24.01) 215.5,24.01 v1(216.75,22.75)
  IN3 w0.762: 211.93,24.13 211.8,24.13 210.4,22.74
  vias: v2(212.69,24.59) v3(209.33,21.68) v3(209.81,22.16)
LG_+1.2VSP: length 7.6
  IN3 w0.762: 180.31,174.99 180.31,176.45 181.13,177.28 184.43,177.28 185.13,176.58
  BOTTOM w0.102: v2(184.99,175.82) v1(184.32,175.82)
  vias: v2(179.98,174.17) v2(180.56,174.17) v2(185.58,175.82)
LID_SW#: length 200.2
  TOP w0.102: v2(44.34,95.08) 43.57,95.08 39.26,99.39 32.71,99.39 30.76,97.44 26,97.44 25.79,97.23 JPWR.2 ; v2(176.14,46.86) v1(176.63,46.37) 177,46 177.92,46 CE30.1 178.53,45.53 RE71.2 179.54,44.52 UE1.115
  IN3 w0.127: v2(176.14,46.86) 176.11,46.83 69.24,46.83 56.09,59.98 56.09,94.01 55.02,95.08 v2(44.34,95.08)
LINE1-L: length 3.6
  TOP w0.102: CA67.1 v1(35.72,29.77)
  TOP w0.203: UA1.22 37.94,28.82 CA67.1
LINE1-R: length 5.1
  TOP w0.102: CA68.1 38.93,30.51 v1(38.93,32.53)
  TOP w0.203: UA1.21 38.34,29.02 38.19,29.17 CA68.1
LINE1-VREFO-L: length 5.9
  TOP w0.102: RA165.1 33.57,23.8 33.05,23.8 32.16,22.91 v1(32.16,22)
  TOP w0.203: UA1.31 35.77,24.62 35.63,24.76 34.53,24.76 RA165.1
LINE1-VREFO-R: length 2.4
  TOP w0.203: RA166.1 v1(35.08,25.2) 35.63,25.2 35.74,25.09 35.77,25.09 35.84,25.02 UA1.30
LINE-IN-L: length 6.9
  TOP w0.254: RA165.2 RA83.1 32.3,23.89 31.58,23.17 v1(30.8,23.17) LA8.2 29.06,23.61 v2(29.06,24.07) 29.06,24.56 RA55.2
  BOTTOM w0.254: v2(29.06,24.07) 29.06,24.01 28.86,23.8 RA80.2
LINE-IN-R: length 9.2
  TOP w0.254: RA84.1 31.54,25.71 v2(32.05,25.2) RA166.2 ; LA9.2 27.97,23.61 v2(28.43,24.07) 28.3,24.2 RA56.2
  BOTTOM w0.254: RA82.2 27.97,23.61 v2(28.43,24.07) 28.43,24.42 28.64,24.64 v1(30.85,24.64) 31.49,24.64 v2(32.05,25.2)
LPC_LAD0: length 112.3
  TOP w0.089: v2(124.81,101.89) 124.41,101.89 v1(124.32,101.98)
  TOP w0.102: UE1.10 186.79,38.66 185.6,39.84 185.6,40.98 v2(185.56,41.02)
  IN1 w0.084: 131.27,100.59 131.09,100.59 129.96,101.72 125.9,101.72 125.52,102.1 125.01,102.1 v2(124.81,101.89)
  IN1 w0.127: v2(185.56,41.02) 185.56,40.45 185.04,39.93 184.45,39.93 181.08,43.3 181.08,50.09 180.37,50.8 180.37,55.61 179.59,56.39 179.59,60.87 176.76,63.7 176.76,65 175.03,66.73 175.03,74.13 170.78,78.38 160.15,78.38 149.77,88.76 147.75,88.76 139.99,96.52 136.63,96.52 132.83,100.32 131.69,100.32 131.42,100.59 131.27,100.59
  BOTTOM w0.076: UC1.AU14 122.74,106.6 122.74,106.12 122.7,106.08 122.7,104.75 122.95,104.5 122.95,104.35 122.95,104.34 122.95,103.81 124.81,101.95 v2(124.81,101.89)
LPC_LAD1: length 109.6
  TOP w0.089: v2(124.98,103.37) 124.98,104.22 125.68,104.93 v1(126.24,104.93)
  TOP w0.102: v2(184.89,41.01) 185.3,40.6 185.3,39.61 185.99,38.92 UE1.8
  IN1 w0.084: 131.57,101.17 130.99,101.17 130.05,102.11 126.53,102.11 125.27,103.37 v2(124.98,103.37)
  IN1 w0.127: 131.57,101.17 133.42,101.17 136.86,97.74 139.71,97.74 148.02,89.42 150.04,89.42 160.43,79.04 171.06,79.04 177.08,73.02 177.08,66.44 178.24,65.28 178.24,63.99 180.34,61.88 180.34,59.64 181.03,58.95 181.03,51.08 181.74,50.36 181.74,44.09 184.82,41.01 v2(184.89,41.01)
  BOTTOM w0.076: v2(124.98,103.37) 124.09,103.37 123.45,104.01 123.45,105.3 UC1.AW12
LPC_LAD2: length 107.4
  TOP w0.089: v2(125.51,102.6) v1(125.51,103.58)
  TOP w0.102: UE1.7 185.59,38.89 184.89,39.59 v2(184.89,40.37)
  IN1 w0.084: 131.57,100.83 131.09,100.83 130.02,101.91 126.21,101.91 v2(125.51,102.6)
  IN1 w0.127: v2(184.89,40.37) 181.41,43.85 181.41,50.23 180.7,50.94 180.7,58.4 179.92,59.17 179.92,61 177.12,63.81 177.12,65.48 175.37,67.24 175.37,74.26 170.92,78.71 160.29,78.71 149.91,89.09 147.89,89.09 139.57,97.41 136.72,97.41 133.29,100.83 131.57,100.83
  BOTTOM w0.076: UC1.AY12 123.28,104.82 123.28,103.94 124.79,102.43 125.34,102.43 v2(125.51,102.6)
LPC_LAD3: length 108.7
  TOP w0.089: v1(123.45,104.55) 123.45,103.98 123.65,103.77 124.49,103.77 v2(124.52,103.8)
  TOP w0.102: v2(184.62,41.96) 184.48,41.82 184.48,39.56 184.92,39.13 184.92,38.75 184.79,38.61 UE1.5
  IN1 w0.084: v2(124.52,103.8) 125.09,103.8 126.6,102.29 130.12,102.29 130.6,101.81 131.27,101.81
  IN1 w0.127: 131.27,101.81 133.24,101.81 136.99,98.07 139.85,98.07 148.16,89.75 150.18,89.75 160.56,79.37 171.19,79.37 177.41,73.15 177.41,66.58 178.83,65.16 178.83,63.86 181.19,61.49 181.19,59.69 181.39,59.49 181.39,51.18 182.07,50.5 182.07,44.52 184.62,41.97 v2(184.62,41.96)
  BOTTOM w0.076: UC1.AW11 123.61,105.3 123.61,104.08 123.89,103.8 v2(124.52,103.8)
LPC_LFRAME#: length 108.3
  TOP w0.089: v2(125.38,101.72) v1(126.13,101.72)
  TOP w0.102: v2(184.51,38.91) 184.39,38.79 UE1.4
  IN1 w0.084: 131.57,99.99 131.56,99.99 131.48,99.91 131.48,99.85 131.41,99.78 130.99,99.78 130.74,100.03 130.74,100.66 129.86,101.54 129.14,101.54 128.49,100.89 126.93,100.89 126.33,101.49 125.61,101.49 v2(125.38,101.72)
  IN1 w0.127: v2(184.51,38.91) 184.51,39.25 180.75,43.01 180.75,49.95 180.04,50.67 180.04,55.22 178.25,57.01 178.25,58.58 177.82,59.01 177.82,60.38 176.35,61.85 176.35,64.95 174.7,66.59 174.7,72.99 169.64,78.05 160.02,78.05 149.63,88.43 147.61,88.43 139.87,96.18 136.51,96.18 132.7,99.99 131.57,99.99
  BOTTOM w0.076: v2(125.38,101.72) 125.38,101.89 125.01,102.26 124.73,102.26 123.12,103.87 123.12,104.57 122.86,104.82 122.86,105.99 UC1.AV12
LVDS_A0+: length 13.7
  TOP w0.102: UX4.41 204.92,176.64 205.29,177.01 205.87,177.59 v3(207.18,177.59) 207.62,177.59 208.77,176.44 211.6,176.44 212.94,177.78 212.94,178.06 v2(213.06,178.17)
  BOTTOM w0.102: JLVDS.2 213.01,176.47 212.88,176.6 212.88,178 v2(213.06,178.17)
LVDS_A0-: length 13.7
  TOP w0.102: v2(212.47,178.17) 212.68,177.97 212.68,177.89 211.49,176.71 208.88,176.71 207.73,177.85 205.76,177.85 205.1,177.2 205.1,177.2 204.65,176.75 204.65,176.1 204.52,175.97 UX4.42
  BOTTOM w0.102: v2(212.47,178.17) 212.61,178.03 212.61,176.61 212.51,176.51 JLVDS.1
LVDS_A1+: length 14.4
  TOP w0.102: v2(214.75,178.03) 214.61,177.89 214.61,177.5 214.34,177.23 213.45,177.23 211.91,175.69 v3(208.74,175.69) 208.45,175.69 207.3,176.84 206.21,176.84 205.59,176.21 205.59,176.06 205.72,175.94 UX4.39
  BOTTOM w0.102: JLVDS.5 214.51,176.51 214.4,176.63 214.4,177.15 214.59,177.34 214.59,177.87 v2(214.75,178.03)
LVDS_A1-: length 14.4
  TOP w0.102: UX4.40 205.32,176.09 205.32,176.09 205.32,176.32 206.1,177.1 207.41,177.1 208.56,175.96 211.8,175.96 213.34,177.5 214.23,177.5 214.34,177.61 214.34,177.86 v2(214.16,178.03)
  BOTTOM w0.102: JLVDS.4 214.01,176.51 214.13,176.63 214.13,177.26 214.32,177.45 214.32,177.87 v2(214.16,178.03)
LVDS_A2+: length 14.6
  TOP w0.102: v2(216.06,177.92) 215.93,177.79 215.93,177.09 215.32,176.48 213.78,176.48 212.2,174.91 v3(210.57,174.91) 208.17,174.91 206.99,176.09 206.6,176.09 206.47,175.95 206.47,175.88 206.52,175.83 UX4.37
  BOTTOM w0.102: v2(216.06,177.92) 215.9,177.76 215.9,176.63 216.01,176.51 JLVDS.8
LVDS_A2-: length 14.7
  TOP w0.102: v2(215.47,177.92) 215.66,177.73 215.66,177.2 215.21,176.75 213.67,176.75 212.09,175.17 208.28,175.17 207.1,176.35 206.49,176.35 206.2,176.06 206.2,175.95 206.12,175.87 UX4.38
  BOTTOM w0.102: v2(215.47,177.92) 215.63,177.76 215.63,176.63 215.51,176.51 JLVDS.7
LVDS_ACLK+: length 13.9
  TOP w0.102: v2(217.56,177.49) 217.47,177.4 217.47,176.49 216.71,175.73 v3(214.67,175.73) 214.14,175.73 212.56,174.16 207.86,174.16 207.82,174.19 UX4.35
  BOTTOM w0.102: JLVDS.11 217.51,176.34 217.51,177.45 v2(217.56,177.49)
LVDS_ACLK-: length 13.8
  TOP w0.102: UX4.36 207.8,174.59 207.97,174.42 212.45,174.42 214.03,176 216.6,176 217.2,176.6 217.2,177.27 v2(216.97,177.49)
  BOTTOM w0.102: JLVDS.10 217.01,176.47 217.12,176.58 217.14,176.58 217.14,176.57 217.18,176.57 217.25,176.65 217.25,177.23 216.98,177.49 v2(216.97,177.49)
LVDS_B0+: length 17.5
  TOP w0.102: UX4.31 207.78,172.59 207.85,172.66 208.12,172.66 208.61,173.15 208.94,173.15 v2(209.01,173.08) 209.18,173.24 209.54,173.24 209.71,173.41 212.93,173.41 214.5,174.98 217.5,174.98 218.95,176.43 218.95,176.88 219.04,176.97 219.04,177.48 v2(219.06,177.49)
  BOTTOM w0.102: v2(209.01,173.08) 208.69,173.4 208.1,173.4 RX40.2 ; JLVDS.14 219.01,176.34 218.95,176.4 218.95,176.88 219.06,176.98 v2(219.06,177.49)
LVDS_B0-: length 17.4
  TOP w0.102: UX4.32 207.81,172.99 207.88,172.92 208.01,172.92 208.5,173.42 208.77,173.42 v2(209.01,173.66) 209.16,173.51 209.43,173.51 209.6,173.68 212.82,173.68 214.39,175.25 217.39,175.25 218.68,176.54 218.68,176.99 218.77,177.08 218.77,177.2 218.48,177.49 v2(218.47,177.49)
  BOTTOM w0.102: RX38.2 208.3,173.67 209.01,173.67 v2(209.01,173.66) ; JLVDS.13 218.51,176.35 218.68,176.52 218.68,176.99 218.79,177.09 218.79,177.18 218.48,177.49 v2(218.47,177.49)
LVDS_B1+: length 18.3
  TOP w0.102: UX4.29 208.4,171.79 208.53,171.92 208.9,171.92 v2(208.97,171.85) 209.17,172.05 209.51,172.05 210.11,172.65 213.25,172.65 214.84,174.23 v3(217.91,174.23) 218.91,174.23 220.54,175.86 220.54,176.83 v2(220.53,176.84)
  BOTTOM w0.102: v2(220.53,176.84) 220.5,176.81 220.5,176.34 220.51,176.33 JLVDS.17 ; RX44.2 208.28,171.81 208.93,171.81 v2(208.97,171.85)
LVDS_B1-: length 18.3
  TOP w0.102: v2(219.95,176.84) 220.27,176.51 220.27,175.97 218.8,174.5 214.73,174.5 213.14,172.91 210,172.91 209.4,172.32 209.09,172.32 v2(208.97,172.44) 208.72,172.19 208.42,172.19 208.29,172.06 207.89,172.06 207.76,172.19 UX4.30
  BOTTOM w0.102: RX42.2 208.12,172.07 208.61,172.07 v2(208.97,172.44) ; v2(219.95,176.84) 219.96,176.84 220.23,176.56 220.23,176.51 220.01,176.29 JLVDS.16
LVDS_B2+: length 21.4
  TOP w0.102: v2(222.06,176.79) 222.06,176 219.54,173.48 215.29,173.48 213.64,171.83 v3(211.51,171.83) 210.38,171.83 209.55,171 v2(209.55,170.82) 209.32,170.82 209.17,170.66 208.33,170.66 207.92,171.07 207.84,171.07 207.76,170.99 UX4.27
  BOTTOM w0.102: JLVDS.20 222.01,176.33 221.99,176.36 221.99,176.73 v2(222.06,176.79) ; v2(209.55,170.82) 209.34,170.82 209.08,170.56 209.08,170.32 208.71,169.95 208.2,169.95 RX48.2
LVDS_B2-: length 21.1
  TOP w0.102: UX4.28 207.78,171.39 207.84,171.34 208.03,171.34 208.44,170.93 209.06,170.93 209.13,171.01 v2(209.13,171.23) 209.4,171.23 210.26,172.1 213.53,172.1 215.18,173.75 219.43,173.75 221.79,176.11 221.79,176.48 v2(221.47,176.79)
  BOTTOM w0.102: v2(209.13,171.23) 209.13,170.99 208.82,170.67 208.82,170.43 208.6,170.21 208.2,170.21 RX46.2 ; JLVDS.19 221.51,176.26 221.64,176.39 221.66,176.39 221.72,176.46 221.72,176.55 221.65,176.63 221.65,176.72 221.57,176.79 v2(221.47,176.79)
LVDS_BCLK+: length 19.3
  TOP w0.102: v2(209.88,169.72) 208.52,169.72 208.05,170.19 UX4.25
  BOTTOM w0.102: v2(209.88,169.72) 211.51,169.72 216.32,174.53 223.07,174.53 223.37,174.83 223.37,175 223.51,175.14 JLVDS.23
LVDS_BCLK-: length 19.2
  TOP w0.102: UX4.26 207.77,170.59 207.91,170.46 208.16,170.46 208.63,169.98 209.57,169.98 209.73,170.14 209.83,170.14 209.88,170.19 v2(209.88,170.3)
  BOTTOM w0.102: v2(209.88,170.3) 210.2,169.98 211.4,169.98 216.21,174.79 222.96,174.79 223.1,174.94 223.1,175.03 223.01,175.12 JLVDS.22
LX_1.05V: length 8
  TOP w0.102: v3(146.78,160.89) v1(147.58,160.89)
  IN1 w0.508: v3(146.78,160.89) 146.78,158.87 145.7,157.79 145.7,156.3 v3(144.17,154.77)
LX_1.5VSP:
  vias: v1(107.32,20.6)
LX_1.8VSP: length 1.3
  BOTTOM w0.102: PR605.1 v1(216.06,98.43)
LX_3V: length 3.6
  TOP w0.102: v2(210.47,13.67) v1(211.09,13.67)
  IN1 w0.762: 207.8,16.32 209.64,14.48 209.64,14.1
  vias: v2(210.47,13.08) v3(207.18,17.81) v3(207.18,17.17)
LX_5V: length 5.3
  IN1 w0.762: 211.93,27.37 210.74,27.37 207.82,24.45
  vias: v1(207.66,22.98) v2(212.69,27.64) v2(212.69,27.05) v3(207.18,23.24) v3(207.18,22.61)
LX_CHG: length 8.8
  IN1 w1.016: 163.8,170.36 154.97,170.36
  vias: v1(152.1,177.29) v2(153.31,170.3) v2(153.89,170.3) v2(164.74,170.68) v2(165.32,170.68) v3(149.06,174.61) v3(149.06,173.6) v3(149.06,172.58) v3(149.95,175.12) v3(149.95,174.11) v3(149.95,173.09) v3(150.97,176.14) v3(150.97,175.12) v3(150.97,174.11) v3(150.97,173.09) v3(151.98,176.14) v3(151.98,175.12) v3(151.98,174.11) v3(151.98,173.09) v3(153,176.14) v3(153,175.12) v3(153,174.11) v3(153,173.09)
LX_PCIE:
  vias: v1(194.11,67.48) v2(194.11,68.53) v2(194.75,68.53)
LX_VDDCI:
  vias: v1(189.63,184.32) v3(188.5,184.15) v3(188.5,183.52)
M_CLK_DDR0: length 77.1
  IN1 w0.084: 106.23,97.69 106.37,97.83 106.37,97.97 106.77,98.37 106.95,98.37 107.15,98.18 107.48,98.18 107.83,98.53 107.83,98.85 107.61,99.07 107.61,99.21 107.83,99.43 108.14,99.43 108.31,99.26 108.62,99.26 108.79,99.44 108.79,100.22 108.9,100.32 108.9,100.79 108.47,101.22 108.47,101.43 108.92,101.88 108.92,102.22 108.83,102.31 108.83,102.38 108.46,102.75 v2(108.46,102.86)
  IN1 w0.127: 106.23,97.69 105.85,97.31 105.85,84.03 102.26,80.44 101.86,80.44 100.34,81.96 100.16,81.96 99.89,81.69 99.89,81.51 101.41,79.99 101.41,79.59 100.98,79.16 100.58,79.16 99.06,80.68 98.88,80.68 98.61,80.41 98.61,80.23 99.77,79.07 99.77,78.67 99.34,78.24 98.93,78.24 97.77,79.4 97.59,79.4 92.75,74.56 79.5,74.56 78.55,73.6 77.74,73.6 75.97,71.83 75.97,71.05 75.81,70.88 75.81,70.75 75.52,70.46 75.26,70.46 v2(75.12,70.33)
  BOTTOM w0.076: v2(108.46,102.86) 107.72,102.86 107.59,103 107.59,104.61 107.56,104.64 107.56,106.34 107.66,106.44 107.79,106.44 107.85,106.37 UC1.AV37
  BOTTOM w0.102: JDIMM1.101 74.2,72.38 74.26,72.32 74.26,71.84 74.49,71.62 74.49,70.63 74.7,70.41 75.04,70.41 v2(75.12,70.33)
M_CLK_DDR1: length 76.1
  IN1 w0.084: v2(108.28,104.62) 108.41,104.75 108.75,104.75 108.82,104.68 108.82,103.54 109.13,103.23 109.13,100.27 108.99,100.13 108.99,99.37 106.84,97.21
  IN1 w0.127: 106.84,97.21 106.48,96.85 106.48,83.76 100.33,77.6 96.85,77.6 93.17,73.92 79.77,73.92 78.81,72.96 78.01,72.96 76.66,71.61 76.66,68.11 76.39,67.84 75.16,67.84 74.88,67.55 74.88,66.12 75.16,65.84 76.29,65.84 76.42,65.71 76.42,64.89 76.29,64.76 74.65,64.76 74.31,64.42 74.31,62.8 74.67,62.44 75.09,62.44 v2(75.2,62.33)
  BOTTOM w0.076: UC1.AY36 108.68,104.73 108.57,104.62 v2(108.28,104.62)
  BOTTOM w0.102: v2(75.2,62.33) 75.01,62.52 74.79,62.52 74.51,62.79 74.51,64.11 74.5,64.12 JDIMM1.102
M_CLK_DDR2: length 93.2
  IN3 w0.084: v2(107.25,109.03) 107.2,109.08 106.89,109.08 106.81,109.01 106.81,107.55 107.46,106.91 107.46,101.6 106.84,100.99 106.84,100.67 106.24,100.07 106.24,99.61 106.88,98.98 106.88,98.55 106.52,98.19 106.52,97.84 106.6,97.76
  IN3 w0.127: 106.6,97.76 106.6,91.45 118.86,79.19 119.54,79.19 119.83,78.91 119.83,78.22 119.95,78.1 120.36,78.1 120.48,78.22 120.48,78.91 120.76,79.19 121.38,79.19 121.66,78.91 121.66,77.3 121.78,77.18 122.19,77.18 122.31,77.3 122.31,78.91 122.6,79.19 123.21,79.19 123.49,78.91 123.49,77.35 123.67,77.18 150.03,77.18 151.65,75.56 151.65,74.86 152.07,74.43 152.92,74.43 153.2,74.15 153.2,73.71 152.99,73.5 152.99,73.29 153.15,73.13 153.98,73.13 154.25,72.86 154.25,72.14 153.98,71.86 153.6,71.86 153.48,71.74 153.48,71.24 153.6,71.12 153.98,71.12 154.25,70.84 154.25,69.91 154.05,69.71 154.05,69.22 153.84,69.01 153.56,69.01 v2(153.37,68.83)
  BOTTOM w0.076: v2(107.25,109.03) 107.32,109.03 UC1.AN38
  BOTTOM w0.102: v2(153.37,68.83) 153.19,69.01 153,69.01 152.75,69.26 JDIMM2.101
M_CLK_DDR3: length 91.8
  IN3 w0.084: v2(107.2,110.29) 106.99,110.5 106.95,110.5 106.71,110.74 106.4,110.74 106.15,110.49 106.15,110.1 106.45,109.8 106.45,107.16 106.23,106.94 106.23,100.9 105.64,100.32 105.64,95.84 105.71,95.77
  IN3 w0.127: v2(153.75,62.37) 153.91,62.53 154.32,62.53 154.59,62.79 154.59,64.01 152.56,66.04 152.56,72.08 151.9,72.73 151.9,73.29 150.75,74.43 150.75,75.19 149.66,76.28 148.89,76.28 120.49,76.28 105.72,91.06 105.72,91.08 105.71,91.08 105.71,95.77
  BOTTOM w0.076: UC1.AL38 107.56,110.65 v2(107.2,110.29)
  BOTTOM w0.102: v2(153.75,62.37) 153.57,62.55 153.37,62.55 153.13,62.79 153.13,64.08 153.05,64.16 JDIMM2.102
M_CLK_DDR#0: length 77.5
  IN1 w0.084: 106.17,98.01 106.69,98.54 107.03,98.54 107.22,98.35 107.41,98.35 107.66,98.6 107.66,98.77 107.43,99 107.43,99.28 107.75,99.6 108.22,99.6 108.38,99.44 108.55,99.44 108.62,99.51 108.62,100.29 108.72,100.39 108.72,100.72 108.3,101.14 108.3,101.5 108.75,101.95 108.75,102.15 108.68,102.22 v2(108.46,102.22)
  IN1 w0.127: 106.17,98.01 105.58,97.42 105.58,84.14 102.15,80.72 101.97,80.72 100.46,82.23 100.05,82.23 99.62,81.8 99.62,81.4 101.14,79.88 101.14,79.7 100.87,79.43 100.69,79.43 99.17,80.95 98.77,80.95 98.34,80.52 98.34,80.11 99.49,78.96 99.49,78.78 99.23,78.51 99.05,78.51 97.89,79.67 97.48,79.67 92.64,74.83 79.39,74.83 78.43,73.87 77.63,73.87 75.7,71.94 75.7,71.16 75.54,71 75.54,70.87 75.41,70.73 75.23,70.73 75.12,70.84 v2(75.12,71.09)
  BOTTOM w0.076: v2(108.46,102.22) 108.46,102.34 108.13,102.67 107.64,102.67 107.4,102.92 107.4,106.42 107.58,106.6 107.83,106.6 107.89,106.67 107.89,106.8 UC1.AU37
  BOTTOM w0.102: JDIMM1.103 74.8,72.41 74.7,72.32 74.54,72.32 74.48,72.25 74.48,71.93 74.7,71.71 74.7,70.72 74.79,70.63 74.85,70.63 75.12,70.9 v2(75.12,71.09)
M_CLK_DDR#1: length 76.3
  IN1 w0.084: 107.03,97.01 107.03,97.16 109.17,99.29 109.17,100.06 109.31,100.2 109.31,103.3 108.99,103.61 108.99,104.75 108.83,104.92 108.63,104.92 v2(108.28,105.27)
  IN1 w0.127: v2(75.2,63.09) 75.2,62.88 75.03,62.71 74.78,62.71 74.58,62.92 74.58,64.31 74.76,64.49 76.41,64.49 76.69,64.78 76.69,65.82 76.41,66.11 75.28,66.11 75.15,66.24 75.15,67.44 75.28,67.57 76.5,67.57 76.93,68 76.93,71.5 78.12,72.69 78.92,72.69 79.88,73.65 93.28,73.65 96.96,77.33 100.44,77.33 106.75,83.64 106.75,96.74 107.03,97.01
  BOTTOM w0.076: UC1.AW36 108.61,105.59 v2(108.28,105.27)
  BOTTOM w0.102: v2(75.2,63.09) 75.28,63.01 75.28,62.85 75.15,62.73 74.88,62.73 74.73,62.88 74.73,64.09 74.83,64.19 74.96,64.19 75.1,64.33 JDIMM1.104
M_CLK_DDR#2: length 93.5
  IN3 w0.084: v2(107.25,109.68) 107.25,109.56 106.95,109.25 106.82,109.25 106.64,109.08 106.64,107.48 107.28,106.84 107.28,101.67 106.67,101.06 106.67,100.74 106.07,100.14 106.07,99.54 106.71,98.91 106.71,98.62 106.35,98.26 106.35,97.78
  IN3 w0.127: v2(153.37,69.59) 153.37,69.4 153.5,69.27 153.74,69.27 153.8,69.33 153.8,69.81 154,70.02 154,70.74 153.87,70.86 153.5,70.86 153.23,71.13 153.23,71.84 153.5,72.11 153.87,72.11 154,72.24 154,72.75 153.87,72.88 153.04,72.88 152.73,73.19 152.73,73.6 152.95,73.81 152.95,74.05 152.82,74.17 151.97,74.17 151.39,74.75 151.39,75.46 149.92,76.92 123.56,76.92 123.24,77.25 123.24,78.81 123.1,78.94 122.7,78.94 122.57,78.81 122.57,77.19 122.3,76.92 121.67,76.92 121.41,77.19 121.41,78.81 121.27,78.94 120.87,78.94 120.73,78.81 120.73,78.12 120.46,77.85 119.84,77.85 119.57,78.12 119.57,78.81 119.44,78.94 118.75,78.94 106.35,91.34 106.35,97.78
  BOTTOM w0.076: v2(107.25,109.68) 107.5,109.68 107.64,109.83 UC1.AM38
  BOTTOM w0.102: v2(153.37,69.59) 153.37,69.38 153.22,69.23 153.09,69.23 152.97,69.35 152.97,71.9 153.35,72.28 JDIMM2.103
M_CLK_DDR#3: length 92
  IN3 w0.084: v2(107.25,110.98) 107.25,110.77 107.15,110.67 107.03,110.67 106.78,110.92 106.33,110.92 105.98,110.56 105.98,110.03 106.27,109.73 106.27,107.24 106.06,107.02 106.06,100.98 105.47,100.39 105.47,96.07 105.46,96.06 105.46,95.67
  IN3 w0.127: 105.46,95.67 105.46,90.97 105.46,90.97 105.46,90.95 120.38,76.03 148.78,76.03 149.56,76.03 150.5,75.09 150.5,74.33 151.64,73.18 151.64,72.63 152.3,71.97 152.3,65.94 154.33,63.91 154.33,62.9 154.22,62.78 153.89,62.78 153.75,62.92 v2(153.75,63.13)
  BOTTOM w0.076: v2(107.25,110.98) 107.4,110.98 107.67,111.25 UC1.AK38
  BOTTOM w0.102: v2(153.75,63.13) 153.75,62.89 153.63,62.77 153.46,62.77 153.34,62.88 153.34,64.06 153.65,64.36 JDIMM2.104
M_ODT:
  vias: v1(84.77,59.56)
M_ODT0: length 14.6
  TOP w0.165: R2348.2 86.07,57.15 86.33,57.41 v2(86.33,58.68)
  IN1 w0.183: v2(79.66,61.18) 81.84,61.18 84.91,58.11 85.75,58.11 v2(86.33,58.68)
  BOTTOM w0.165: JDIMM1.116 78.7,63.9 78.83,63.77 78.83,62.01 v2(79.66,61.18)
M_ODT1: length 11.2
  TOP w0.165: R2349.2 v2(85.68,58.68)
  IN1 w0.183: v2(79.66,62.71) 80.93,62.71 85.04,58.6 85.61,58.6 v2(85.68,58.68)
  BOTTOM w0.165: JDIMM1.120 79.9,63.87 80.1,63.67 80.1,63.15 v2(79.66,62.71)
M_ODT2: length 86.4
  TOP w0.165: R2350.2 v1(88.46,53.49) 90.08,51.87 111.12,51.87 112.27,53.01 115.28,53.01 v2(115.73,52.57)
  IN1 w0.183: v2(115.73,52.57) 117.81,50.48 150.29,50.48 154.33,54.52 154.33,57.13 154.33,57.14 154.33,58.82 v2(157.55,62.04)
  BOTTOM w0.165: JDIMM2.116 157.25,64.19 157.48,63.96 157.74,63.96 158.02,63.68 158.02,62.5 v2(157.55,62.04)
M_ODT3: length 87
  TOP w0.165: v2(115.09,52.57) 113.97,51.45 89.61,51.45 R2352.2
  IN1 w0.183: v2(157.55,60.51) 157.06,60.03 156.16,60.03 154.77,58.64 154.77,54.34 150.47,50.04 117.62,50.04 v2(115.09,52.57)
  BOTTOM w0.165: JDIMM2.120 158.45,63.91 158.45,63.91 158.45,61.41 v2(157.55,60.51)
MAA0_0: length 31.7
  TOP w0.102: UV5.K4 167.94,152.46 v2(168.3,152.1)
  IN3 w0.102: 177.07,137.4 177.07,135.88 177.32,135.62 177.32,134.1 176.54,133.32 176.54,132.86 v2(177.22,132.18) ; 172.05,151.59 168.81,151.59 v2(168.3,152.1)
  IN3 w0.157: 177.07,137.4 177.07,150.42 175.71,151.78 174.39,151.78 174.2,151.59 172.05,151.59
  BOTTOM w0.102: v2(177.22,132.18) 177.12,132.28 175.84,132.28 UV1.G24 ; UV5.K4 167.94,152.46 v2(168.3,152.1)
MAA0_1: length 30
  TOP w0.102: UV5.K5 167.88,151.14 v2(167.97,151.05)
  IN3 w0.102: v2(176.05,131.18) 175.48,131.75 175.48,132.51 174.84,133.15 174.84,134.61 174.13,135.33 174.13,137.15 ; v2(167.97,151.05) 167.97,150.55 168.86,149.66 173.38,149.66 174.3,148.74 174.3,145.34 174.67,144.97 174.67,143.36
  IN3 w0.157: 174.67,143.36 174.13,142.81 174.13,139.94 174.28,139.78 174.79,139.78 174.91,139.65 174.91,139.27 174.79,139.15 174.28,139.15 174.13,138.99 174.13,137.15
  BOTTOM w0.102: v2(167.97,151.05) 167.88,151.14 UV5.K5 ; v2(176.05,131.18) 176.66,130.57 UV1.J23
MAA0_2: length 29.5
  TOP w0.102: UV5.K11 v2(167.48,147.26)
  IN3 w0.102: v2(174.97,131.69) 174.57,132.09 174.57,134.16 173.63,135.1 173.63,136.64 ; 173.87,143.5 173.87,144.48 173.47,144.88 173.47,148.43 172.81,149.09 168.43,149.09 167.86,148.52 167.86,147.63 167.49,147.26 v2(167.48,147.26)
  IN3 w0.157: 173.63,136.64 173.63,136.64 173.63,140.35 173.47,140.51 173.37,140.51 173.25,140.63 173.25,141.01 173.37,141.14 173.47,141.14 173.63,141.29 173.63,141.61 173.47,141.77 172.59,141.77 172.46,141.89 172.46,142.27 172.59,142.4 173.47,142.4 173.63,142.55 173.63,143.1 173.87,143.34 173.87,143.5
  BOTTOM w0.102: UV1.H24 175.46,131.2 v2(174.97,131.69) ; UV5.K11 v2(167.48,147.26)
MAA0_3: length 29.6
  TOP w0.102: UV5.K10 167.92,147.66 v2(168.3,148.04)
  IN3 w0.102: 172.87,143.36 173.07,143.56 173.07,145.66 172.69,146.04 172.69,148.26 172.37,148.58 168.81,148.58 168.3,148.07 v2(168.3,148.04) ; v2(176.05,130.61) 175.35,131.31 174.58,131.31 174.29,131.6 174.29,131.93 174.29,134.02 172.69,135.62 172.69,137.4
  IN3 w0.157: 172.87,143.36 171.87,142.36 171.87,141.63 171.99,141.5 172.17,141.5 172.3,141.37 172.3,141 172.17,140.87 171.99,140.87 171.87,140.74 171.87,140.33 171.99,140.21 172.95,140.21 173.08,140.08 173.08,139.7 172.95,139.58 172.62,139.58 172.49,139.45 172.49,139.11 172.62,138.98 173.02,138.98 173.14,138.85 173.14,138.48 173.02,138.35 172.88,138.35 172.69,138.16 172.69,137.4
  BOTTOM w0.102: UV5.K10 167.92,147.66 v2(168.3,148.04) ; UV1.J24 175.74,130.3 v2(176.05,130.61)
MAA0_4: length 30.1
  TOP w0.102: UV5.H11 v2(169.88,147.26)
  IN3 w0.102: 170.03,137.4 170.34,137.09 170.84,137.09 171.86,136.07 171.86,135.43 172.94,134.35 172.94,132.96 173.31,132.59 173.31,132.08 v2(173.7,131.69) ; v2(169.88,147.26) 170.07,147.26 171.11,146.22 171.11,145.39 171.5,145 171.5,143.49 171.38,143.36
  IN3 w0.157: 171.38,143.36 171.08,143.07 170.85,143.07 169.78,142 169.78,141.44 169.63,141.28 167.99,141.28 167.86,141.15 167.86,140.78 167.99,140.65 169.63,140.65 169.78,140.49 169.78,140.18 169.63,140.02 166.97,140.02 166.84,139.89 166.84,139.52 166.97,139.39 169.63,139.39 169.91,139.11 169.91,137.52 170.03,137.4
  BOTTOM w0.102: UV5.H11 v2(169.88,147.26) ; UV1.H26 174.26,131.13 v2(173.7,131.69)
MAA0_5: length 30
  TOP w0.102: UV5.H10 v2(169.88,148.06)
  IN3 w0.102: v2(169.88,148.06) 170.27,147.68 171.62,147.68 172.24,147.05 172.24,145.78 172.3,145.72 172.3,143.56 172.1,143.36 ; 172.2,137.4 172.2,137.38 172.3,137.28 172.3,135.69 174.08,133.91 174.08,131.85 174.08,131.85 174.08,131.53 174.08,131.53 174.08,131.37 174.21,131.24 174.22,131.24 174.53,130.93 v2(174.91,130.93)
  IN3 w0.157: 172.2,137.4 172.2,137.91 172.07,138.04 170.63,138.04 170.51,138.16 170.51,138.56 170.63,138.69 171.88,138.69 172.01,138.82 172.01,139.19 171.88,139.32 170.4,139.32 170.27,139.45 170.27,140.32 170.4,140.45 171.25,140.45 171.38,140.58 171.38,141.08 171.22,141.24 170.4,141.24 170.27,141.37 170.27,141.74 170.4,141.87 171.22,141.87 171.38,142.03 171.38,142.64 172.1,143.36
  BOTTOM w0.102: UV5.H10 v2(169.88,148.06) ; UV1.J26 174.28,130.3 v2(174.91,130.93)
MAA0_6: length 30.3
  TOP w0.102: UV5.H5 169.49,151.51 v2(169.81,151.18)
  IN3 w0.102: 176.5,137.4 176.5,136.73 176.24,136.47 176.24,134.93 176.56,134.61 176.56,133.72 176.34,133.5 176.34,132.73 176.84,132.23 176.84,131.82 v2(177.13,131.53)
  IN3 w0.157: 176.5,137.4 176.5,141.32 176.34,141.48 175.83,141.48 175.67,141.63 175.67,141.95 175.83,142.11 176.34,142.11 176.5,142.26 176.5,149.4 175.99,149.91 175.99,150.14 176.26,150.41 176.26,150.54 175.94,150.86 175.82,150.86 175.54,150.58 175.32,150.58 175.13,150.77 170.23,150.77 v2(169.81,151.18)
  BOTTOM w0.102: v2(177.13,131.53) 177.56,131.1 UV1.H21 ; UV5.H5 169.49,151.51 v2(169.81,151.18)
MAA0_7: length 34.2
  TOP w0.102: UV5.H4 169.48,152.46 v2(169.08,152.86)
  IN3 w0.102: v2(169.08,152.86) 169.08,152.92 169.45,153.28 169.45,153.81 169.71,154.08 170.04,154.08 170.64,154.67 175.11,154.67 175.43,154.35 ; v2(178.46,132.4) 177.93,132.93 177.93,133.56 178.14,133.77 178.14,135.04 178.78,135.68 178.78,136.92 179.25,137.4
  IN3 w0.157: 179.25,137.4 179.25,151.08 177.88,152.44 176.59,153.74 175.91,154.42 175.84,154.42 175.78,154.35 175.43,154.35
  BOTTOM w0.102: UV5.H4 169.48,152.46 v2(169.08,152.86) ; UV1.G21 177.97,131.9 v2(178.46,132.4)
MAA0_8: length 29.4
  TOP w0.102: v2(168.94,151.12) 168.68,151.37 UV5.J5
  IN3 w0.102: 174.46,150.36 169.7,150.36 v2(168.94,151.12) ; v2(177.17,130.93) 176.64,131.46 176.64,132.14 176.05,132.73 176.05,133.5 175.8,133.75 175.8,136.51 175.99,136.7 175.99,137.4
  IN3 w0.157: 175.99,137.4 175.99,140.84 175.86,140.96 175.26,140.96 175.1,141.12 175.1,142.39 175.9,143.18 175.9,148.92 174.46,150.36
  BOTTOM w0.102: UV5.J5 168.68,151.37 v2(168.94,151.12) ; UV1.H23 176.99,131.1 v2(177.17,130.93)
MAA1_0: length 30.4
  TOP w0.102: v2(188.75,151.18) 188.75,152.04 UV3.K4
  IN3 w0.102: 182.31,137.4 182.04,137.13 181.97,137.13 180.25,135.41 180.25,133.79 180.81,133.24 180.81,132.92 180.25,132.36 180.25,131.62 v2(179.68,131.06) ; v2(188.75,151.18) 187.6,150.03 183.66,150.03 182.13,148.49
  IN3 w0.157: 182.13,148.49 181.81,148.18 181.81,140.21 182.31,139.72 182.31,137.4
  BOTTOM w0.102: UV3.K4 188.75,152.04 v2(188.75,151.18) ; UV1.H19 179.73,131.1 v2(179.68,131.06)
MAA1_1: length 29.6
  TOP w0.102: UV3.K5 188.37,151.59 187.99,151.98 v2(187.99,152.01)
  IN3 w0.102: v2(178.59,131.5) 179.05,131.96 179.05,135.38 179.18,135.51 179.18,136.34 180.24,137.4 ; v2(187.99,152.01) 187.59,152.4 183.68,152.4 183.04,151.75 182.52,151.75 182.13,151.36
  IN3 w0.157: 180.24,137.4 180.24,149.47 182.13,151.36
  BOTTOM w0.102: v2(187.99,152.01) 187.99,151.98 188.37,151.59 UV3.K5 ; v2(178.59,131.5) 178.99,131.1 UV1.H20
MAA1_2: length 27.8
  TOP w0.102: UV3.K11 188.4,146.8 v2(188.79,147.19)
  IN3 w0.102: 186.27,137.4 186.27,137.19 185.25,136.17 185.25,135.32 184.65,134.72 184.65,133.92 184.31,133.58 184.31,132.83 183.73,132.26 183.73,131.75 183.29,131.31 v2(183.29,130.74) ; 188.1,143.3 187.98,143.42 187.98,143.99 187.61,144.35 187.61,146.74 188.04,147.17 188.77,147.17 v2(188.79,147.19)
  IN3 w0.157: 186.27,137.4 186.27,137.51 186.95,138.2 186.95,138.84 187.2,139.09 188.04,139.09 188.14,139.18 188.14,139.47 188.29,139.63 189.34,139.63 189.47,139.75 189.47,140.13 189.34,140.26 188.29,140.26 188.14,140.41 188.14,140.73 188.29,140.89 188.97,140.89 189.1,141.01 189.1,141.39 188.97,141.52 188.29,141.52 188.14,141.67 188.14,143.26 188.1,143.3
  BOTTOM w0.102: UV3.K11 188.4,146.8 v2(188.79,147.19) ; UV1.L13 184.44,128.7 183.99,129.14 183.72,129.14 183.51,129.35 183.51,130.52 v2(183.29,130.74)
MAA1_3: length 25.9
  TOP w0.102: UV3.K10 188.4,147.63 188.04,147.98 v2(188.01,147.98)
  IN3 w0.102: 184.78,137.4 184.78,137.19 183.95,136.36 183.95,134.08 183.6,133.73 182.73,133.73 182.5,133.5 182.5,132.93 182.11,132.54 v2(182.11,132.3) ; 185.58,143.3 185.58,147.44 186.01,147.87 186.01,148.4 186.14,148.53 187.89,148.53 188.01,148.4 v2(188.01,147.98)
  IN3 w0.157: 184.78,137.4 184.78,141.72 184.91,141.85 186.27,141.85 186.4,141.97 186.4,142.35 186.27,142.48 184.91,142.48 184.78,142.6 184.78,142.98 184.91,143.11 185.45,143.11 185.58,143.23 185.58,143.3
  BOTTOM w0.102: UV1.G16 182.51,131.9 v2(182.11,132.3) ; v2(188.01,147.98) 188.04,147.98 188.4,147.63 UV3.K10
MAA1_4: length 26.3
  TOP w0.102: v2(189.59,147.19) 189.6,147.19 UV3.H11
  IN3 w0.102: 185.77,137.4 185.77,137.19 185.04,136.46 185.04,135.4 184.45,134.81 184.45,134.01 184.07,133.63 184.07,132.88 183.84,132.66 183.18,132.66 182.79,132.27 182.79,131.78 v2(182.11,131.1) ; 187.45,143.3 187.18,143.57 187.18,146.64 187.91,147.37 188.23,147.37 188.47,147.61 189.18,147.61 v2(189.59,147.19)
  IN3 w0.157: 187.45,143.3 187.65,143.1 187.65,141.06 187.52,140.94 187.28,140.94 187.15,140.81 187.15,140.43 187.28,140.31 187.52,140.31 187.65,140.18 187.65,139.7 187.52,139.58 185.9,139.58 185.77,139.45 185.77,139.07 185.9,138.95 186.34,138.95 186.46,138.82 186.46,138.44 186.34,138.32 185.9,138.32 185.77,138.19 185.77,137.4
  BOTTOM w0.102: v2(189.59,147.19) 189.6,147.19 UV3.H11 ; v2(182.11,131.1) 182.66,130.55 UV1.J16
MAA1_5: length 26.7
  TOP w0.102: UV3.H10 189.6,147.99 v2(189.59,147.99)
  IN3 w0.102: v2(182.11,131.7) 182.59,132.18 182.59,132.36 183.31,133.07 183.31,133.31 183.46,133.47 183.62,133.47 184.24,134.09 184.24,136.16 185.28,137.19 185.28,137.4 ; 186.38,143.3 186.38,144.81 186.81,145.24 186.81,147.35 187.04,147.58 188.15,147.58 188.44,147.87 188.44,148.15 188.66,148.37 189.21,148.37 v2(189.59,147.99)
  IN3 w0.157: 185.28,137.4 185.28,138.07 185.27,138.07 185.27,139.94 185.4,140.06 186.08,140.06 186.21,140.19 186.21,140.57 186.08,140.69 185.4,140.69 185.27,140.82 185.27,141.23 185.4,141.36 187.03,141.36 187.16,141.49 187.16,142.79 187.03,142.93 186.53,142.93 186.38,143.08 186.38,143.3
  BOTTOM w0.102: UV1.H16 182.66,131.15 v2(182.11,131.7) ; UV3.H10 189.6,147.99 v2(189.59,147.99)
MAA1_6: length 29.9
  TOP w0.102: UV3.H5 190.32,151.27 v2(190.32,150.29)
  IN3 w0.102: 183.79,143.3 183.79,143.45 183.98,143.64 183.98,145.06 184.57,145.65 184.57,146.08 184.41,146.24 184.41,148.15 184.57,148.31 184.57,148.44 185.46,149.33 189.36,149.33 v2(190.32,150.29) ; 183.79,137.4 183.79,137.19 182.96,136.36 182.96,134.57 182.69,134.3 181.81,134.3 181.57,134.06 181.57,133.67 181.47,133.57 181.47,131.57 180.9,131 v2(180.9,130.92)
  IN3 w0.157: 183.79,143.3 183.79,137.4
  BOTTOM w0.102: v2(180.9,130.92) 181.46,130.35 UV1.J17 ; UV3.H5 190.32,151.27 v2(190.32,150.29)
MAA1_7: length 29.5
  TOP w0.102: UV3.H4 190.38,152.01 v2(190.4,152.01)
  IN3 w0.102: 183.3,143.3 183.21,143.38 183.21,145.07 183.58,145.44 183.58,146.55 183.38,146.74 183.38,147.63 183.61,147.85 183.61,148.2 184.94,149.53 188.62,149.53 189.96,150.86 189.96,151.57 v2(190.4,152.01) ; 183.3,137.4 183.3,137.23 182.34,136.28 182.34,135.47 182.05,135.17 181.76,135.17 181.36,134.78 181.36,133.75 181.26,133.66 181.26,131.91 v2(180.89,131.53)
  IN3 w0.157: 183.3,137.4 183.3,143.3
  BOTTOM w0.102: v2(180.89,131.53) 181.61,131.53 181.74,131.4 181.74,131.23 181.61,131.1 UV1.H17 ; v2(190.4,152.01) 190.38,152.01 UV3.H4
MAA1_8: length 30.6
  TOP w0.102: UV3.J5 189.2,151.5 v2(189.58,151.12)
  IN3 w0.102: v2(179.67,130.47) 179.67,130.48 180.45,131.26 180.45,132.28 181.01,132.84 181.01,133.32 180.45,133.88 180.45,135.32 182.06,136.93 182.33,136.93 182.8,137.4 ; 182.31,143.3 182.31,148.02 182.59,148.3 182.59,148.51 183.91,149.82 188.28,149.82 v2(189.58,151.12)
  IN3 w0.157: 182.31,143.3 182.31,140.42 182.8,139.92 182.8,137.4
  BOTTOM w0.102: UV1.J19 180.26,130.56 180.14,130.69 179.89,130.69 v2(179.67,130.47) ; v2(189.58,151.12) 189.2,151.5 UV3.J5
MAB0_0: length 34
  TOP w0.102: UV7.K4 212.76,135.86 v2(212.4,135.5)
  IN3 w0.102: 211.89,131.76 211.89,134.99 v2(212.4,135.5) ; 194.39,125.59 194.3,125.68 193.55,125.68 193.19,126.05 190.41,126.05 189.72,125.35 v2(189.38,125.35)
  IN3 w0.157: 211.89,131.76 211.89,129.6 212.08,129.41 212.08,128.1 210.72,126.73 201.7,126.73 200.56,125.59 194.39,125.59
  BOTTOM w0.102: UV1.P8 188.86,125.87 v2(189.38,125.35) ; UV7.K4 212.76,135.86 v2(212.4,135.5)
MAB0_1: length 32.9
  TOP w0.102: UV7.K5 211.44,135.92 v2(211.36,135.83)
  IN3 w0.102: 194.39,128.12 192.55,128.12 191.29,126.86 189.6,126.86 189.51,126.95 189.19,126.95 188.97,126.73 188.81,126.73 188.68,126.6 188.68,126.6 188.46,126.38 188.46,126.38 187.61,125.53 v2(187.54,125.53) ; 203.66,129.13 205.27,129.13 205.64,129.5 209.04,129.5 209.96,130.42 209.96,134.95 210.85,135.83 v2(211.36,135.83)
  IN3 w0.157: 203.66,129.13 201.33,129.13 200.32,128.12 194.39,128.12
  BOTTOM w0.102: v2(211.36,135.83) 211.44,135.92 UV7.K5 ; v2(187.54,125.53) 188.06,125.01 UV1.T9
MAB0_2: length 31.6
  TOP w0.102: v2(207.56,136.32) 207.16,135.92 UV7.K11
  IN3 w0.102: v2(188.3,126.76) 188.79,127.24 190.25,127.24 190.83,127.82 190.99,127.82 191.55,128.38 194.07,128.38 194.3,128.61 194.39,128.61 ; v2(207.56,136.32) 207.56,136.31 207.93,135.94 208.82,135.94 209.39,135.37 209.39,130.61 209.12,130.34 205.18,130.34 204.78,129.93 203.88,129.93 203.8,129.86 203.66,129.86
  IN3 w0.157: 203.66,129.86 201.38,129.86 200.13,128.61 194.39,128.61
  BOTTOM w0.102: UV1.P9 188.3,126.34 v2(188.3,126.76) ; UV7.K11 207.16,135.92 v2(207.56,136.32)
MAB0_3: length 31.4
  TOP w0.102: v2(208.35,135.5) 207.96,135.88 UV7.K10
  IN3 w0.102: v2(208.35,135.5) 207.98,135.13 207.98,132.18 207.36,131.56 206.09,131.56 206.02,131.5 203.66,131.5 ; 194.39,129.6 192.13,129.6 191.48,128.96 191.15,128.96 190.06,127.87 v2(189.9,127.87)
  IN3 w0.157: 203.66,131.5 203.55,131.5 203.42,131.37 203.42,130.97 203.29,130.84 202.85,130.84 202.72,130.97 202.72,131.75 202.59,131.88 202.13,131.88 202.01,131.75 202.01,130.97 201.88,130.84 201.5,130.84 201.38,130.97 201.38,131.76 201.25,131.88 200.63,131.88 200.5,131.76 200.5,131.56 200.37,131.43 199.26,131.43 198.66,130.84 197.37,130.84 197.13,130.61 197.13,129.73 197.01,129.6 196.63,129.6 196.5,129.73 196.5,130.76 196.38,130.89 196,130.89 195.87,130.76 195.87,129.73 195.75,129.6 194.39,129.6
  BOTTOM w0.102: UV1.N7 189.66,127.63 v2(189.9,127.87) ; UV7.K10 207.96,135.88 v2(208.35,135.5)
MAB0_4: length 31.4
  TOP w0.102: UV7.H11 v2(207.56,133.92)
  IN3 w0.102: 203.66,132.42 203.79,132.3 205.3,132.3 205.69,132.69 206.52,132.69 207.56,133.73 v2(207.56,133.92) ; 194.39,130.1 192.12,130.1 191.32,129.3 191.21,129.3 190.15,128.25 189.74,128.25 189.39,127.9 v2(189.24,127.9)
  IN3 w0.157: 194.39,130.1 194.52,130.1 195.8,131.38 196.51,131.38 196.68,131.55 196.68,133.97 196.81,134.1 197.18,134.1 197.31,133.97 197.31,131.46 197.44,131.33 197.81,131.33 197.94,131.46 197.94,132.89 198.07,133.02 198.44,133.02 198.57,132.89 198.57,132.01 198.7,131.89 199.07,131.89 199.2,132.01 199.2,132.88 199.33,133.01 201.09,133.01 201.44,132.66 203.43,132.66 203.66,132.42
  BOTTOM w0.102: v2(189.24,127.9) 188.86,127.52 UV1.N8 ; UV7.H11 v2(207.56,133.92)
MAB0_5: length 31.9
  TOP w0.102: UV7.H10 v2(208.36,133.92)
  IN3 w0.102: 194.39,129.11 194.36,129.14 192.02,129.14 190.91,128.03 190.69,128.03 190.15,127.49 188.99,127.49 v2(188.56,127.92) ; 203.66,130.47 203.93,130.74 205.96,130.74 206.34,131.12 208.56,131.12 208.88,131.43 208.88,133.4 v2(208.36,133.92)
  IN3 w0.157: 203.66,130.47 203.55,130.35 200.29,130.35 200.16,130.23 200.16,129.33 200.03,129.21 199.66,129.21 199.53,129.33 199.53,130.39 199.4,130.51 199.03,130.51 198.9,130.39 198.9,129.23 198.77,129.1 198.4,129.1 198.27,129.23 198.27,130.23 198.14,130.35 197.77,130.35 197.64,130.23 197.64,129.24 197.51,129.11 194.39,129.11
  BOTTOM w0.102: v2(188.56,127.92) 188.06,127.42 UV1.N9 ; UV7.H10 v2(208.36,133.92)
MAB0_6: length 32.5
  TOP w0.102: UV7.H5 211.81,134.32 v2(211.48,133.99)
  IN3 w0.102: v2(188.06,124.33) 188.94,125.21 188.94,125.5 189.23,125.78 189.86,125.78 190.33,126.25 194.23,126.25 194.39,126.09
  IN3 w0.157: v2(211.48,133.99) 211.07,133.58 211.07,128.67 209.71,127.31 201.58,127.31 200.36,126.09 194.39,126.09
  BOTTOM w0.102: UV1.U9 v2(188.06,124.33) ; v2(211.48,133.99) 211.81,134.32 UV7.H5
MAB0_7: length 37.7
  TOP w0.102: UV7.H4 212.76,134.32 v2(213.16,134.72)
  IN3 w0.102: v2(213.16,134.72) 213.22,134.72 213.59,134.35 214.11,134.35 214.38,134.09 214.38,133.76 214.98,133.16 214.98,128.69 214.66,128.37 214.66,127.96 ; 194.39,123.31 194.16,123.31 194.09,123.37 193.23,123.37 192.91,123.05 191.54,123.05 191.26,122.77 189.54,122.77 v2(189.13,123.18)
  IN3 w0.157: 214.66,127.96 214.66,127.83 212.75,125.92 211.38,124.55 202.32,124.55 201.07,123.31 194.39,123.31
  BOTTOM w0.102: v2(189.13,123.18) 188.86,123.45 UV1.U8 ; UV7.H4 212.76,134.32 v2(213.16,134.72)
MAB0_8: length 31.7
  TOP w0.102: v2(211.42,134.86) 211.67,135.12 UV7.J5
  IN3 w0.102: 209.28,127.96 210.66,129.34 210.66,134.1 v2(211.42,134.86) ; v2(188.43,125.4) 188.56,125.4 189.14,125.99 189.59,125.99 190.06,126.46 191.79,126.46 191.99,126.65 193.68,126.65 193.71,126.68 194.39,126.68
  IN3 w0.157: 209.28,127.96 209.22,127.9 201.49,127.9 200.27,126.68 194.39,126.68
  BOTTOM w0.102: UV1.T8 188.86,124.97 v2(188.43,125.4) ; UV7.J5 211.67,135.12 v2(211.42,134.86)
MAB1_0: length 32.2
  TOP w0.102: v2(211.17,114.92) 211.41,115.16 212.21,115.16 UV9.K4
  IN3 w0.102: v2(211.17,114.92) 209.71,116.38 209.71,118.73 208.84,119.6 208.84,119.84 208.37,120.31 208.02,120.31 207.8,120.53 206.92,120.53 206.73,120.34 205.61,120.34 205.25,120.7 203.56,120.7 203.47,120.62 ; v2(188.48,120.53) 188.89,120.94 190.16,120.94 190.47,120.63 190.47,120.38 190.99,119.86 193.13,119.86 193.22,119.77 194.39,119.77
  IN3 w0.157: 194.39,119.77 202.63,119.77 203.47,120.62
  BOTTOM w0.102: v2(211.17,114.92) 211.41,115.16 212.21,115.16 UV9.K4 ; UV1.Y9 188.06,120.95 v2(188.48,120.53)
MAB1_1: length 32.9
  TOP w0.102: UV9.K5 211.78,115.52 v2(212.18,115.93)
  IN3 w0.102: 211.24,121.79 211.93,121.1 211.93,120.36 211.75,120.18 211.75,116.86 211.74,116.85 211.74,116.37 v2(212.18,115.93) ; v2(188.26,121.92) 188.7,122.36 191.43,122.36 191.63,122.57 192.98,122.57 193.14,122.4 193.15,122.4 193.17,122.38 193.69,122.38 193.74,122.34 193.86,122.21 194.39,122.21
  IN3 w0.157: 194.39,122.21 201.38,122.21 202.65,123.48 209.54,123.48 211.24,121.79
  BOTTOM w0.102: v2(188.26,121.92) 188.06,122.12 UV1.W9 ; UV9.K5 211.78,115.52 v2(212.18,115.93)
MAB1_2: length 28.2
  TOP w0.102: UV9.K11 v2(207.37,115.12)
  IN3 w0.102: v2(207.37,115.12) 207.37,115.38 207.74,115.74 207.74,116.19 207.61,116.32 207.23,116.32 206.81,116.74 203.74,116.74 203.71,116.76 203.47,116.76 ; v2(189.13,118.42) 189.51,118.8 190.15,118.8 190.79,118.15 191.63,118.15 192.99,116.79 194.39,116.79
  IN3 w0.157: 203.47,116.76 203.03,117.21 201.51,117.21 201.39,117.08 201.39,116.32 201.26,116.19 200.87,116.19 200.74,116.32 200.74,116.64 200.62,116.77 200.24,116.77 200.11,116.64 200.11,115.28 199.99,115.16 199.61,115.16 199.48,115.28 199.48,116.09 199.36,116.21 198.98,116.21 198.85,116.09 198.85,115.28 198.73,115.16 197.03,115.16 195.39,116.79 194.39,116.79
  BOTTOM w0.102: v2(189.13,118.42) 189.11,118.42 188.86,118.66 UV1.AC8 ; UV9.K11 v2(207.37,115.12)
MAB1_3: length 36.5
  TOP w0.102: UV9.K10 207.74,115.52 v2(207.36,115.9)
  IN3 w0.102: v2(188.46,118.4) 188.9,117.95 191.47,117.95 192.42,117 192.42,116.54 193.45,115.51 194.39,115.51 ; 203.47,115.94 204.16,115.94 204.52,116.3 206.87,116.3 207.27,115.9 v2(207.36,115.9)
  IN3 w0.157: 203.47,115.94 203.1,115.94 202.94,116.1 202.94,116.59 202.81,116.72 202.44,116.72 202.31,116.59 202.31,116.07 202.02,115.78 202.02,114.89 201.9,114.76 201.5,114.76 201.38,114.89 201.38,115.58 201.25,115.71 200.87,115.71 200.75,115.58 200.75,114.83 200.59,114.67 199.5,114.67 199.34,114.51 199.34,112.38 199.21,112.26 198.84,112.26 198.71,112.38 198.71,114.51 198.55,114.67 198.24,114.67 198.08,114.51 198.08,112 197.95,111.88 197.58,111.88 197.45,112 197.45,114.51 197.29,114.67 196.83,114.67 195.99,115.51 194.39,115.51
  BOTTOM w0.102: v2(207.36,115.9) 207.74,115.52 UV9.K10 ; UV1.AC9 188.46,118.51 v2(188.46,118.4)
