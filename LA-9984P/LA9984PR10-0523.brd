# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
MAB1_4: length 28.6
  TOP w0.102: UV9.H11 206.97,113.92 v2(207.37,114.32)
  IN3 w0.102: v2(189.93,119.36) 190.3,118.99 192.21,118.99 193.38,117.82 194.39,117.82 ; v2(207.37,114.32) 207.79,114.74 207.79,115.25 207.94,115.41 207.94,116.45 207.77,116.62 207.77,116.86 207.53,117.1 205.42,117.1 204.98,117.54 203.47,117.54
  IN3 w0.157: 194.39,117.82 195.76,117.82 195.99,117.59 195.99,116.89 197.23,115.64 198.24,115.64 198.37,115.77 198.37,117.57 198.49,117.69 198.87,117.69 199,117.57 199,116.83 199.12,116.7 199.5,116.7 199.63,116.83 199.63,117.57 199.75,117.69 203.32,117.69 203.47,117.54
  BOTTOM w0.102: UV1.AA7 189.93,119.83 v2(189.93,119.36) ; v2(207.37,114.32) 206.97,113.92 UV9.H11
MAB1_5: length 29.7
  TOP w0.102: v2(208.17,114.32) 207.77,113.92 UV9.H10
  IN3 w0.102: v2(189.26,119.36) 189.64,119.74 190.09,119.74 190.59,119.24 192.25,119.24 193.18,118.31 194.39,118.31 ; v2(208.17,114.32) 208.55,114.7 208.55,117.68 208.33,117.9 208.05,117.9 207.65,118.3 203.75,118.3 203.63,118.18 203.47,118.18
  IN3 w0.157: 194.39,118.31 197.12,118.31 197.25,118.18 197.25,116.32 197.38,116.19 197.75,116.19 197.88,116.32 197.88,118.03 198.04,118.18 203.47,118.18
  BOTTOM w0.102: v2(189.26,119.36) 189.26,119.7 188.86,120.1 UV1.AA8 ; UV9.H10 207.77,113.92 v2(208.17,114.32)
MAB1_6: length 30.9
  TOP w0.102: UV9.H5 211.44,113.6 v2(210.47,113.6)
  IN3 w0.102: 194.39,119.29 193.13,119.29 192.77,119.65 190.76,119.65 190.26,120.15 189.58,120.15 189.2,120.52 v2(189.2,120.53) ; 203.47,119.87 203.55,119.94 205.24,119.94 205.83,119.35 206.26,119.35 206.41,119.5 208.46,119.5 209.5,118.46 209.5,114.56 v2(210.47,113.6)
  IN3 w0.157: 194.39,119.29 202.89,119.29 203.47,119.87
  BOTTOM w0.102: UV9.H5 211.44,113.6 v2(210.47,113.6) ; UV1.Y8 189.2,120.96 v2(189.2,120.53)
MAB1_7: length 31.4
  TOP w0.102: v2(212.19,113.52) 212.57,113.9 UV9.H4
  IN3 w0.102: 203.47,119.14 204.13,119.14 204.56,118.7 208.33,118.7 209.3,117.73 209.3,113.92 210.08,113.14 211.8,113.14 v2(212.19,113.52) ; v2(188.56,119.4) 189.11,119.95 190.17,119.95 190.67,119.44 192.5,119.44 193.15,118.8 194.39,118.8
  IN3 w0.157: 203.47,119.14 203.44,119.14 203.1,118.8 194.39,118.8
  BOTTOM w0.102: v2(188.56,119.4) 188.06,119.9 UV1.AA9 ; v2(212.19,113.52) 212.57,113.9 UV9.H4
MAB1_8: length 31.7
  TOP w0.102: UV9.J5 211.84,114.72 v2(212.22,114.34)
  IN3 w0.102: 194.39,120.75 193.4,120.75 193.07,121.08 192.27,121.08 191.99,121.36 191.51,121.36 191.3,121.15 190.53,121.15 190.31,121.36 189.62,121.36 v2(189.24,121.75) ; 208.67,121.79 210.2,120.26 210.2,116.79 212.22,114.77 v2(212.22,114.34)
  IN3 w0.157: 208.67,121.79 208.46,122 203.27,122 202.02,120.75 194.39,120.75
  BOTTOM w0.102: UV9.J5 211.84,114.72 v2(212.22,114.34) ; v2(189.24,121.75) 189.24,122.13 UV1.W8
MCT0: length 4.9
  TOP w0.102: RL19.1 v1(20.29,89.49)
  TOP w0.254: v2(19.49,88.13) 19.55,88.06 RL19.1
  BOTTOM w0.254: TL1.14 v2(19.49,88.13)
MCT1: length 3.4
  TOP w0.254: RL20.1 19.55,84.25 v2(19.49,84.32)
  BOTTOM w0.254: TL1.11 v1(20.18,84.32) v2(19.49,84.32)
MDI0+: length 8.4
  BOTTOM w0.102: UL1.1 35.22,86.54 35.21,86.53 34.38,86.53 33.96,86.11 33.96,85.18 33.46,84.67 33.46,82.96 v3(33,82.5) 32.7,82.21 32.21,82.21 32.11,82.11 32.11,81.88 32.01,81.78 TL1.8
MDI0-: length 8.4
  BOTTOM w0.102: TL1.7 32.01,83.05 32.11,82.94 32.11,82.72 32.21,82.61 32.54,82.61 33.05,83.13 v3(33.05,84.28) 33.05,84.84 33.56,85.35 33.56,86.28 34.21,86.94 UL1.2
MDI1+: length 6.1
  BOTTOM w0.102: UL1.4 35.27,87.74 35.26,87.73 34.28,87.73 v3(33.87,88.15) 33.15,88.86 33.15,89.18 32.5,89.83 32.21,89.83 32.11,89.73 32.11,89.5 32.01,89.4 TL1.2
MDI1-: length 6.1
  BOTTOM w0.102: UL1.5 34.45,88.14 33.56,89.03 33.56,89.35 v3(33,89.91) 32.67,90.23 32.21,90.23 32.11,90.34 32.11,90.56 32.01,90.67 TL1.1
MDO0+: length 8.1
  BOTTOM w0.102: TL1.9 v3(20.39,81.78) 17.43,81.78 16.86,81.21 JLAN.1
MDO0-: length 8
  BOTTOM w0.102: JLAN.2 15.35,81.94 15.67,81.62 16.69,81.62 17.26,82.18 v3(18.42,82.18) 20.56,82.18 20.76,82.38 20.76,82.8 21.01,83.05 TL1.10
MDO1+: length 12.8
  BOTTOM w0.102: JLAN.3 15.75,83.25 16.64,84.14 17.8,84.14 18.28,84.62 v3(18.28,86.5) 18.28,88.76 18.91,89.4 TL1.15
MDO1-: length 12.9
  BOTTOM w0.102: JLAN.6 15.35,86.26 17.06,84.55 17.63,84.55 17.87,84.79 17.87,88.93 18.75,89.8 v3(19.13,89.8) 20.79,89.8 20.91,89.92 20.91,90.56 21.01,90.67 TL1.16
ME_EN: length 88.9
  TOP w0.102: v2(177.96,50.55) 178.04,50.46 178.96,50.46 179.42,50.92 RE326.1 180.16,50.92 180.16,50.92 UE1.99
  IN1 w0.127: v2(177.96,50.55) 177.56,50.15 177,50.15 176.37,50.79 176.37,60.05 173.98,62.43 173.98,65.5 173.17,66.31 173.17,73.27 169.27,77.16 159.65,77.16 157.27,79.54 155.24,79.54 139.67,95.11 v2(139.28,95.11)
  BOTTOM w0.102: v2(139.28,95.11) 139.28,95.05 138.64,94.4 v1(135.12,94.4) 130.28,94.4 128.53,96.15 127.26,96.15 126.34,97.07 RC8.1
ME_SUS_PWR_ACK: length 110
  TOP w0.102: UE1.34 198.25,39.72 198.53,39.99 v2(198.53,40.69) ; v2(179.09,48.88) 178.38,48.88 175.81,51.45 v1(175.81,54.16) 175.81,60.46 175.17,61.09 175.17,72.41 173.94,73.64 173.94,81.22 164.63,90.53 164.63,92.5 161.78,95.35 144.24,95.35 141.95,97.63 136.39,97.63 135.91,98.11 RC27.2 RC42.1
  IN3 w0.127: v2(198.53,40.69) 198.53,42.44 193.12,47.85 190.57,47.85 189.9,48.51 188.34,48.51 187.08,47.25 184.95,47.25 184.19,46.48 182.05,46.48 180.05,48.48 179.49,48.48 v2(179.09,48.88)
ME_SUS_PWR_ACK_R: length 11.9
  TOP w0.102: RC42.2 RC35.1 v1(132.37,101.02) 132.37,102.23 132.58,102.44 132.58,103.34 132.27,103.65 131.7,103.65 v2(131.6,103.55)
  BOTTOM w0.076: UC1.AV4 128.63,105.94 128.63,105.47 128.68,105.41 128.68,104.8 129.28,104.19 130.1,104.19 130.75,103.55 v2(131.6,103.55)
MECH#1: length 4.5
  BOTTOM w0.102: T82.1 162.73,137.59 165.23,135.1 UV1.A39
MECH#2: length 3.2
  BOTTOM w0.102: T83.1 193.38,104.57 193.38,106.98 UV1.AW1
MECH#3: length 3.5
  BOTTOM w0.102: UV1.AW39 165.26,104.51 T84.1
MEM_SMBCLK: length 22.7
  IN3 w0.127: v2(137.64,110.54) 137.38,110.81 v2(137.38,112.06) 137.58,112.26 138.06,112.26 139.66,110.66 143.9,110.66 144.17,110.93 144.71,110.93 v2(144.74,110.9)
  BOTTOM w0.076: 132.08,108.57 130.48,108.57 130.4,108.65 130.16,108.65 129.86,108.36 UC1.AP2
  BOTTOM w0.089: 132.08,108.57 132.59,108.07 134.06,108.07 134.19,108.19 135.29,108.19 137.63,110.54 v2(137.64,110.54)
  BOTTOM w0.102: v2(137.38,112.06) 137.44,112.06 137.89,112.51 137.89,113.97 137.96,114.05 RP40.1 ; QC1.6 v2(144.74,110.9)
MEM_SMBDATA: length 22.8
  IN3 w0.127: v2(137.44,112.64) 137.6,112.49 138.16,112.49 139.76,110.89 143.81,110.89 144.24,111.32 145.62,111.32 v2(146.04,110.9)
  BOTTOM w0.076: 134.85,110.82 134.55,111.12 134.55,111.71 134.15,112.11 130.28,112.11 UC1.AH1
  BOTTOM w0.089: 134.85,110.82 136.49,110.82 136.93,111.25 136.93,112.21 137.36,112.64 v2(137.44,112.64)
  BOTTOM w0.102: RP40.2 137.95,114.55 137.63,114.23 137.63,112.84 v2(137.44,112.64) ; QC1.3 v2(146.04,110.9)
MIC1-L: length 2.8
  TOP w0.203: UA1.19 39.14,28.28 38.94,28.48 38.94,28.52 38.92,28.55 38.92,29.5 39.44,30.02 CA74.1
MIC_CLK: length 348.4
  TOP w0.102: CA22.1 46.12,23.42 45.95,23.26 LA1.2 45.3,23.67 v2(45.69,24.06)
  IN1 w0.127: v2(45.69,24.06) 47.91,24.06 51.69,27.83 51.69,36.57 58.45,43.33 59.62,43.33 60.78,44.49 103.02,44.49 105.18,46.66 133.57,46.66 136.91,43.32 160.6,43.32 167.16,36.77 180.11,36.77 180.61,37.26 183.25,37.26 v2(184.05,36.46) ; v2(226.72,174.74) 221.45,169.47 221.45,165.33 217.48,161.36 217.48,120.75 219.81,118.43 219.81,113.54 221.26,112.09 221.26,104.28 216.24,99.26 216.24,95.81 212.56,92.13 212.56,86.06 220.48,78.15 220.48,59.86 217.61,56.99 217.61,47.32 v2(220.93,44)
  BOTTOM w0.102: v2(220.93,44) 220.39,44.54 209.22,44.54 208.32,43.64 v1(206.65,43.64) 201.01,43.64 200.42,43.05 196.16,43.05 194.39,41.27 194.39,38.92 192.86,37.4 184.99,37.4 v2(184.05,36.46) ; v2(226.72,174.74) 227.01,175.03 JLVDS.30
MIC_CLK_C: length 2.3
  TOP w0.102: LA1.1 44.54,23.25 v1(43.5,23.25) 43,23.25 42.83,23.42 UA1.3
MIC_DATA: length 351.1
  TOP w0.102: v2(48.92,23.42) 48.43,22.93 46.08,22.93 45.84,22.68 44.2,22.68 44.02,22.86 43.42,22.86 43.36,22.93 42.94,22.93 42.85,23.02 UA1.2
  IN1 w0.127: v2(221.31,44.57) 217.86,48.02 217.86,56.89 220.91,59.93 220.91,78.24 212.88,86.26 212.88,91.92 216.58,95.62 216.58,99.24 221.52,104.18 221.52,112.19 220.06,113.65 220.06,118.54 217.74,120.86 217.74,161.26 221.71,165.23 221.71,169.36 226.65,174.31 226.91,174.31 227.3,174.69 v2(227.55,174.69) ; v2(183.42,36.44) 183.42,36.52 182.98,36.96 180.67,36.96 180.22,36.51 167.06,36.51 160.5,43.07 137.01,43.07 136.8,43.07 133.46,46.41 105.38,46.41 103.21,44.24 60.89,44.24 59.73,43.08 58.64,43.08 52,36.44 52,27.78 48.92,24.71 v2(48.92,23.42)
  BOTTOM w0.102: JLVDS.32 228.01,175.16 v2(227.55,174.69) ; v2(183.42,36.44) 184.63,37.65 192.76,37.65 194.13,39.03 194.13,41.38 196.06,43.3 200.31,43.3 201.14,44.13 208.48,44.13 209.12,44.77 v1(220.69,44.77) 221.12,44.77 v2(221.31,44.57)
MIC_IN: length 25.3
  TOP w0.102: LA7.2 v1(22.29,27.28)
  IN1 w0.254: v2(23.21,25.47) 23.08,25.34 17.87,25.34 17.3,24.77 v2(17.3,24.7)
  IN1 w1.016: 24.22,25.91 24.22,26.36 26.25,28.39 29.62,28.39 30.07,28.83 35.02,28.83 35.72,29.53 38.13,29.53
  BOTTOM w0.254: QA6.3 16.6,24.01 v2(17.3,24.7)
  vias: v2(23.21,26.05) v2(39.4,29.28) v2(39.4,28.67)
MIC_IN_R: length 17.4
  TOP w1.016: JHP.4 4.19,20.64 11.71,20.64 v1(13.74,22.67) 13.74,24.72 15.07,26.04 16.54,26.04
MIIC_SCL: length 5.5
  TOP w0.102: v2(200.52,176.98) 200.71,176.79 200.71,176.62 200.99,176.34 201.46,176.34 201.58,176.46 v3(201.79,176.46) 202.03,176.46 202.13,176.35 202.13,176.01 202.12,176 UX4.48
  BOTTOM w0.102: v2(200.52,176.98) 200.75,177.2 200.75,177.41 200.55,177.61 200.17,177.61 RX171.1 RX169.2
MIIC_SDA: length 5.9
  TOP w0.102: UX4.47 202.52,175.85 202.36,176.01 202.36,176.45 202.12,176.68 201.48,176.68 201.36,176.57 201.09,176.57 200.94,176.71 200.94,176.8 v2(201.12,176.98)
  BOTTOM w0.102: v2(201.12,176.98) 200.98,177.12 200.98,177.5 200.62,177.87 200.17,177.87 RX170.1 RX168.2
MS_BS: length 23.7
  TOP w0.102: v2(178.54,31.49) v1(177.56,31.49) 175.54,31.49 173.89,29.84 173.89,26.99 173.82,26.92 172.36,26.92 172.24,26.8 172.24,26.63 172.36,26.51 173.71,26.51 173.83,26.4 173.83,26.23 173.71,26.11 172.36,26.11 172.24,25.99 172.24,25.82 172.36,25.7 173.76,25.7 173.89,25.57 173.89,25.02 174.35,24.57 UR1.22
  BOTTOM w0.102: JREAD.15 178.55,26.42 179.02,26.89 179.02,29.61 178.54,30.09 v2(178.54,31.49)
MS_CLK_SD_WP: length 27.1
  TOP w0.102: v2(184.62,23.74) 184.62,23.37 v1(184.03,22.77) 183.85,22.6 182.03,22.6 CR5.1 RR3.2
  BOTTOM w0.102: JREAD.5 187.67,24.64 186.77,23.74 v2(184.62,23.74) 181.72,20.83 175.48,20.83 172.12,24.2 170.65,24.2 170.19,24.66 JREAD.22
MS_CLK_SD_WP_R: length 6.1
  TOP w0.102: UR1.8 180.53,24.07 RR3.1 180.2,23.74 179.8,23.33 179.8,22.65 180.72,21.72 v1(181.68,21.72)
MS_D0: length 28
  TOP w0.102: UR1.16 176.82,27.59 176.72,27.69 176.05,27.69 175.95,27.79 175.95,28 176.05,28.1 176.72,28.1 176.82,28.2 176.82,28.4 176.72,28.51 176.05,28.51 175.95,28.61 175.95,28.81 176.05,28.91 176.72,28.91 176.82,29.01 176.82,29.94 177.22,30.34 181.02,30.34 181.12,30.24 181.12,28.64 181.22,28.54 181.84,28.54 181.94,28.44 181.94,28.02 182.05,27.92 v1(182.43,27.92) 182.67,27.92 182.77,27.82 182.77,27.62 182.67,27.51 182.05,27.51 181.94,27.41 181.94,27.21 182.05,27.11 182.96,27.11 183.06,27.01 183.06,26.8 182.96,26.7 182.05,26.7 181.94,26.6 181.94,26.4 182.05,26.3 183.36,26.3 183.46,26.4 183.46,27.53 183.52,27.59 183.52,28.86 183.42,28.96 v2(181.53,28.96)
  BOTTOM w0.102: JREAD.12 181.59,28.91 v2(181.53,28.96)
MS_D1_SD_D3: length 43.2
  TOP w0.102: v2(179.86,31.49) 179.16,30.8 175.91,30.8 v1(175.82,30.71) 175.77,30.66 175.35,30.66 174.35,29.65 174.35,25.77 174.55,25.57 UR1.20
  BOTTOM w0.102: JREAD.3 189.95,30.05 188.5,31.49 v2(179.86,31.49) 179.86,30.66 180.01,30.51 181.27,30.51 181.37,30.41 181.37,30.21 181.27,30.1 180.31,30.1 180.19,29.98 180.19,29.82 180.31,29.7 181.29,29.7 181.39,29.6 181.39,29.39 181.29,29.29 180.04,29.29 179.92,29.17 179.92,29 180.04,28.88 180.92,28.88 181.02,28.78 181.02,28.58 180.92,28.48 180.17,28.48 180.07,28.38 180.07,28.17 180.17,28.07 181.26,28.07 181.36,27.97 181.36,27.77 181.26,27.67 180.17,27.67 180.07,27.56 180.07,27.36 180.17,27.26 181.26,27.26 181.36,27.16 181.36,26.95 181.26,26.85 180.17,26.85 180.07,26.75 JREAD.13
MS_D2_SD_CLK: length 26.8
  TOP w0.102: v2(179.61,28.09) 179.61,26.4 179.71,26.3 179.93,26.3 180.03,26.4 180.03,28.17 180.16,28.3 180.36,28.3 180.48,28.17 180.48,26.4 180.58,26.3 181.53,26.3 181.64,26.41 181.64,26.56 181.53,26.67 181,26.67 180.9,26.77 v1(180.9,26.88) 180.9,26.99 181,27.09 181.52,27.09 181.64,27.21 181.64,27.37 181.52,27.48 181,27.48 180.9,27.59 180.9,27.79 181,27.89 181.55,27.89 181.68,28.01 181.68,28.19 181.55,28.31 180.99,28.31 180.89,28.41 180.89,29.94 180.72,30.11 178.66,30.11 RR2.2 CR6.1
  IN3 w0.127: v2(179.61,28.09) 179.76,28.25 v2(183.11,28.25)
  BOTTOM w0.102: JREAD.14 179.31,26.82 179.61,27.12 v2(179.61,28.09) ; JREAD.10 v2(183.11,28.25)
MS_D2_SD_CLK_R: length 5.7
  TOP w0.102: RR2.1 178.21,28.87 178.68,29.34 178.68,29.61 178.83,29.76 179.03,29.76 v1(179.13,29.66) 179.23,29.55 179.23,29.31 178.68,28.75 178.68,28.16 178.55,28.03 178.12,28.03 177.99,27.9 177.99,27.65 177.87,27.52 177.44,27.52 177.32,27.4 UR1.15
MS_D3: length 26.7
  TOP w0.102: UR1.12 184.22,26.07 184.33,26.17 184.33,27.12 184.43,27.22 184.63,27.22 184.73,27.12 184.73,26.17 184.83,26.07 185.04,26.07 185.14,26.17 185.14,26.73 185.24,26.84 185.44,26.84 185.55,26.73 185.55,26.17 185.65,26.07 185.85,26.07 185.95,26.17 185.95,26.58 186.05,26.68 186.26,26.68 186.36,26.58 186.36,26.17 186.46,26.07 186.76,26.07 186.86,26.17 v1(186.86,26.8) 186.86,27.08 186.76,27.18 v2(185.89,27.18)
  BOTTOM w0.102: JREAD.7 186.15,26.72 186.39,26.96 186.39,27.59 186.29,27.69 185.35,27.69 185.25,27.79 185.25,27.99 185.35,28.09 186.29,28.09 186.39,28.2 186.39,28.4 186.29,28.5 185.35,28.5 185.25,28.6 185.25,28.81 185.35,28.91 186.29,28.91 186.39,29.01 186.39,29.24 186.29,29.34 184.89,29.34 184.79,29.24 184.79,27.28 184.89,27.18 v2(185.89,27.18)
MS_INS#: length 7.2
  TOP w0.102: v2(184.62,24.32) 184.5,24.2 v1(184.08,24.2) 183.06,24.2 CR10.1 182.58,24.2 180.75,24.2 180.38,24.57 UR1.9
  BOTTOM w0.102: v2(184.62,24.32) 184.63,24.33 JREAD.8
O-USR: length 5.9
  TOP w0.102: v1(85.58,144.57) 85.58,143.41 86.01,142.98 v2(86.01,142.61)
  TOP w0.254: PR506.2 85.82,142.42 v2(86.01,142.61)
  BOTTOM w0.203: v2(86.01,142.61) 86.19,142.61 86.97,141.82 87.46,141.82 PU501.9
  BOTTOM w0.254: v2(86.01,142.61) 85.94,142.67 PR502.1
OCP_CPU: length 3.5
  TOP w0.102: v2(88.61,142.61) 88.76,142.61 v1(89.21,143.06)
  TOP w0.254: PR503.2 88.48,142.48 v2(88.61,142.61)
  BOTTOM w0.203: v2(88.61,142.61) 89.02,142.2 PU501.12
  BOTTOM w0.254: v2(88.61,142.61) PR501.1
ODD_DA#: length 201.2
  TOP w0.089: v2(129.31,118.48) 129.31,118.26 v1(128.97,117.92) 128.24,117.19 128.24,116.78 128.42,116.59 128.42,116.06 128.6,115.88 129.91,115.88 130.49,115.3 131.47,115.3 v2(131.66,115.5) 131.73,115.56 131.73,116 131.87,116.14 RP54.1
  IN1 w0.127: v2(218.52,55.87) 218.53,55.87 218.95,56.29 218.95,57.26 221.41,59.72 221.41,87.4 226.09,92.07 v2(226.09,110.03)
  IN3 w0.084: 137.82,108.85 126.81,108.85 126.5,109.16 126.5,110.48 126.36,110.62 126.36,111.4 126.65,111.69 127.92,111.69 128.2,111.97 128.2,112.68 128.88,113.35 129.42,113.35 131.56,115.5 v2(131.66,115.5)
  IN3 w0.127: v2(218.52,55.87) 215.28,55.87 213.2,53.79 199.48,53.79 196.94,56.33 196.94,59.3 183.92,72.31 183.92,80.61 163.01,101.53 163.01,102.17 161.88,103.3 154.14,103.3 149.43,108.02 145.04,108.02 143.83,109.22 138.86,109.22 138.48,108.85 137.82,108.85
  BOTTOM w0.089: UC1.T3 128.98,118.82 v2(129.31,118.48)
  BOTTOM w0.102: CS17.1 225.86,110.25 v2(226.09,110.03) JBTB.7 JBTB1.5
ODD_DETECT#: length 201.4
  TOP w0.102: v2(152.07,107.75) v1(152.66,107.75)
  IN1 w0.127: v2(218.52,56.45) 218.52,57.19 221.16,59.82 221.16,87.66 225.52,92.01 225.52,110.37 225.98,110.83 v2(231.44,110.83)
  IN2 w0.127: v2(152.07,107.75) 151.59,108.23 151.59,110.77 151.31,111.05 151.31,112.27 149.74,113.85 149.74,116.98 149.19,117.53 146.69,117.53 145.56,118.66 144.2,118.66 143.04,119.81 139.12,119.81 137.62,118.32 v2(137.62,118.23)
  IN3 w0.084: v2(127.26,117.91) 127.62,118.27 128,118.27 128.45,117.82 130.77,117.82 132.22,119.28 133.54,119.28 134.24,118.58 136.26,118.58 136.66,118.18 137.57,118.18 v2(137.62,118.23)
  IN3 w0.127: v2(218.52,56.45) 218.31,56.24 215.29,56.24 213.09,54.04 199.59,54.04 197.2,56.43 197.2,59.4 184.18,72.42 184.18,80.72 172.69,92.22 172.69,94.07 171.15,95.6 169.67,95.6 163.53,101.75 163.53,102.4 162.1,103.83 155.99,103.83 v2(152.07,107.75)
  BOTTOM w0.076: v2(137.62,118.23) 137.48,118.09 137.48,117.68 137.92,117.24
  BOTTOM w0.089: UC1.V6 126.99,117.64 v2(127.26,117.91)
  BOTTOM w0.102: 137.92,117.24 137.99,117.17 RP37.1 ; JBTB1.4 v2(231.44,110.83)
ODD_EN: length 6
  BOTTOM w0.102: QS3.1 222.75,127.29 v1(223.04,127) 223.05,126.99 RS6.1 223.05,124.77 CS16.1 222.85,124.53 QS2.3
ODD_EN#: length 136.6
  IN1 w0.084: 137.92,117.91 137.42,117.4 134.76,117.4 v2(134.33,116.97)
  IN1 w0.127: v2(216.91,124.04) 216.91,120.92 218.72,119.11 218.72,105.8 212.8,99.87 210.74,99.87 210.35,100.27 201.09,100.27 196.3,95.48 193.12,95.48 191.56,97.04 189.87,97.04 189.2,96.37 177.52,96.37 176.24,97.65 172.96,97.65 171.22,95.92 v2(171.22,94.86) ; 137.92,117.91 138.18,118.16 138.33,118.16 139.98,119.81 143.02,119.81 152.05,110.78 v2(152.05,109.59)
  IN3 w0.127: v2(171.22,94.86) 170.05,94.86 163.27,101.64 163.27,102.28 161.99,103.56 155.42,103.56 151.65,107.33 151.65,109.19 v2(152.05,109.59)
  BOTTOM w0.089: UC1.Y1 130.57,116.89 131.35,116.89 131.85,117.39 133.9,117.39 v2(134.33,116.97)
  BOTTOM w0.102: v2(216.91,124.04) 217.85,124.04 218.23,123.66 v1(218.65,123.66) 218.82,123.66 219.42,124.26 221.22,124.26 221.81,124.84 QS3.2
ON/OFFBTN#: length 259.7
  TOP w0.102: v2(43.46,96) 39.84,99.62 32.62,99.62 30.66,97.67 25.11,97.67 24.79,97.35 JPWR.3 ; v2(177.45,46.53) 177.65,46.33 178.38,46.33 179.5,45.21 179.88,45.21 180.18,44.92 UE1.114 ; v2(168.75,46.39) 168.75,36.94 169.35,36.34 v4(175.89,36.34) 177.68,36.34 181.1,32.92 191.2,32.92 RE49.1 195.55,30.58 CE20.1 195.88,33.14 SW1.3 v2(199.86,33.14) SW1.4
  IN3 w0.127: v2(43.46,96) 43.46,93.84 45.56,91.75 45.56,88.63 47.44,86.75 47.44,56.21 55.29,48.36 67.07,48.36 69.05,46.39 v2(168.75,46.39) 177.3,46.39 v2(177.45,46.53)
  BOTTOM w0.102: SW2.3 199.74,41.49 199.74,38.66 199.22,38.14 SW2.4 199.22,33.79 v2(199.86,33.14)
PACIN#: length 2.6
  BOTTOM w0.102: v1(189.05,99.37) RV74.2 189.13,100.45 QV14.5 QV14.6
PANEL_BKLEN: length 136.5
  TOP w0.102: v2(193.39,51.27) 192.47,51.27 191.19,52.56 UE1.76
  IN2 w0.127: v2(186.24,50.48) 186.24,55.63 185.5,56.37 185.5,67.77 186.26,68.54 186.26,75.85 182.32,79.79 182.32,80.62 160.49,102.45 157.92,102.45 152.66,107.71 152.66,110.06 151.62,111.1 151.62,112.81 150.19,114.24 150.19,117.22 148.43,118.99 144.37,118.99 143.26,120.09 143.26,123.41 136.62,130.05 136.62,133.57 135.88,134.3 127.93,134.3 125.62,131.99 v2(125.62,131.85)
  IN3 w0.127: v2(193.39,51.27) 192.78,50.66 189.52,50.66 189.33,50.85 186.6,50.85 v2(186.24,50.48)
  BOTTOM w0.076: v2(125.62,131.85) 125.62,131.6 125.82,131.39 v1(125.82,130.84) 125.82,129.03 124.83,128.03 UC1.A9
PBTN_OUT#: length 257.1
  TOP w0.102: v2(172.94,56.71) 172.94,54 v1(173.06,53.87) 178.46,48.48 180.37,48.48 180.73,48.12 UE1.106
  IN1 w0.084: 137.75,110 135.74,110 134.36,111.38 129.82,111.38 129.63,111.57 127.7,111.57 127.62,111.65 127.22,111.65 v2(126.82,111.25)
  IN1 w0.127: 137.75,110 138.62,110.87 144.17,110.87 144.58,110.45 147.09,110.45 148.15,109.4 148.15,108.56 152.94,103.77 152.94,103.62 160.46,96.09 160.46,93.63 167.02,87.07 171.67,87.07 172.32,86.42 174.36,86.42 178.04,82.74 180.1,82.74 v2(183.48,79.36)
  IN3 w0.127: v2(65.73,90.71) 66,90.44 66,80.5 70.77,75.73 70.77,74.48 73.14,72.11 73.14,59.35 75.62,56.87 111.46,56.87 112.15,57.56 116.36,57.56 117.04,56.87 172.13,56.87 172.29,56.71 v2(172.94,56.71) 173.09,56.86 175.46,56.86 177.64,59.03 180.34,59.03 184.92,63.62 184.92,65.23 185.07,65.38 185.07,68.33 183.48,69.92 183.48,79.34 183.48,79.35 v2(183.48,79.36)
  BOTTOM w0.089: v2(126.82,111.25) 126.54,110.97 UC1.AL7
  BOTTOM w0.102: RC49.1 65.09,90.71 v2(65.73,90.71)
PC_BEEP: length 5.6
  TOP w0.102: DA8.1 50.38,27.73 v1(50.19,27.53) 49.14,27.53 RA19.1 47.98,28.69 RA79.2
PCH_AUDIO_EN: length 3.5
  BOTTOM w0.076: RC116.1 132.86,119.69 v1(132.46,119.69) 130.36,119.69 UC1.P1
PCH_AZ_BITCLK: length 7
  BOTTOM w0.076: 125.2,104.26 125.11,104.35 125.11,105.3 UC1.AW8
  BOTTOM w0.089: R2359.2 128.11,99.96 v1(127.18,100.9) 126.55,101.53 126.55,102.28 126.24,102.58 126.24,103.21 125.2,104.26
PCH_AZ_CODEC_BITCLK: length 176.5
  TOP w0.102: UA1.6 43.7,24.62 43.78,24.69 R2355.1 v2(45.04,24.06)
  IN1 w0.127: v2(137.51,53.2) 142.78,58.47 142.78,71.05 144.11,72.38 144.11,82.54 v2(131.45,95.2) ; v2(137.51,47.42) 136.72,48.21 65.47,48.21 65.09,47.83 57.53,47.83 50.8,41.1 50.8,28.36 47.46,25.02 45.93,25.02 45.04,24.13 v2(45.04,24.06)
  BOTTOM w0.089: R2359.1 127.91,98.8 127.91,97.97 CC5.1 127.21,97.03 127.6,96.63 129.96,96.63 130.03,96.56
  BOTTOM w0.102: v2(131.45,95.2) 131.45,95.2 v1(130.63,96.01) 130.09,96.56 130.03,96.56 ; v2(137.51,47.42) v2(137.51,53.2)
PCH_AZ_CODEC_RST#: length 210.2
  TOP w0.102: v2(15.03,27.5) v1(15.79,27.5) ; v2(43.19,26.62) UA1.11
  IN1 w0.084: v2(128.28,98.41) 128.65,98.41 129.66,97.4 129.97,97.4 130.42,96.95
  IN1 w0.127: v2(15.03,27.5) 15.6,26.93 19.46,26.93 22.32,29.78 24.48,29.78 28.86,34.17 42.76,34.17 44.48,32.45 47.88,32.45 ; 47.88,32.45 48.14,32.71 48.14,42.21 57.9,51.97 102.61,51.97 105.95,55.31 134.14,55.31 136.76,52.69 138.14,52.69 143.98,58.54 143.98,71.43 144.62,72.06 144.62,82.75 130.42,96.95 ; 47.88,32.45 47.88,31.59 44.35,28.06 44.35,27.5 43.96,27.1 43.57,27.1 43.19,26.72 v2(43.19,26.62)
  BOTTOM w0.089: v2(128.28,98.41) 128.92,99.05 R2358.1
  BOTTOM w0.102: RA6.1 v2(15.03,27.5)
PCH_AZ_CODEC_SDIN0: length 182.4
  TOP w0.102: v2(46.57,26.72) 45.88,26.02 45.7,26.02 RA130.1
  IN1 w0.084: 131.57,98.29 131.16,98.29 130.1,99.34 127.21,99.34 v2(125.62,100.93)
  IN1 w0.127: 131.57,98.29 131.6,98.29 132.29,97.6 132.29,97.23 147.57,81.95 147.57,68.55 146.46,67.44 146.46,58.86 138.77,51.17 137.93,51.17 137.93,51.17 136.13,51.17 133.51,53.79 114.22,53.79 112.7,52.26 105.06,52.26 103.24,50.45 62.7,50.45 61.13,48.88 57.09,48.88 49.75,41.54 49.75,29.9 v2(46.57,26.72)
  BOTTOM w0.089: v2(125.62,100.93) 126.22,101.54 126.22,102.35 126.07,102.51 126.07,103.14 124.65,104.55 UC1.AY10
PCH_AZ_CODEC_SDOUT: length 182.5
  TOP w0.089: v1(124.27,99.47) 125.75,99.47 126.77,98.44 v2(126.77,98.43)
  TOP w0.102: UA1.5 43.34,24.22 43.5,24.06 v2(44.35,24.06)
  IN1 w0.084: 131.32,97.85 130.85,97.85 129.78,98.91 128.25,98.91 127.91,98.57 127.91,98.26 127.68,98.04 127.16,98.04 v2(126.77,98.43)
  IN1 w0.127: 131.32,97.85 131.78,97.39 131.78,97.02 146.27,82.53 146.27,74.02 145.76,73.52 145.76,70.36 145.77,70.35 145.77,68.06 145.76,68.05 145.76,66.49 145,65.73 145,58.96 145,58.11 138.56,51.68 138.14,51.68 136.34,51.68 133.72,54.3 114.01,54.3 112.49,52.77 104.85,52.77 103.03,50.95 58.37,50.95 49.21,41.8 49.21,30.59 45.52,26.9 45.52,25.33 44.35,24.16 v2(44.35,24.06)
  BOTTOM w0.089: R2356.1 127.24,98.9 v2(126.77,98.43)
PCH_AZ_CODEC_SYNC: length 174.5
  TOP w0.089: v1(127.89,97.88) 128.03,98.02 128.78,98.02 129.17,98.41 v2(129.33,98.41)
  TOP w0.102: v2(43.78,26.6) 43.34,26.15 42.96,26.15 42.89,26.22 UA1.10
  IN1 w0.084: v2(129.33,98.41) 130.2,97.54 130.91,97.54 130.96,97.49
  IN1 w0.127: 130.96,97.49 131.27,97.18 131.27,96.81 145.76,82.32 145.76,74.23 145.25,73.73 145.25,70.15 145.26,70.14 145.26,69.8 145.25,69.79 145.25,69.39 145.26,69.38 145.26,69.03 145.25,69.03 145.25,68.63 145.26,68.62 145.26,68.27 145.25,68.26 145.25,68.07 144.49,67.31 144.49,58.75 144.49,58.33 138.35,52.19 136.55,52.19 133.93,54.8 106.16,54.8 102.82,51.46 58.16,51.46 48.68,41.98 48.68,31.67 47.54,30.54 47.54,29.64 44.5,26.6 v2(43.78,26.6)
  BOTTOM w0.089: v2(129.33,98.41) 129.42,98.5 R2357.1
PCH_AZ_RST#: length 8.7
  BOTTOM w0.076: UC1.AU8 125.73,106.6 125.73,106.12 125.7,106.08 125.7,104.56 125.68,104.55
  BOTTOM w0.089: 125.68,104.55 125.68,104.03 126.42,103.29 126.42,102.9 v1(127.09,102.23) 127.26,102.06 127.26,101.34 128.15,100.45 128.57,100.45 R2358.2
PCH_AZ_SDOUT: length 10.1
  BOTTOM w0.089: R2356.2 RC8.2 RC3.2 125.43,99.97 125.06,100.33 125.06,100.94 125.44,101.32 125.57,101.32 125.81,101.56 v1(125.81,102.2) 125.89,102.28 125.89,103.07 124.31,104.64 124.31,106.53 UC1.AU11
PCH_AZ_SYNC: length 11.7
  TOP w0.089: v2(128.17,101.28) 128.43,101.54 128.43,103.37 128.04,103.75 128.04,104.08 126.75,105.37 124.81,105.37 v1(124.26,105.92) 123.59,105.92 123.56,105.94 v2(123.53,105.94)
  BOTTOM w0.076: v2(123.53,105.94) 123.83,106.24 UC1.AV11
  BOTTOM w0.089: v2(128.17,101.28) 128.53,101.28 129.48,100.33 129.48,99.95 R2357.2
PCH_BATLOW#: length 20.2
  TOP w0.089: 137.92,111.25 137.35,111.25 v1(136.9,110.8) 135.49,109.39 130.09,109.39 129.57,109.91 129.09,109.91 v2(128.66,109.49)
  TOP w0.102: RC31.2 146.57,111.43 144.3,111.43 144.12,111.25 137.92,111.25
  BOTTOM w0.089: UC1.AN4 128.33,109.15 v2(128.66,109.49)
PCH_DPWROK: length 9.5
  TOP w0.089: RC33.1 RE37.1 129.73,102.08 v1(129.73,102.54) v2(129.73,103.21)
  BOTTOM w0.076: v2(129.73,103.21) 129.35,103.59 128.2,103.59 127.64,104.15 127.64,104.53 127.36,104.81 127.36,105.99 UC1.AV5
PCH_GPIO9: length 23.5
  TOP w0.089: v2(129.28,109.49) 129.74,109.02 v1(135.16,109.02) 135.59,109.02 137.53,110.95 137.92,110.95
  TOP w0.102: 137.92,110.95 143.89,110.95 144.35,110.49 148.62,110.49 149.46,109.65 v2(149.92,109.65)
  BOTTOM w0.076: v2(129.28,109.49) 128.98,109.79 UC1.AM3
  BOTTOM w0.102: RC125.2 149.46,110.11 v2(149.92,109.65)
PCH_GPIO12: length 1.1
  TOP w0.089: v2(126.97,110.42) 126.84,110.54 T182.1
  BOTTOM w0.089: UC1.AM7 126.7,110.14 v2(126.97,110.42)
PCH_GPIO14: length 1.5
  TOP w0.089: T126.1 127.83,112.45 v2(127.83,112.18)
  BOTTOM w0.076: v2(127.83,112.18) 127.95,112.07 UC1.AH4
PCH_GPIO25: length 1.1
  TOP w0.089: v2(128.04,109.46) 128.36,109.78 T127.1
  BOTTOM w0.089: UC1.AM4 128.33,109.75 v2(128.04,109.46)
PCH_GPIO35: length 10.3
  TOP w0.102: v2(138.29,117.67) v1(138.95,117.67)
  IN3 w0.127: v2(132.23,118.76) 132.23,118.67 133.44,117.46 138.08,117.46 v2(138.29,117.67)
  BOTTOM w0.076: v2(132.23,118.76) 132.06,118.76 131.4,118.1 UC1.U1
  BOTTOM w0.102: RP37.2 v2(138.29,117.67)
PCH_GPIO37: length 12.9
  BOTTOM w0.076: UC1.AC1 130.75,115.11 131.51,115.86 132.77,115.86 133.26,115.38 134.76,115.38 134.78,115.41 135.06,115.41 135.28,115.18 136.81,115.18 137.32,115.69 137.32,117.08
  BOTTOM w0.089: 137.92,118.61 137.38,118.61 137,118.23 v1(137,117.78) 137,117.59 137.32,117.27 137.32,117.08
  BOTTOM w0.102: 137.92,118.61 138.03,118.61 138.46,118.17 RP37.3
PCH_GPIO44: length 16.3
  TOP w0.089: 137.92,111.69 137.8,111.56 137,111.56 136.3,110.86 134.32,110.86 v2(134.3,110.85)
  TOP w0.102: 137.92,111.69 137.99,111.75 v1(140.76,111.75) 142.35,111.75 v2(142.4,111.7)
  BOTTOM w0.076: v2(134.3,110.85) 134.3,111.63 134,111.93 130.92,111.93 130.8,111.82 130.02,111.82 129.85,111.65 129.14,111.65 129.1,111.69 128.62,111.69 UC1.AK4
  BOTTOM w0.102: v2(142.4,111.7) 142.15,111.95 RC104.1
PCH_GPIO46: length 27.3
  IN3 w0.084: 137.82,113.28 135.47,113.28 134.17,114.58 131.42,114.58 v2(129.32,112.48)
  IN3 w0.127: 137.82,113.28 138.95,113.28 139.84,112.39 143.15,112.39 143.83,111.71 149.39,111.71 149.4,111.71 149.75,111.71 149.75,111.71 150.06,111.71 v2(150.78,110.99)
  BOTTOM w0.076: UC1.AG3 128.98,112.83 v2(129.32,112.48)
  BOTTOM w0.102: v2(150.78,110.99) v1(150.78,110.28) 150.78,109.65 150.35,109.22 RC124.2
PCH_GPIO47: length 1.1
  TOP w0.089: v2(126.62,115.08) 126.97,115.43 T174.1
  BOTTOM w0.089: UC1.AB6 126.99,115.46 v2(126.62,115.08)
PCH_GPIO48: length 2.6
  TOP w0.089: T124.1 127.98,119.91 v2(127.95,119.91)
  BOTTOM w0.076: v2(127.95,119.91) 128.02,119.83 128.02,118.4 128.33,118.1 UC1.U4
PCH_GPIO49: length 4.6
  BOTTOM w0.076: 133.33,116.34 133.3,116.31 129.23,116.31 UC1.Y3
  BOTTOM w0.089: T125.1 133.33,116.34
PCH_GPIO66: length 9.3
  BOTTOM w0.076: UC1.D3 129.31,125.2 129.75,125.2 129.93,125.39 129.93,125.84 130.14,126.04 131.6,126.04
  BOTTOM w0.089: 131.6,126.04 132.1,126.54 133.82,126.54 134.41,127.13 RC122.1 135.04,127.59 RC118.2 135.33,128.35 v1(135.82,128.83)
PCH_GPIO83: length 1.3
  TOP w0.089: v2(126.51,118.83) 126.14,119.2 T177.1
  BOTTOM w0.089: v2(126.51,118.83) 126.99,119.32 UC1.R6
PCH_GPIO84: length 2.2
  TOP w0.089: v2(126.65,120.77) 126.65,121.41 T176.1
  BOTTOM w0.089: v2(126.65,120.77) 126.99,121.11 UC1.L6
PCH_GPIO85: length 1.3
  TOP w0.089: T175.1 127.05,120.04 v2(127.35,119.75)
  BOTTOM w0.089: UC1.N6 126.99,120.11 v2(127.35,119.75)
PCH_GPIO89: length 2.2
  TOP w0.089: v2(126.58,119.81) 126.14,120.26 125.89,120.26 125.61,120.54 T178.1
  BOTTOM w0.089: UC1.N7 126.34,120.06 v2(126.58,119.81)
PCH_GPIO90: length 3
  BOTTOM w0.089: UC1.K2 130.01,121.46 130.95,121.46 T179.1
PCH_GPIO93: length 3.8
  BOTTOM w0.076: UC1.J2 129.92,122.89 130.47,122.89 130.73,123.16 130.73,123.33 130.9,123.5 132.83,123.5 T180.1
PCH_GPIO94: length 4.7
  BOTTOM w0.089: UC1.G1 130.76,123.83 132.39,123.83 132.64,124.08 133.71,124.08 T181.1
PCH_HOT#: length 107.3
  TOP w0.089: 135.96,103.46 135.95,103.46 135.95,103.9 135.76,104.1 v2(135.76,104.16)
  TOP w0.102: RE7.1 191.66,56.67 v2(191.41,56.93) ; v2(177.51,53.14) 176.04,54.61 176.04,60.55 175.47,61.12 175.47,72.44 174.17,73.73 174.17,81.31 164.86,90.62 164.86,92.59 v1(159.75,97.71) 158.08,97.71 156.28,99.51 144.61,99.51 144.02,100.09 139.71,100.09 139.69,100.11 139.27,100.53 139.05,100.75 138.62,100.75 135.96,103.41 135.96,103.46
  IN3 w0.127: v2(191.41,56.93) 191.41,53.82 190.65,53.06 177.59,53.06 v2(177.51,53.14)
  BOTTOM w0.076: 130.33,104.54 129.54,104.54 129.34,104.74 129.34,105.08 129.29,105.13 129.29,105.74 129.06,105.97 128.84,105.97 128.66,106.14 128.66,106.36 128.3,106.73 UC1.AU4
  BOTTOM w0.089: 135.02,104.48 R2330.2 135.54,104.5 135.55,104.5 135.73,104.32 135.73,104.19 v2(135.76,104.16)
  BOTTOM w0.102: 130.33,104.54 130.55,104.32 132.74,104.32 133.16,103.9 134.62,103.9 134.81,104.09 134.81,104.1 135.02,104.31 135.02,104.48
PCH_INTVRMEN: length 12.6
  BOTTOM w0.076: 125.86,104.35 125.86,105.99 UC1.AV7
  BOTTOM w0.089: 125.86,104.35 125.86,104.1 126.6,103.36 126.6,103.15 127.87,101.88 128.18,101.88 129.66,100.41 129.66,100.08 129.9,99.84 130.37,99.84 130.84,99.37 130.84,98.81 v1(131.25,98.4) 131.57,98.4
  BOTTOM w0.102: 131.57,98.4 RC1.2 133.04,98.4 RC2.1
PCH_JTAG_JTAGX: length 9.6
  BOTTOM w0.076: UC1.AE63 90.38,113.65
  BOTTOM w0.102: v1(84.18,114.63) 84.62,114.19 RC62.2 RC59.1 84.64,112.69 RC130.1 86.07,112.69 86.13,112.62 89.36,112.62 90.38,113.65
PCH_JTAG_RST#: length 67
  TOP w0.102: RC57.2 R2341.2 73.55,115.24 72.95,115.24 72.76,115.05 72.76,111.33 73,111.09 73,108.09 75.49,105.59 75.49,103.07 73.37,100.95 v4(73.37,99.61) 73.37,95.11 69.85,91.59 v2(67.34,91.59)
  BOTTOM w0.076: UC1.AU62 92.11,106.91 91.79,107.23 91.16,107.23 90.64,106.71
  BOTTOM w0.089: 87.92,103.99 87.12,103.19
  BOTTOM w0.102: 87.12,103.19 84.15,100.22 77.9,100.22 74.95,97.27 74.95,92.05 74.49,91.59 v2(67.34,91.59) ; 90.64,106.71 87.92,103.99
PCH_JTAG_TCK: length 59.1
  TOP w0.102: v4(77.52,110.43) 76.75,109.65 v2(76.74,109.65)
  IN3 w0.127: v2(66.62,90.9) 66.79,90.72 70.25,90.72 71.53,92 71.53,100.38 75.15,104 75.15,108.07 v2(76.74,109.65)
  BOTTOM w0.076: UC1.AE62 92.08,113.43 91.87,113.43 91.74,113.36 91.71,113.35 91.46,113.35 91.35,113.46 90.55,113.46
  BOTTOM w0.102: v2(76.74,109.65) 77.24,110.16 77.69,110.16 78.45,110.92 82.32,110.92 83.02,110.22 83.93,110.22 RC135.1 RC65.2 84.81,112 85.94,112 86.37,112.43 89.53,112.43 90.55,113.46 ; RP46.4 59.1,88.37 60.54,86.92 64.74,86.92 66.78,88.96 66.78,90.74 v2(66.62,90.9)
PCH_JTAG_TDI: length 26.8
  TOP w0.089: v2(93.3,114.04) 93.3,114.02 92.87,113.59 90.83,113.59 90.14,112.89 89.06,112.89 v2(88.67,113.27) 88.64,113.31 88.45,113.31
  TOP w0.102: 88.45,113.31 87.05,114.71 v4(83.91,114.71) 82.44,114.71 v2(80.31,112.57)
  BOTTOM w0.089: UC1.AD61 92.95,114.39 v2(93.3,114.04) ; v2(88.67,113.27) 88.4,113 RP48.8
  BOTTOM w0.102: v2(80.31,112.57) 79.68,111.95 78.65,111.95 77.35,110.64 76.15,110.64 75.75,110.24 75.75,107.78 75.49,107.53 75.49,106.5 75.21,106.22 RC44.1
PCH_JTAG_TDO: length 24.9
  TOP w0.089: v2(89.31,113.27) 89.31,113.58 88.91,113.97
  TOP w0.102: v2(79.72,112.6) v4(81.68,114.55) 82.24,115.11 87.77,115.11 RC63.2 88.91,113.97 ; v2(92.65,114.02) 90.82,114.02 90.07,113.27 v2(89.31,113.27)
  BOTTOM w0.089: UC1.AE61 92.95,113.72 v2(92.65,114.02) ; 88.91,113.67 v2(89.31,113.27)
  BOTTOM w0.102: RP48.7 88.27,113.5 88.48,113.72 88.87,113.72 88.91,113.67 ; RC43.1 75.21,108.69 75.21,110.61 77.2,112.6 v2(79.72,112.6)
PCH_JTAG_TMS: length 34.5
  TOP w0.102: v2(67.14,111.32) 67.61,111.32 v4(67.78,111.5)
  BOTTOM w0.089: UC1.AD62 91.9,114 88.91,114
  BOTTOM w0.102: RC46.1 65.94,110.12 v2(67.14,111.32) 68.46,112.64 69.94,112.64 72.36,115.05 85.88,115.05 86.13,114.8 88.48,114.8 88.74,114.55 88.74,114 ; 88.74,114 RP48.6 ; 88.74,114 88.91,114
PCH_OPI_COMP: length 7.6
  BOTTOM w0.076: UC1.AW15 121.95,105.3 121.95,104.42 122.1,104.27 122.19,104.18 122.19,103.58 122.29,103.48 122.29,103.33 122.71,102.91
  BOTTOM w0.305: 122.71,102.91 122.9,102.72 v1(122.9,100.47) 123.71,99.67 123.78,99.67 123.93,99.52 123.93,99.51 RC101.1
PCH_PCIE_RCOMP: length 5.4
  BOTTOM w0.089: v1(114.6,132.5) 114.66,132.44 RC91.2
  BOTTOM w0.305: RC91.2 114.66,130.95 115.04,130.57 115.04,129.33 114.59,128.89 114.59,127.73 UC1.A27
PCH_PLTRST#: length 30.1
  TOP w0.089: v2(126.71,112.19) 126.33,111.82 126.33,111.1 126.57,110.87 127.15,110.87 127.47,110.55 127.47,109.51 127.89,109.09 129.42,109.09 129.89,108.63 136.61,108.63 137.92,109.94
  TOP w0.102: 148.44,108.45 148.44,109.19 v1(148.35,109.29) 147.83,109.81 CC33.1 146.6,109.81 145.82,109.03 145,109.03 143.31,110.73 138.71,110.73 137.92,109.94 ; 148.44,108.45 UC3.1 ; 148.44,108.45 147.99,108.45 147.79,108.26 UC3.2
  BOTTOM w0.076: UC1.AG7 126.71,112.29 v2(126.71,112.19)
PCH_PWR_EN: length 53.8
  TOP w0.102: v2(174.72,49.85) 174.72,49.85 v1(175.52,49.04) 176.87,49.04 178.05,47.87 RE36.1
  IN1 w0.127: v2(174.72,49.85) 174.72,49.85 174.31,50.26 173.96,50.26 173.45,49.74 173.45,41.15 v2(172.18,39.88)
  IN3 w0.127: v2(142.97,28.45) 143.03,28.51 143.03,30.36 146.4,33.72 166.02,33.72 v2(172.18,39.88)
  BOTTOM w0.102: v2(142.97,28.45) 142.49,28.93 141.55,28.93 R416.1
PCH_PWROK: length 139.4
  TOP w0.089: CC34.1 135.3,113.97 134.84,114.43 133.2,114.43 v2(132.81,114.03) ; v2(132.81,114.03) 132.49,114.35 RP50.3 ; v2(132.81,114.03) 132.81,113.97 132.68,113.85 RP50.2
  TOP w0.102: UE1.32 195.59,36.67 v2(195.8,36.46) 195.93,36.33 RE18.1 196.83,35.82 CE31.1 197.12,35.82 v4(197.95,34.99)
  IN1 w0.084: v2(132.81,114.03) 130.58,114.03 130.33,113.78 130.33,112.79 130.81,112.3 134.44,112.3 134.66,112.53 136.06,112.53 137.06,113.53 137.72,113.53
  IN1 w0.127: 137.72,113.53 141.8,113.53 143.64,115.37 147.1,115.37 151.63,110.84 151.63,107.6 151.95,107.28 152.76,107.28 153.95,106.08 153.95,104.26 164.43,93.78 164.43,91.1 167.43,88.1 174.12,88.1 178.46,83.76 182.49,83.76 188.79,77.46 188.79,67.42 189.83,66.38 189.83,59.34 190.73,58.44 190.73,56.65 191.47,55.92 191.47,52.65 191.91,52.21 191.91,49.77 191.58,49.44 191.58,46.27 191.75,46.1 v2(191.75,46.08)
  IN3 w0.127: v2(195.8,36.46) 195.8,37.33 196.85,38.38 196.85,43.39 195.42,44.82 192.59,44.82 191.75,45.66 v2(191.75,46.08)
PCH_PWROK_R: length 17.1
  TOP w0.089: v2(127.85,113.15) 128.04,113.34 v1(129.61,113.34) 129.95,113.34 130.46,113.85 RP50.7
  IN3 w0.084: v2(127,103.36) 126.15,104.21 126.15,110.34 126.01,110.48 126.01,111.73 126.15,111.88 126.15,112.66 126.27,112.77 127.48,112.77 v2(127.85,113.15)
  BOTTOM w0.089: v2(127,103.36) 127,103.36 126.89,103.36 126.15,104.09 UC1.AY7
PCH_RSMRST#_R: length 8.7
  TOP w0.089: RC41.2 126.06,100.09 RC33.2 126.06,100.4 v1(127.85,102.19) 127.79,102.25 127.79,103.12 v2(127.74,103.18)
  BOTTOM w0.076: v2(127.74,103.18) 127.74,103.54 127.35,103.94 126.88,103.94 126.87,103.94 126.78,103.94 126.61,104.11 126.61,105.3 126.84,105.53 UC1.AW6
PCH_RTCRST#: length 160.1
  TOP w0.089: 131.19,97.72 130.84,98.07 130.84,102.96 127.2,106.59 v2(126.53,106.59)
  TOP w0.102: v2(163.73,41.91) 163.73,42.85 162.87,43.72 162.87,52.3 166.6,56.03 168.94,56.03 171.63,58.73 172.24,58.73 174.07,60.55 174.07,65.28 173.13,66.22 173.13,72.51 172.61,73.03 v4(172.61,77.37) 172.61,80.83 159.29,94.15 143.74,94.15 142.1,95.8 137.06,95.8 136.44,95.18 132.68,95.18 131.92,95.94 131.92,96.97 132.56,97.61 CC4.2 RC6.2 131.19,97.72
  BOTTOM w0.076: UC1.AU7 126.23,106.89 v2(126.53,106.59)
  BOTTOM w0.102: v2(163.73,41.91) 163.22,42.42 162.56,42.42 162.37,42.23 114.41,42.23 113.6,41.42 CMOS1.2
PCH_RTCX1: length 27.3
  TOP w0.102: v2(132.06,103.17) 131.84,102.95 131.84,100.05 RG3.2
  BOTTOM w0.076: 128.02,104.33 128.02,105.22 UC1.AW5
  BOTTOM w0.089: 131.12,103.17 131.43,103.17
  BOTTOM w0.102: YC1.1 146.92,102.68 CC1.2 146.03,100.26 RC4.1 v1(144.14,100.26) 139.43,100.26 136.51,103.17 v2(132.06,103.17) 131.43,103.17 ; 128.02,104.33 128.36,103.99 129.79,103.99 130.61,103.17 131.12,103.17
PCH_RTCX1_R: length 192.9
  TOP w0.102: RG3.1 132.34,99.02 133.8,97.56 133.8,96.75 134.57,95.98 136.34,95.98 136.74,96.38 142.19,96.38 143.94,94.64 159.49,94.64 173.1,81.02 173.1,73.37 174.55,71.92 174.55,60.35 172.44,58.24 171.83,58.24 169.14,55.55 166.8,55.55 164.41,53.15 v2(164.41,45.74) ; UG1.9 64.72,47.04 64.94,47.26 v1(66.15,47.26) 66.36,47.26 v2(66.73,47.63)
  BOTTOM w0.102: v2(66.73,47.63) 67.17,48.07 135.5,48.07 137.65,45.93 164.21,45.93 v2(164.41,45.74)
PCH_RTCX2: length 25.4
  BOTTOM w0.102: UC1.AY5 127.83,104.8 127.83,104.24 128.27,103.8 129.71,103.8 130.82,102.68 136.31,102.68 139.23,99.77 v1(140.8,99.77) 146.43,99.77 RC4.2 147.78,101.12 CC2.2 149.36,102.72 YC1.2
PCH_SMB_ALERT#: length 20.4
  IN3 w0.084: 137.92,109.53 135.54,109.53 135.47,109.46 134.39,109.46 v2(134.01,109.84)
  IN3 w0.127: v2(145.13,109.5) 144.88,109.74 138.61,109.74 138.4,109.53 137.92,109.53
  BOTTOM w0.076: UC1.AN2 130.08,109.57 130.47,109.57 130.58,109.46 130.85,109.46 130.97,109.34 133.63,109.34 134.01,109.72 v2(134.01,109.84)
  BOTTOM w0.102: R2329.2 142.76,111.07 143.46,110.37 v1(143.69,110.37) 143.89,110.37 144.76,109.5 v2(145.13,109.5)
PCH_SPI_CLK: length 14
  IN1 w0.084: v2(129.28,115.48) 130.04,115.48 131,116.44 137.73,116.44 137.92,116.63
  IN1 w0.127: 137.92,116.63 139.36,118.07 v2(140.94,118.07)
  BOTTOM w0.076: v2(129.28,115.48) 128.98,115.78 UC1.AA3
  BOTTOM w0.102: R2333.2 141.48,117.87 141.28,118.07 v2(140.94,118.07)
PCH_SPI_CLK_R: length 44.4
  IN3 w0.127: v2(143.35,118.5) 143.66,118.5 144.06,118.9 144.99,118.9 145.12,119.03 150.98,119.03 v2(151.4,119.46)
  BOTTOM w0.102: v2(151.4,119.46) 154.14,116.72 154.14,113.22 154.47,112.89 154.47,112.29 155.3,111.46 v1(155.3,109.98) 155.3,107.76 155.52,107.54 155.52,105.66 165.51,95.67 U2302.6 ; R2333.1 142.55,117.86 ; 142.55,117.86 C2326.1 ; 142.55,117.86 142.71,117.86 v2(143.35,118.5)
PCH_SPI_CS0#: length 80.1
  IN3 w0.084: 137.72,120.68 137.54,120.68 136.17,119.3 134.31,119.3 133.68,119.94 130.78,119.94 130.15,119.31 128.17,119.31 127.39,118.54 127.02,118.54 126.77,118.29 125.76,118.29 125.5,118.04 125.5,117.53 125.63,117.4 126.07,117.4 v2(126.52,116.95)
  IN3 w0.127: v2(149.28,121.19) 149.18,121.1 147.72,121.1 147.42,121.39 143.35,121.39 142.94,120.98 140.01,120.98 139.7,120.68 137.72,120.68
  BOTTOM w0.076: UC1.Y7 126.34,116.77 v2(126.52,116.95)
  BOTTOM w0.102: U2302.1 168.05,83.22 166.49,81.66 162.78,81.66 159.78,84.66 159.78,98.67 v1(154.15,104.3) 153.11,105.33 153.11,110.45 152.21,111.35 152.21,115.92 149.28,118.85 v2(149.28,121.19)
PCH_SPI_HOLD1#: length 47.8
  IN3 w0.127: v2(151.4,120.05) 150.86,120.59 150.26,120.59 149.74,120.07 144.7,120.07 144.56,119.93 143.63,119.93 143.23,119.53 142.3,119.53 141.51,120.32 v2(141.51,120.47)
  BOTTOM w0.102: v2(151.4,120.05) 151.5,120.05 154.63,116.92 154.63,113.42 154.96,113.09 154.96,112.49 155.78,111.66 155.78,107.96 156,107.74 156,105.86 v1(163.54,98.32) 166.34,95.53 166.34,92.71 166.78,92.27 U2302.7 ; RP39.4 141.01,119.97 v2(141.51,120.47)
PCH_SPI_HOLD#: length 18.3
  IN1 w0.127: v2(140.94,119.31) 141.57,118.67 141.57,117.84 141.18,117.45 139.46,117.45 138.09,116.08 136.44,116.08 136.05,115.69 136.05,114.92 v2(135.92,114.8)
  BOTTOM w0.076: UC1.AF1 130.32,113.65 134.78,113.65 v1(134.94,113.81) v2(135.92,114.8)
  BOTTOM w0.102: RP39.5 139.44,119.97 139.92,119.49 140.68,119.49 140.86,119.31 v2(140.94,119.31) 141.3,119.31 R2335.2
PCH_SPI_MISO: length 14.1
  IN1 w0.084: v2(127.82,115.99) 130.26,115.99 131.66,117.39 133.94,117.39 136.43,119.88 v2(137.76,119.88)
  BOTTOM w0.089: v2(127.82,115.99) 127.92,115.89 UC1.AA4 ; v2(137.76,119.88) 137.76,120.38 137.92,120.55
  BOTTOM w0.102: 137.92,120.55 138.27,120.89 138.38,120.89 138.46,120.97 RP39.7
PCH_SPI_MISO_1: length 59.9
  IN3 w0.127: v2(142.14,120.47) 142.56,120.04 143.02,120.04 143.86,120.89 147.12,120.89 147.43,120.58 149.53,120.58 v2(149.76,120.81)
  BOTTOM w0.102: v2(149.76,120.81) 149.76,119.05 v1(150.49,118.32) 152.7,116.12 152.7,111.55 153.6,110.65 153.6,105.53 160.26,98.87 160.26,84.86 162.98,82.15 165.76,82.15 166.78,83.16 U2302.2 ; v2(142.14,120.47) 141.64,120.97 RP39.2
PCH_SPI_MOSI: length 13.8
  IN1 w0.084: v2(133.75,117.02) 133.85,117.02 136.2,119.37 137.92,119.37
  IN1 w0.127: v2(138.2,121.4) 138.84,120.77 138.84,120.05 138.16,119.37 137.92,119.37
  BOTTOM w0.076: UC1.AA2 129.86,115.85 130.16,116.15 133.65,116.15 133.75,116.24 v2(133.75,117.02)
  BOTTOM w0.102: RP39.8 138.27,121.47 v2(138.2,121.4)
PCH_SPI_MOSI_1: length 47
  IN3 w0.127: v2(140.87,121.85) 141.18,121.54 142.76,121.54 143.13,121.9 147.64,121.9 147.93,121.61 148.81,121.61 v2(148.87,121.68)
  BOTTOM w0.102: v2(140.87,121.85) 140.87,121.65 140.69,121.47 RP39.1 ; U2302.5 164.24,96.26 154.56,105.93 154.56,108.27 154.82,108.52 154.82,111.26 153.99,112.09 153.99,112.69 153.66,113.02 153.66,116.52 v1(152.58,117.6) 150.9,119.27 150.9,120.77 150,121.68 v2(148.87,121.68)
PCH_SPI_WP1#: length 57.8
  IN3 w0.127: v2(140.87,120.47) 140.87,120.13 141.99,119.01 143.44,119.01 143.85,119.42 144.78,119.42 144.91,119.55 149.94,119.55 v2(150.43,120.04)
  BOTTOM w0.102: U2302.3 165.51,83.01 165.13,82.63 163.18,82.63 160.75,85.06 160.75,99.07 v1(158.11,101.71) 154.08,105.73 154.08,110.85 153.51,111.42 153.51,112.49 153.18,112.82 153.18,116.32 150.4,119.1 150.4,120.01 v2(150.43,120.04) ; RP39.3 v2(140.87,120.47)
PCH_SPI_WP#: length 18.6
  IN1 w0.084: 137.92,120.26 136.51,120.26 133.97,117.72 131.41,117.72 130.14,116.45 127.67,116.45 v2(127.17,116.95)
  IN1 w0.127: 137.92,120.26 v2(138.33,120.26)
  BOTTOM w0.076: v2(127.17,116.95) 126.99,116.77 UC1.Y6
  BOTTOM w0.102: R2334.2 140.67,118.76 140.45,118.98 138.91,118.98 138.33,119.56 v2(138.33,120.26) 138.46,120.26 138.67,120.47 RP39.6
PCH_X1_R: length 254.7
  TOP w0.102: v2(161.73,44.14) 161.73,53.24 168.18,59.69 171.84,59.69 173.1,60.95 173.1,64.67 171.72,66.06 171.72,72.13 171.56,72.3 171.56,80.52 160.97,91.11 121.31,91.11 117.66,94.77 117.66,97.46 117.12,98 117.12,103.52 116.91,103.74 116.91,105.04 117.61,105.74 117.61,111.2 117.05,111.76 117.05,114.51 117.44,114.9 117.44,116.51 118.62,117.69 118.62,119.33 117.94,120.02 117.94,120.48 117.06,121.35 117.06,122.37 116.35,123.08 116.35,125.5 116.02,125.83 116.02,128.46 117.34,129.78 117.34,132.65 119.56,134.88 119.56,137.21 RG6.1 ; v2(69.37,43.55) 69.37,41.52 68.75,40.9 v1(67.33,40.9) 65.09,40.9 64.7,41.29 64.7,42 63.97,42.72 63.97,43.04 64.21,43.28 64.21,43.7 63.92,44 UG1.5
  BOTTOM w0.102: v2(161.73,44.14) 136.07,44.14 135.36,44.85 81.05,44.85 79.76,43.55 v2(69.37,43.55)
PCIE_B+: length 2.7
  BOTTOM w0.102: PJP1301.1 v1(192,60.77)
PCIE_CRX_C_GTX_N0: length 11.8
  TOP w0.102: CV44.2 160.33,119.06 160.88,119.06 161.4,118.54 166.22,118.54 166.75,119.08 167.74,119.08 168.7,120.03 169.13,120.03
  TOP w0.109: v2(169.64,120.73) 169.57,120.73 169.44,120.6 169.44,120.35 169.13,120.03
  BOTTOM w0.102: v2(169.64,120.73) 169.54,120.73 169.26,121 UV1.Y32
PCIE_CRX_C_GTX_N1: length 10.8
  TOP w0.102: v2(169.62,121.79) 169.49,121.79 169.36,121.66 169.36,121.44 169.1,121.18 167.81,121.18 167.65,121.02 167.65,119.83 167.41,119.59 166.44,119.59 166.12,119.91 163.43,119.91 163.15,120.19 v3(162.91,120.19) 162.15,120.19 CV46.2
  BOTTOM w0.102: v2(169.62,121.79) 169.62,122.15 UV1.W32
PCIE_CRX_C_GTX_N2: length 12
  TOP w0.102: CV48.2 160.32,121.4 163.02,121.4 163.82,120.61 165.77,120.61 166.38,121.22 166.92,121.22 167.99,122.28 169.19,122.28 169.39,122.49 169.39,122.86 v2(169.56,123.03)
  BOTTOM w0.102: v2(169.56,123.03) 169.26,123.33 UV1.U32
PCIE_CRX_C_GTX_N3: length 12.1
  TOP w0.102: CV50.2 162.17,122.78 v3(163.12,122.78) 163.94,122.78 164.4,122.32 164.83,122.32 165.29,121.87 165.8,121.87 166.95,123.02 167.48,123.02 167.68,123.22 168.25,123.22 168.77,123.74 171.1,123.74 171.29,123.55 171.29,123.18 v2(171.42,123.04)
  BOTTOM w0.102: v2(171.42,123.04) 171.42,123.09 171.66,123.34 UV1.U29
PCIE_CRX_C_GTX_P0: length 11.8
  TOP w0.102: 169.04,120.24 169.03,120.24 168.61,120.24 167.65,119.28 166.65,119.28 166.14,118.77 165.38,118.77 165.37,118.76 165.05,118.76 165.04,118.77 v3(162.07,118.77) 161.5,118.77 160.98,119.29 160.32,119.29 CV43.2
  TOP w0.109: v2(168.86,120.78) 168.97,120.89 169.11,120.89 169.23,120.76 169.23,120.44 169.04,120.24
  BOTTOM w0.102: v2(168.86,120.78) 168.46,121.18 UV1.Y33
PCIE_CRX_C_GTX_P1: length 10.7
  TOP w0.102: v2(168.76,121.79) 168.88,121.9 169.03,121.9 169.16,121.77 169.16,121.52 169.03,121.39 167.72,121.39 167.44,121.11 167.44,119.92 167.32,119.81 166.53,119.81 166.2,120.14 163.53,120.14 163.23,120.43 162.17,120.43 CV45.2
  BOTTOM w0.102: v2(168.76,121.79) 168.76,122.2 UV1.W33
PCIE_CRX_C_GTX_P2: length 12
  TOP w0.102: CV47.2 160.33,121.63 163.12,121.63 163.91,120.84 v3(165,120.84) 165.69,120.84 166.29,121.43 166.84,121.43 167.9,122.49 169.1,122.49 169.18,122.58 169.18,122.8 v2(168.95,123.03)
  BOTTOM w0.102: UV1.U33 168.46,123.2 168.63,123.03 v2(168.95,123.03)
PCIE_CRX_C_GTX_P3: length 12.2
  TOP w0.102: CV49.2 162.16,122.56 163.84,122.56 164.29,122.11 164.74,122.11 165.2,121.66 165.87,121.66 167.01,122.79 v3(167.25,122.79) 167.54,122.79 167.76,123.01 168.33,123.01 168.85,123.53 171.02,123.53 171.08,123.47 171.08,123.29 170.89,123.1 v2(170.64,123.1)
  BOTTOM w0.102: UV1.U30 171.03,123.53 171.03,123.3 170.83,123.1 v2(170.64,123.1)
PCIE_PRX_LANTX_N3: length 104.6
  IN1 w0.084: 88.91,114.2 89.37,114.2 90.01,113.57 91.85,113.57 92.49,112.92 94.23,112.92 94.42,112.73 95.71,112.73 97.24,114.26 113.6,114.26 113.79,114.45 116.86,114.45 117.35,114.94 117.35,116.52 118.81,117.98 118.81,120.12 120.75,122.06 123.49,122.06 123.82,122.39 123.82,124.2 123.71,124.31 123.57,124.31 123.44,124.18 v2(123.44,123.94)
  IN1 w0.127: v2(41.88,93.99) 42.07,93.79 44.2,93.79 47.75,97.35 47.75,99.97 56,108.22 62.73,108.22 65.1,110.6 67.06,110.6 67.72,111.26 72.87,111.26 74.7,113.09 77.89,113.09 78.53,113.73 87.42,113.73 87.89,114.2 88.91,114.2
  BOTTOM w0.089: v2(123.44,123.94) 123.58,123.94 UC1.G11
  BOTTOM w0.102: CL31.1 42.54,92.24 42.54,93.44 42.29,93.68 42.19,93.68 v2(41.88,93.99)
PCIE_PRX_LANTX_N3_C: length 4.1
  BOTTOM w0.102: UL1.18 40.27,88.94 40.35,89.02 40.55,89.02 v3(41.08,89.55) 41.63,90.1 42.45,90.1 42.73,90.37 42.73,90.68 CL31.2
PCIE_PRX_LANTX_P3: length 104.6
  IN1 w0.084: 88.91,113.93 88.93,113.93 88.95,113.95 89.01,113.95 89.03,113.97 89.28,113.97 89.91,113.34 91.75,113.34 92.4,112.69 94.14,112.69 94.33,112.5 95.81,112.5 97.34,114.03 113.69,114.03 113.88,114.23 116.96,114.23 117.58,114.84 117.58,116.43 119.04,117.89 119.04,120.03 120.84,121.83 123.59,121.83 124.05,122.29 124.05,124.29 123.81,124.54 123.52,124.54 v2(123.41,124.64)
  IN1 w0.127: 88.91,113.93 88,113.93 87.53,113.46 78.64,113.46 78,112.82 74.81,112.82 72.98,110.99 67.83,110.99 67.17,110.32 65.22,110.32 62.84,107.95 56.11,107.95 48.02,99.86 48.02,97.23 44.31,93.52 41.99,93.52 v2(41.88,93.4)
  BOTTOM w0.089: UC1.F11 123.75,124.3 v2(123.41,124.64)
  BOTTOM w0.102: v2(41.88,93.4) 41.93,93.46 42.2,93.46 42.32,93.35 42.32,92.08 CL30.1
PCIE_PRX_LANTX_P3_C: length 4.2
  BOTTOM w0.102: CL30.2 42.14,90.98 42.45,90.98 42.5,90.93 42.5,90.47 42.35,90.32 41.53,90.32 40.45,89.24 40.35,89.24 40.26,89.34 UL1.17
PCIE_PRX_WLANTX_N4: length 56.7
  IN3 w0.084: v2(122.52,124.68) 122.66,124.54 122.77,124.54 122.86,124.45 123.07,124.24 123.07,122.37 122.69,121.99 118.39,121.99 117.36,123.03 117.36,124.55 116.98,124.92 116.98,126.44 117.37,126.82 117.37,132.02 118.06,132.71 118.06,132.74 118.12,132.8 118.11,132.81 118.11,132.82 118.12,132.83
  IN3 w0.127: JMINI.23 104.3,151.65 104.38,151.57 104.38,151.05 104.8,150.63 113.31,150.63 114.15,149.79 119.28,149.79 122.08,146.99 122.08,139.88 118.27,136.07 118.27,132.98 118.12,132.83
  BOTTOM w0.076: v2(122.52,124.68) 122.89,124.3 UC1.F13
PCIE_PRX_WLANTX_P4: length 56.6
  IN3 w0.084: v2(122.52,123.93) 122.41,123.93 122.27,124.07 122.27,124.24 122.33,124.3 122.71,124.3 122.89,124.12 122.89,122.49 122.6,122.2 118.48,122.2 117.57,123.12 117.57,124.64 117.2,125.01 117.2,126.35 117.58,126.73 117.58,131.93 118.3,132.65
  IN3 w0.127: 118.3,132.65 118.52,132.87 118.52,135.97 122.33,139.78 122.33,147.09 119.38,150.04 114.26,150.04 113.42,150.88 104.91,150.88 104.64,151.15 104.64,151.52 104.77,151.66 104.94,151.66 105.1,151.82 JMINI.25
  BOTTOM w0.089: UC1.G13 122.79,123.65 v2(122.52,123.93)
PCIE_PTX_LANRX_N3: length 12.7
  BOTTOM w0.102: CC32.1 39.59,101.7 39.59,100.46 39.6,100.45 39.6,99.91 39.59,99.9 39.59,99.26 38.26,97.93 v3(38.26,94.5) 38.26,90.68 38.35,90.59 UL1.14
PCIE_PTX_LANRX_N3_C: length 95.9
  IN1 w0.084: 86.76,120.77 87.03,120.77 87.05,120.74 90.79,120.74 92.21,122.17 93.67,122.17 94.39,122.89 94.39,123.31 94.13,123.57 94.13,124.15 95.64,125.66 111.58,125.66 113.11,127.2 113.11,129.32 112.94,129.49 112.77,129.49 112.55,129.26 v2(112.55,129.18)
  IN1 w0.127: 86.76,120.77 84.42,120.77 83.4,119.75 74.53,119.75 69.42,114.63 50.52,114.63 46,110.11 43.06,110.11 39.76,106.82 39.76,104.94 39.41,104.59 38.71,104.59 v2(38.51,104.79)
  BOTTOM w0.076: v2(112.55,129.18) 112.55,129.25 112.36,129.43 112.3,129.43 112.16,129.29 112.16,128.1 112.76,127.49 112.76,126.74 113.06,126.45 UC1.C29
  BOTTOM w0.102: v2(38.51,104.79) 38.7,104.6 39.18,104.6 39.49,104.29 39.49,103.35 CC32.2
