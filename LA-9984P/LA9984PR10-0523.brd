# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N39986171: length 12.9
  BOTTOM w0.102: QV24.1 180.24,92.25 180.93,91.56 184.3,91.56 185.13,92.38 186.58,92.38 v1(187.03,92.83) RV107.2 RV108.1
N39986181: length 4.2
  BOTTOM w0.102: v1(189.26,97.92) RV108.2 189.24,96.82 CV103.1 188.06,96.7 QV22.2
N40812716: length 3.5
  TOP w0.305: UR1.6 178.32,22.23 178.53,22.02 179.85,22.02 v1(180.11,21.76) CR3.2
N45520480: length 3.3
  TOP w0.102: RV206.2 174.55,127.79 v2(173.96,127.2) 173.91,127.2 v1(173.33,127.78)
  BOTTOM w0.102: UV1.M27 173.46,127.52 173.78,127.2 v2(173.96,127.2)
N46608735: length 2.4
  BOTTOM w0.254: PR701.1 v1(141.93,165.9) 141.21,166.62 PQ701.2
N46608740: length 3.3
  BOTTOM w0.102: v1(137.93,170.5) 137.93,170.17 139.58,168.52 PQ701.4
N46608753: length 6.4
  BOTTOM w0.254: PR701.2 PR703.1 144,167.02 144.83,167.02 145.13,167.31 v1(145.13,168.39) 144.87,168.64 PC702.1 143.81,169.01 PC701.2
N46612327: length 3.5
  TOP w0.102: v1(166.6,176.04) 166.63,176.04 167.62,175.05 PR708.1
  TOP w0.254: PU701.13 167.99,174.73 PR708.1
N46612330: length 1.9
  TOP w0.254: PU701.12 v2(168.49,174.3) 168.49,174.97 PR710.1
N46660696: length 1.3
  TOP w0.102: PC520.2 v1(107.22,147.06)
N46662317: length 3.6
  TOP w0.102: v1(84.81,140.3) 84.81,140.16 85.45,139.52 86.11,139.52 v2(86.33,139.31)
  TOP w0.254: v2(86.33,139.31) 86.39,139.24 PR510.1
  BOTTOM w0.203: v2(86.33,139.31) 86.4,139.23 PU501.4
N46663656: length 3.4
  TOP w0.102: v1(85.96,138.83) 85.96,138.66 86.3,138.31 v2(86.34,138.31)
  TOP w0.254: v2(86.34,138.31) 86.38,138.36 PC504.1
  BOTTOM w0.203: PU501.2 86.45,138.43 v2(86.34,138.31)
  BOTTOM w0.254: PR516.2 85.81,137.78 v2(86.34,138.31)
N46665785: length 3.1
  BOTTOM w0.102: PR529.1 93.26,134.01 93.7,134.01 v1(94.38,133.34)
  BOTTOM w0.254: PC514.1 92.29,134.67 92.36,134.61 PR529.1
N46673636: length 6.7
  TOP w0.102: v2(93,144.39) v1(93,145.04)
  IN1 w0.254: v2(93,144.39) 92.89,144.49 92.89,144.83 93.85,145.78 96.1,145.78 96.43,146.11 v2(96.43,146.22)
  BOTTOM w0.254: v2(96.43,146.22) 96.43,145.53 PH501.2 ; PR515.1 92.99,143.77 92.99,144.39 v2(93,144.39)
N46674251: length 19.1
  BOTTOM w0.254: PR518.2 v1(94.44,147.5) 100.83,147.5 102.33,146.01 102.33,142.61 102.77,142.17 PL502.2
N46860163: length 5.8
  TOP w0.254: PR713.2 172.46,173.86 v1(172.46,174.65) 171.98,175.12 PQ708.1 171.23,175.12 170.02,173.92 170.02,173.92 169.7,173.6 169.7,172.45 PU701.10
N46975913: length 2.5
  BOTTOM w0.102: v1(119.28,142.24) 118.56,142.24 PR536.2
  BOTTOM w0.254: PR536.2 118.22,141.65 117.62,141.05 PC501.1
N46975982: length 5.4
  BOTTOM w0.102: PR536.1 117.62,142.7 118.51,142.7 118.98,143.17 119.83,143.17 v1(119.98,143.32)
  BOTTOM w0.203: PR536.1 116.45,141.9 115.9,142.44 PU502.6
N46976065: length 4.9
  BOTTOM w0.102: v1(115.54,138.37) 115.54,139.66 PC501.2
  BOTTOM w0.203: PU502.7 115.83,142.04 116.25,141.63 116.25,141.29 PC501.2
N47007806: length 3.7
  TOP w0.102: v1(126.64,167.52) 127.46,168.34 PR28.2
  TOP w0.254: PQ2.3 127.66,169.52 PC16.1 127.47,168.9 127.46,168.89 PR28.2
N47007810: length 4.4
  TOP w0.102: PR29.1 127.65,172.68 v1(127.37,172.96)
  TOP w0.254: PQ2.2 127.55,170.17 PC16.2 127.47,171.5 127.65,171.68 PR29.1
N47007850: length 4.4
  TOP w0.102: v1(132.45,167.76) 131.88,168.33 PR33.2
  TOP w0.254: PR33.2 131.98,168.89 PR31.1 131.8,169.71 131.35,170.17 PQ2.5
N47007898: length 3.7
  TOP w0.102: v1(133.45,164.72) PR32.1
  TOP w0.254: PC14.2 PR32.1 131.78,164.72 131.54,164.96 PQ3.5
N47008006: length 1.3
  TOP w0.102: PR10.2 v1(127.51,178.61)
N47008110: length 3.5
  TOP w0.102: v1(126.55,165.31) 126.82,165.58 PC15.1
  TOP w0.254: PQ3.2 128.17,164.96 127.93,164.72 PR30.2 PC15.1
N47008134: length 8.3
  TOP w0.102: v1(132.41,183.43) 131.59,184.25 PR6.2
  TOP w0.254: v2(130.97,184.77) 131.03,184.71 PR6.2
  BOTTOM w0.254: v2(130.97,184.77) 130.71,184.52 PL2.2 128.97,184.67 PQ6.1
N47008301: length 1.2
  TOP w0.102: PQ4.1 127.92,181.35 v1(127.28,180.71)
N47305899: length 2.1
  BOTTOM w0.102: v1(215.45,62.31) 214.21,63.54 PR805.1
N47415217: length 2.2
  TOP w0.102: v1(206.86,14.31) PC104.2
  TOP w0.254: PC104.2 PR103.1
N47415258: length 1.8
  BOTTOM w0.102: PR113.2 v1(209.41,17.27)
N47415272: length 3.2
  BOTTOM w0.102: PR112.2 209.79,24.39 v1(208.75,23.35)
N47415370: length 2.6
  TOP w0.102: v1(206.75,26.28) 207.47,25.56 PC110.1
  TOP w0.254: PC110.1 PR111.2
N47417471: length 0.9
  BOTTOM w0.102: 104.31,14.82 103.89,14.82 v1(103.57,15.14)
N47417524: length 1.2
  BOTTOM w0.102: v1(103.72,19.31) 104.61,19.31 PR405.2
N47420895:
  vias: v1(159.12,13.17)
N47445410: length 2.2
  TOP w0.203: PU100.19 206.75,22.32 206.58,22.48 PR114.1
N47894294: length 1.9
  BOTTOM w0.089: v1(98.94,96.56) 98.83,96.66 RC23.1 97.97,96.68 CC8.2
N47894380: length 2
  BOTTOM w0.089: RC24.1 93.51,97.53 CC9.2 93.5,98.08 v1(93.89,98.48)
N47894401: length 3.4
  BOTTOM w0.089: RC25.1 95.29,97.53 CC10.2 95.28,98.36 v1(96.45,99.53)
N47938591: length 9.3
  TOP w0.089: T118.1 122.7,101.74 122.7,106.54 124.49,108.32 124.49,108.51 125.04,109.07 v2(125.05,109.07)
  BOTTOM w0.089: UC1.AN10 124.62,109.49 v2(125.05,109.07)
N47938593: length 1.6
  TOP w0.089: v2(125.06,109.72) 124.64,109.3 T119.1
  BOTTOM w0.076: v2(125.06,109.72) 124.63,110.14 UC1.AM10
N47938689: length 1.3
  TOP w0.089: v2(121.56,125.28) 121.95,124.89 T120.1
  BOTTOM w0.089: v2(121.56,125.28) 121.89,124.95 UC1.E15
N47938710: length 1.9
  TOP w0.089: T121.1 122.52,126.58 122.52,125.31 v2(122.53,125.3)
  BOTTOM w0.089: UC1.E13 122.88,124.95 v2(122.53,125.3)
N47964855: length 5.3
  BOTTOM w0.076: UC1.L60 93.3,120.8 92.83,120.8 92.78,120.85 92,120.85 91.84,120.68 91.06,120.68 90.73,121.02 T153.1
N47964866: length 1.4
  TOP w0.254: v2(93.3,120.02) 92.89,119.61 T154.1
  BOTTOM w0.254: v2(93.3,120.02) 93.6,120.32 UC1.N60
N47964871: length 3.9
  TOP w0.089: v2(116.14,116.49) 116.14,116.47 116.87,115.74 116.87,115.13 T155.1
  BOTTOM w0.076: UC1.W23 116.55,116.89 v2(116.14,116.49)
N47964873: length 1.7
  TOP w0.089: v2(116.79,116.49) 116.79,117.33 T156.1
  BOTTOM w0.076: UC1.Y22 v2(116.79,116.49)
N47964879: length 9.3
  BOTTOM w0.076: UC1.AV62 91.95,105.91 91,105.91
  BOTTOM w0.102: T157.1 88.79,99.1 88.79,102.94 89.13,103.28 89.13,104.04 91,105.91
N47964884: length 6.3
  BOTTOM w0.076: T158.1 93.31,129.45 94.81,127.95 94.81,127.42 94.67,127.28 94.67,126.98 94.71,126.94 94.71,126.79 94.64,126.73 94.64,126.45 94.73,126.36 94.73,126.18 94.63,126.08 94.63,125.79 94.94,125.48 UC1.D58
N47965485: length 4.4
  BOTTOM w0.102: UC1.AV63 91.21,106.24 91.08,106.1 90.92,106.1 88.65,103.83 88.65,103.52 T146.1
N47965487: length 8.8
  BOTTOM w0.089: 88,103.75 88,102.15 87.52,101.66
  BOTTOM w0.102: T147.1 87.52,101.66 ; UC1.AU63 91.14,106.9 88,103.75
N47965489: length 1.3
  TOP w0.089: T160.1 119.32,119.93 v2(119.71,119.54)
  BOTTOM w0.076: UC1.P20 119.3,119.54 v2(119.71,119.54)
N47965491: length 1.3
  TOP w0.089: T162.1 119.97,118.13 v2(119.62,118.48)
  BOTTOM w0.076: v2(119.62,118.48) 119.17,118.93 UC1.R20
N47965493: length 5
  BOTTOM w0.089: 130.94,130.52 130.72,130.52
  BOTTOM w0.102: T159.1 130.94,130.52 ; 130.72,130.52 130.59,130.38 130.59,130.16 129.57,129.15 129.14,129.15 127.72,127.73 UC1.A5
N47965495: length 4.4
  BOTTOM w0.102: T148.1 87.56,126.94 89.42,126.94 89.71,126.65 91.17,126.65 91.56,126.26 UC1.C63
N47965502: length 3.2
  BOTTOM w0.076: T161.1 132.8,125.05 UC1.E1
N47965509: length 4.3
  BOTTOM w0.076: UC1.C62 92.04,125.93 91.51,125.93 90.99,126.45 89.94,126.45
  BOTTOM w0.089: 88.91,126.38 88.99,126.45 89.94,126.45
  BOTTOM w0.102: T149.1 88.91,126.38
N47965511: length 4.3
  BOTTOM w0.076: UC1.D1 131.72,125.71 132.38,126.37 134.12,126.37 T163.1
N47965522: length 5.7
  BOTTOM w0.076: UC1.B43 104.41,127.16 104.7,127.45 104.7,127.69 103.98,128.41 103.98,129.87
  BOTTOM w0.102: 103.98,129.87 103.98,130.35 104.73,131.1 T150.1
N47965524: length 1.2
  TOP w0.089: v2(118.66,122.67) 118.53,122.54 T164.1
  BOTTOM w0.089: v2(118.66,122.67) 118.78,122.67 UC1.J20
N47965529: length 3.6
  BOTTOM w0.076: UC1.A51 99.39,129.63 T151.1
N47965534: length 4.1
  BOTTOM w0.076: UC1.B51 99.39,127.16 99.98,127.74 T152.1
N47965536: length 1.2
  TOP w0.089: v2(119.66,123.33) 119.35,123.64 T165.1
  BOTTOM w0.076: v2(119.66,123.33) 119.98,123 UC1.H18
N48037563: length 4.6
  TOP w0.102: RD6.2 103.96,70.79 v2(104.04,70.71) 104.28,70.71 v1(104.51,70.94)
  BOTTOM w0.102: JDIMM1.197 103,71.45 103.74,70.71 v2(104.04,70.71)
N48037565: length 5.1
  TOP w0.102: v1(104.54,69.56) 104.15,69.95 v2(104.04,69.95) 104,69.9 RD7.2
  BOTTOM w0.102: JDIMM1.201 104.2,72.47 104.49,72.19 104.49,70.39 v2(104.04,69.95)
N48039107: length 6
  TOP w0.102: v1(81.61,62.68) 81.5,62.79 v2(81.5,63.43) 81.5,63.81 81.69,64 CD21.1 CD22.1 83.46,65.43 RD4.1
  BOTTOM w0.102: JDIMM1.126 81.7,64.01 81.5,63.81 v2(81.5,63.43)
N48051997: length 5.3
  TOP w0.102: v2(160.25,63.51) v1(160.25,62.76)
  TOP w0.508: v2(160.25,63.51) 160.3,63.56 CD52.1 CD53.1 162.06,64.56 RD10.1
  BOTTOM w0.356: v2(160.25,63.51) JDIMM2.126
N48052813: length 7.9
  TOP w0.102: v2(182.59,69.49) 182.76,69.49 183.19,69.92 183.19,71.21 v1(183.15,71.25) 183.1,71.3 183.1,72.18 RD13.1
  BOTTOM w0.102: JDIMM2.197 181.55,72.05 182.03,71.57 182.03,70.05 182.59,69.49 v2(182.59,69.49)
N48052822: length 7.1
  TOP w0.102: v4(183.29,69.23) 182.97,68.91 v2(182.59,68.91) 182.79,68.7 RD12.1
  BOTTOM w0.102: JDIMM2.201 182.75,72.01 183.04,71.72 183.04,69.35 v2(182.59,68.91)
N48120577: length 3.1
  TOP w0.102: UX4.12 200.9,170.19 200.79,170.08 200.79,169.06 200.69,168.96 v1(200.23,168.96) 199.56,168.96 RX5.2
N55155843: length 2.5
  TOP w0.102: v1(226.38,177.5) 226.25,177.62 RX3.2 225.9,178.89 QX1.1
N55200533: length 18
  TOP w0.102: 14.82,105.45 14.82,104.95 ; 14.82,105.45 14.82,105.59 v2(16,106.76) ; 14.82,105.45 RP59.5 ; 14.82,104.95 14.82,104.45 ; 14.82,104.95 RP59.6 ; 13.5,99.99 13.5,99.49 ; 13.5,99.99 13.5,100.89 v1(14.82,102.22) 14.82,103.95 ; 13.5,99.99 RP58.5 ; 13.5,99.49 RP58.6 ; 13.5,99.49 13.5,98.99 ; RP59.7 14.82,104.45 ; 14.82,104.45 14.82,103.95 ; RP58.7 13.5,98.99 ; 13.5,98.99 13.5,98.6 13.61,98.49 RP58.8 ; RP59.8 14.82,103.95
  BOTTOM w0.102: v2(16,106.76) 18.06,108.83 QX3.1
N55201771: length 11.3
  TOP w0.102: v2(13.05,112.57) 13.05,112.99 v1(12.82,113.22)
  IN3 w0.127: v2(13.05,112.57) 9.87,112.57 8.73,111.43 8.73,108.1 JHDMI.13
  BOTTOM w0.102: RX12.2 13.06,112.56 v2(13.05,112.57)
N56393123: length 3
  BOTTOM w0.203: 36.5,85.19 36.75,85.44 UL1.31
  BOTTOM w0.254: 35.46,84.82 35.46,84.46 35.08,84.08 RL31.2 ; 35.46,84.82 35.72,85.08 36.39,85.08 36.5,85.19 ; 35.46,84.82 v1(35.46,84.86)
N56393790: length 6.3
  BOTTOM w0.102: T94.1 40.31,81.08 40.31,83.14 39.86,83.6 39.86,83.61 38.35,85.11 UL1.27
N56393809: length 2.1
  BOTTOM w0.102: T95.1 39.15,85.33 UL1.25
N56393828: length 7.2
  BOTTOM w0.102: T96.1 43.58,81.66 41.91,81.66 41.2,82.37 41.2,82.58 40.08,83.69 40.08,83.88 38.75,85.22 UL1.26
N56394014: length 7.3
  TOP w0.102: v1(21.77,86.67) RL19.2
  TOP w0.254: RL19.2 RL20.2 19.78,85.65 19,84.88 19,81.98 CL33.1
N56394031: length 6.6
  BOTTOM w0.102: TL1.3 31.92,88.13 32.41,87.63 32.41,87.11 CL41.2 32.93,86.49 v1(32.93,85.59) 31.66,84.32 TL1.6
N60531222: length 72.5
  TOP w0.102: v2(146.43,128.51) v1(145.85,127.93) 145.55,127.63 145.55,123.27 149.22,119.59 149.22,118.03 149.72,117.53 149.72,114.82 147.95,113.05 146.07,113.05 145,111.98 144.01,111.98 143.58,112.41 142.75,112.41 v2(142.34,112.81)
  IN1 w0.084: v2(108.57,127.73) 109.25,127.05 111.6,127.05 112.11,127.56 112.11,130.61 112.3,130.8 114.9,130.8 116.36,132.26 121.26,132.26 122.71,130.81 122.71,129.85 124.36,128.2 135.28,128.2 135.89,127.59 136.53,127.59
  IN1 w0.127: v2(146.43,128.51) 146.43,128.5 145.52,127.59 136.53,127.59
  BOTTOM w0.076: UC1.C35 109.11,126.55 109.01,126.7 108.96,126.85 108.96,127.04 108.98,127.07 109.02,127.19 109.02,127.3 108.96,127.46 108.87,127.56 108.74,127.69
  BOTTOM w0.089: 108.74,127.69 108.7,127.73 v2(108.57,127.73)
  BOTTOM w0.102: RP41.1 142.08,113.3 142.01,113.24 142.01,113.13 142.34,112.81 v2(142.34,112.81)
N60531228: length 70.4
  TOP w0.102: v2(145.84,128.51) 145.32,127.99 145.32,123.18 148.84,119.65 148.84,117.9 149.34,117.39 149.34,116.63 148.84,116.12 148.84,114.64 147.64,113.44 v1(145.88,113.44) 144.97,113.44 144.48,112.94 143.08,112.94 v2(142.95,112.81)
  IN1 w0.084: 136.69,127.85 136.06,127.85 135.54,128.37 124.43,128.37 122.88,129.92 122.88,130.91 121.36,132.43 116.29,132.43 114.83,130.97 112.23,130.97 111.93,130.68 111.93,127.63 111.53,127.22 109.94,127.22 v2(109.09,128.07)
  IN1 w0.127: v2(145.84,128.51) 145.18,127.85 136.69,127.85
  BOTTOM w0.076: 109.11,127.57 109.11,127.55 109.19,127.33 109.19,127.16 109.16,127.08 109.15,127.06 109.13,127.01 109.13,126.87 109.16,126.77 109.37,126.56 109.54,126.56 109.71,126.39 UC1.C34
  BOTTOM w0.089: 109.11,127.57 109.11,128.05 v2(109.09,128.07)
  BOTTOM w0.102: RP41.2 142.63,113.8 142.95,113.48 v2(142.95,112.81)
N60531230: length 21.3
  TOP w0.102: v2(141.76,112.81) 141.76,112.86 v1(142.19,113.3)
  IN1 w0.084: v2(125.78,112.19) 126.3,112.7 128.17,112.7 128.51,113.04 129.34,113.04 130.6,111.79 134.65,111.79 134.88,112.01 136.41,112.01
  IN1 w0.127: 136.41,112.01 136.75,111.67 137.54,111.67 138.01,112.14 141.09,112.14 141.76,112.8 v2(141.76,112.81)
  BOTTOM w0.089: UC1.AK8 125.99,111.13 125.99,111.96 125.78,112.17 v2(125.78,112.19)
  BOTTOM w0.102: RP41.3 141.96,114.3 141.82,114.16 141.82,113.79 141.76,113.72 v2(141.76,112.81)
N60531232: length 25.7
  TOP w0.102: v2(141.17,112.81) 139.47,112.81 v1(139.4,112.74)
  IN1 w0.084: v2(125.47,111.17) 125.07,111.17 124.74,111.49 124.74,111.56 124.74,111.57 124.74,112.11 124.78,112.16 124.78,112.93 125.45,113.6 129.03,113.6 130.67,111.96 134.58,111.96 134.81,112.18 136.3,112.18 137.14,113.02 137.61,113.02
  IN1 w0.127: v2(141.17,112.81) 140.96,113.02 137.61,113.02
  BOTTOM w0.089: v2(125.47,111.17) 125.97,110.66 UC1.AL8
  BOTTOM w0.102: v2(141.17,112.81) 141.32,112.96 141.32,113.61 141.6,113.89 141.6,114.57 141.83,114.8 RP41.4
N60754677: length 4.9
  TOP w0.089: T111.1 89.21,124.35 89.8,123.76 v2(89.8,123.64)
  BOTTOM w0.076: v2(89.8,123.64) 90.19,123.24 90.72,123.24 90.8,123.32 91.3,123.32 91.38,123.24 91.53,123.1 91.77,123.1 91.94,123.27 91.94,123.44 92.18,123.68 92.7,123.68 UC1.H61
N60754679: length 4.3
  BOTTOM w0.076: 89.05,123.3 89.28,123.08 90.83,123.08 90.91,123.15 91.24,123.15 91.31,123.08 91.31,123.08 91.46,122.93 91.84,122.93 91.85,122.94 91.85,122.94 UC1.H62
  BOTTOM w0.089: 88.91,123.44 89.05,123.3
  BOTTOM w0.102: T112.1 88.61,123.74 88.91,123.44
N60754681: length 1.2
  TOP w0.089: v2(94.67,122.24) 94.51,122.09 T113.1
  BOTTOM w0.076: v2(94.67,122.24) 94.35,121.93 UC1.K59
N60754683: length 2.1
  TOP w0.089: T114.1 90.52,123.77 v2(90.39,123.65)
  BOTTOM w0.076: v2(90.39,123.65) 90.55,123.49 91.55,123.49 UC1.H63
N60754685: length 1.4
  TOP w0.089: T115.1 93.3,121.25 v2(93.3,121.51)
  BOTTOM w0.076: UC1.K60 93.6,121.81 v2(93.3,121.51)
N60754687: length 1.2
  TOP w0.089: T116.1 92.74,122.92 v2(92.65,123.01)
  BOTTOM w0.076: UC1.J61 92.95,122.71 v2(92.65,123.01)
N60931942: length 4.5
  BOTTOM w0.076: T97.1 133.6,114.73 132.43,114.73 131.91,114.21 130.55,114.21 130.4,114.06 130.09,114.06 130.08,114.05 130.07,114.05 UC1.AF2
N60931944: length 5.6
  BOTTOM w0.076: UC1.AF4 128.65,113.24 129.04,113.24 129.14,113.15 129.92,113.15 130.09,113.31 130.4,113.31 130.54,113.46 132.47,113.46
  BOTTOM w0.089: T99.1 133.42,113.46 132.47,113.46
N60931946: length 6.2
  BOTTOM w0.076: T98.1 134.8,115.22 133.19,115.22 132.73,115.67 132.16,115.67 132.03,115.55 132.03,115.34 131.51,114.82 130.33,114.82 129.86,114.36 UC1.AD2
N61580896: length 5.8
  TOP w0.102: v1(180.53,63.29) 181.64,62.18 Q2307.1 182.97,63.23 183.16,63.43 183.48,63.43 183.8,63.11 R2314.2
N61580898: length 3.8
  TOP w0.102: Q2308.1 147.9,123.71 R2315.2 147.26,124.7 v1(148.34,125.78)
N63469417: length 3.9
  TOP w0.102: RA79.1 CA65.2 CA69.1 RA81.2 v1(46.18,30.85)
N63469524: length 16.8
  TOP w0.254: CA68.2 38.19,31.63 v2(38.45,31.88)
  BOTTOM w0.254: RA82.1 27.97,22.42 28.43,21.96 30.56,21.96 34.25,25.65 34.25,27.37 v1(38.01,31.13) 38.45,31.57 v2(38.45,31.88)
N63469526: length 14.5
  TOP w0.254: v2(37.24,31.88) 36.99,31.63 CA67.2
  BOTTOM w0.254: RA80.1 v1(30.31,22.47) 33.74,25.91 33.74,27.4 37.24,30.9 v2(37.24,31.88)
N63469613: length 3.4
  TOP w0.102: CA65.1 43.74,28.69 43.34,28.29 43.34,27.69 43.4,27.63 v1(43.4,27.54) 43.4,27.38 43.03,27.02 UA1.12
N63469617: length 3.6
  TOP w0.102: v1(41.1,28.98) 41.54,28.55 41.54,28.17
  TOP w0.203: UA1.13 41.54,28.17 41.77,28.41 41.99,28.41 42.33,28.76 42.33,29.36 RA51.1
N63469687: length 2.7
  TOP w0.203: UA1.28 35.97,25.82 35.9,25.89 35.43,25.89 35.04,26.28 CA23.2
N63469697: length 5.1
  TOP w0.102: v1(40.92,32.17) 40.28,31.52 40.28,30.47 RA153.2
  TOP w0.203: RA153.2 40.99,29.76 40.99,29.48 40.64,29.14 40.64,28.39 40.74,28.3 UA1.15
N63469703: length 3.5
  TOP w0.102: v1(34.71,21.16) CA24.1 34.98,22.15 35.29,21.84 UA1.37
N63469709: length 4.9
  TOP w0.102: v1(33.11,20.45) 33.11,20.89 33.8,21.58 CA24.2 34.36,22.71 34.62,22.71 34.81,22.9 35.64,22.9 35.76,23.02 UA1.35
N63469711: length 2.2
  TOP w0.102: UA1.34 35.83,23.42 35.64,23.23 v1(35.18,23.23) 34.33,23.23 CA25.2
N63469717: length 3
  TOP w0.203: CA62.2 34.3,27.48 v1(35.09,26.69) 35.56,26.22 UA1.27
N63469723: length 3.6
  TOP w0.203: 37.75,20.49 37.75,20.94 37.94,21.13 UA1.39
  TOP w0.254: 37.75,20.49 v1(37.51,20.25) 36.1,20.25 CA63.2
N63469729: length 6
  TOP w0.102: UA1.7 43.94,25.02 44.07,25.15 46.33,25.15 CA64.2 46.64,25.99 v1(47.35,26.7)
N63469750: length 2.2
  TOP w0.102: UA1.8 v1(43.48,25.42) 43.81,25.42 44.03,25.64 RA130.2
N63642793: length 44.4
  TOP w0.089: v2(123.39,111.78) 123.79,112.18 123.79,112.57 123.99,112.78 125.74,112.78 126.16,112.37 126.16,109.45 126.76,108.85 127.24,108.85 127.24,108.85 129.36,108.85 129.86,108.35 133.1,108.35 136.13,105.31 136.13,103.56 136.24,103.46
  TOP w0.102: 136.24,103.46 138.71,100.98 139.14,100.98 139.8,100.32 142.83,100.32 143.46,100.95 v1(150.33,100.95) 150.84,101.46 150.84,105.75 150.65,105.95 149.79,105.95 149.57,106.16 R264.2 149.57,107.3 149.5,107.38 C51.1
  BOTTOM w0.089: UC1.AH11 123.71,112.1 v2(123.39,111.78)
N63643467: length 1
  TOP w0.089: v2(122.52,122.68) 122.02,122.68 T53.1
  BOTTOM w0.089: UC1.J13 122.59,122.68 v2(122.52,122.68)
N63643476: length 1.3
  TOP w0.254: T55.1 122.62,111.51 v2(122.62,111.77)
  BOTTOM w0.254: v2(122.62,111.77) 122.94,112.1 UC1.AH13
N63643505: length 1
  TOP w0.254: T56.1 125.86,116 v2(125.87,115.99)
  BOTTOM w0.254: v2(125.87,115.99) 125.69,115.82 UC1.AB8
N63643514: length 1.6
  TOP w0.089: v2(124.03,114.45) 124.01,114.43 T58.1
  BOTTOM w0.089: v2(124.03,114.45) 124.15,114.57 UC1.AD10
N63643523: length 1.1
  TOP w0.089: T59.1 125.68,114.85 v2(125.89,115.05)
  BOTTOM w0.089: UC1.AD8 125.69,114.85 v2(125.89,115.05)
N63656577: length 6.9
  TOP w0.089: T38.1 111.11,115.95 113.92,115.95 114.1,115.76 116.05,115.76 v2(116.14,115.68)
  BOTTOM w0.254: UC1.AB23 116.55,115.27 116.14,115.68 v2(116.14,115.68)
N63657072: length 5.2
  BOTTOM w0.076: UC1.P60 93.31,119.31 92.83,119.31 92.79,119.35 92,119.35 91.84,119.18 91.53,119.18
  BOTTOM w0.089: 91.53,119.18 91.52,119.18 88.91,119.18
  BOTTOM w0.102: T39.1 88.91,119.18
N63657081: length 1.6
  TOP w0.089: v2(92.65,120.02) 91.88,120.02 T40.1
  BOTTOM w0.089: v2(92.65,120.02) 92.95,119.72 UC1.P61
N63657090: length 1.1
  TOP w0.254: v2(94.64,120.77) 94.58,120.7 T41.1
  BOTTOM w0.254: UC1.N59 94.31,120.43 v2(94.64,120.77)
N63657099: length 6.1
  BOTTOM w0.076: T42.1 87.58,120.19 90.14,120.19 90.27,120.33 91.3,120.33 91.53,120.1 91.77,120.1 91.94,120.27 91.94,120.45 92.18,120.68 92.7,120.68 UC1.N61
N63657120: length 1.1
  TOP w0.089: v2(93.95,118.52) 94.26,118.83 T43.1
  BOTTOM w0.089: v2(93.95,118.52) 94.25,118.82 UC1.T59
N63657126: length 1.9
  TOP w0.254: T44.1 93.41,114.61 v2(93.99,114.03)
  BOTTOM w0.254: UC1.AD60 93.6,114.41 v2(93.99,114.03)
N63657135: length 1.1
  TOP w0.254: v2(94.67,114.14) 94.33,114.48 T45.1
  BOTTOM w0.254: v2(94.67,114.14) 94.37,114.43 UC1.AD59
N63657146: length 1.2
  TOP w0.254: T46.1 94.58,115.62 v2(94.58,115.5)
  BOTTOM w0.254: v2(94.58,115.5) 94.58,115.6 UC1.AA59
N63657155: length 8.2
  BOTTOM w0.076: 90.71,113.27 91.3,113.27 91.39,113.19 91.75,113.19 91.85,113.23 91.91,113.26 93.25,113.26 UC1.AE60
  BOTTOM w0.089: 90.71,113.27 89.56,112.13 86.64,112.13 T47.1
N63657164: length 1.8
  TOP w0.254: T48.1 93.35,116.12 93.95,115.52 v2(93.95,115.52)
  BOTTOM w0.254: UC1.AC59 93.95,115.41 v2(93.95,115.52)
N63657173: length 1.7
  TOP w0.089: v2(94.64,113.12) 94.49,113.26 T49.1
  BOTTOM w0.254: UC1.AG58 94.59,113.07 v2(94.64,113.12)
N63657182: length 2.6
  TOP w0.089: v2(95.46,118.84) 95.24,119.06 T50.1
  BOTTOM w0.076: UC1.U59 94.46,118.1 94.87,118.51 95.13,118.51 v2(95.46,118.84)
N63657191: length 1.1
  TOP w0.089: v2(94.58,117.02) 94.58,117.15 T51.1
  BOTTOM w0.089: v2(94.58,117.02) 94.25,117.35 UC1.V59
N64564173: length 1.6
  TOP w0.102: PR1101.2 182.73,171.18 v1(182.27,170.73)
N64564191: length 1.9
  TOP w0.102: PR1104.2 v1(180.24,170.51)
N64734520: length 2.1
  TOP w0.089: T107.1 125.92,113.1 v2(125.96,113.14)
  BOTTOM w0.089: v2(125.96,113.14) 126,113.1 126,112.52 126.17,112.35 126.17,111.88 UC1.AJ7
N64734538: length 1.4
  TOP w0.089: v2(127.42,111.28) 128.13,111.28 T105.1
  BOTTOM w0.089: UC1.AL5 127.42,110.84 v2(127.42,111.28)
N64734540: length 4.7
  BOTTOM w0.076: UC1.AP4 128.56,108.4 128.86,108.69 129.1,108.69 129.14,108.65 129.92,108.65 130.09,108.82 130.52,108.82 130.55,108.85 132.47,108.85 T106.1
N93761952: length 5.8
  BOTTOM w0.102: UV8.J13 205.11,134.67 203.93,134.67 v1(202.35,133.1) 201.9,132.64 201.9,132.17 RV163.2
N93762059: length 8.1
  TOP w0.102: RV162.2 v1(202.38,130.32) 203.23,131.17 203.23,133.97 203.95,134.69 205.13,134.69 UV7.J13
N93819115: length 5
  BOTTOM w0.102: UV10.J13 204.92,114.28 202.94,114.28 v1(202.17,113.51) RV171.2
N93820861: length 5
  TOP w0.102: RV169.2 v1(202.61,113.95) 202.95,114.29 204.94,114.29 UV9.J13

## Copper pours and planes (outline as drawn)
0.675V_DDR_VTT_ON on TOP (solid shape): 83.76,56.26 83.76,55.36 83.43,55.03 83.43,52.68 83.32,52.57 81.09,52.57 80.99,52.67 80.99,53.01 81.13,53.14 82.38,53.14 82.56,53.33 82.56,54.86 82.12,55.3 82.12,56.31 82.29,56.48 83.54,56.48
1.35V_B+ on BOTTOM (solid shape): 158.91,20.61 166.73,20.61 167.73,19.61 167.73,17.07 167.35,16.69 162.65,16.69 162.59,16.75 162.59,17.26 162.27,17.58 156.37,17.58 155.79,18.15 155.79,20.56 156,20.77 158.75,20.77
3/5V_B+ on BOTTOM (solid shape): 220.37,25.28 220.37,16.32 219.48,15.43 217.01,15.43 216.75,15.69 216.75,17.34 215.99,18.1 215.99,18.99 215.74,19.24 215.74,22.48 215.99,22.74 215.99,25.59 216.37,25.97 219.67,25.97
3VALW_PCH on TOP (solid shape): 141.25,29.47 141.25,27.36 141.19,27.29 139.25,27.29 138.74,27.8 138.74,29.66 138.94,29.86 140.87,29.86
3VS on TOP (solid shape): 197.26,18.93 197.26,18.61 197.2,18.54 196.82,18.54 196.69,18.42 196.69,17.15 196.75,17.08 197.13,17.08 197.26,16.96 197.26,16.51 197.13,16.39 194.4,16.39 194.15,16.64 194.15,19.12 194.21,19.18 197.01,19.18
5VS on TOP (solid shape): 197.2,22.67 197.2,22.48 197.13,22.42 196.75,22.42 196.69,22.35 196.69,21.08 196.75,21.02 197.13,21.02 197.26,20.89 197.26,20.58 197.2,20.51 194.21,20.51 194.15,20.58 194.15,21.71 195.24,22.8 197.07,22.8
+0.675VS on TOP (solid shape): 105.93,75.13 105.93,64.41 105.68,64.16 104.83,64.16 104.66,64.33 104.66,69.31 104.69,69.32 104.82,69.56 104.69,69.8 104.66,69.81 104.66,70.71 104.79,70.94 104.66,71.18 104.66,72.33 104.75,72.33 104.87,72.45 104.87,75.23 105.82,75.23
+0.675VS on TOP (solid shape): 184.48,76.33 184.48,66.66 185.26,65.88 185.26,64.31 185.08,64.13 184.24,64.13 184.23,64.12 183.38,64.12 183.21,64.29 183.21,68.8 183.24,68.87 183.31,68.9 183.62,69.2 183.37,69.55 183.31,69.6 183.3,69.68 183.31,69.72 183.32,69.79 183.37,69.84 183.37,71.07 183.42,71.31 183.28,71.5 183.28,72.25 183.21,72.32 183.21,76.68 183.23,76.7 184.12,76.7
+0.675VS on BOTTOM (solid shape): 184.38,74.35 184.38,64.5 184.06,64.18 183.54,64.18 183.46,64.27 183.46,71.73 183.16,72.04 183.16,74.43 183.27,74.54 184.2,74.54
+0.675VS on BOTTOM (solid shape): 105.83,74.39 105.83,64.54 105.51,64.22 104.99,64.22 104.91,64.3 104.91,71.77 104.66,72.02 104.66,72.26 104.61,72.32 104.61,74.47 104.72,74.58 105.65,74.58
+0.675VS on BOTTOM (solid shape): 156.05,32.12 156.05,31.17 155.6,30.72 155.35,30.72 155.35,31.23 155.29,31.29 154.78,31.29 154.71,31.23 154.71,30.79 154.65,30.72 154.27,30.72 154.09,30.91 154.09,32.07 154.39,32.37 155.79,32.37
+0.675VS on IN2 (solid shape): 155.84,34.39 155.84,31.63 155.51,31.31 154.5,31.31 154.19,31.62 154.19,34.28 154.47,34.56 155.68,34.56
+0.675VS on IN2 (solid shape): 156.41,58.78 156.41,56.02 156.09,55.69 155.07,55.69 154.76,56 154.76,58.66 155.04,58.94 156.25,58.94
+0.675VS on IN3 (solid shape): 106.11,68.57 106.11,66.32 106.02,66.23 105.07,66.23 104.9,66.39 104.9,68.46 105.15,68.71 105.97,68.71
+0.675VS on IN3 (solid shape): 157.13,58.55 157.13,57.67 156.97,57.5 154.7,57.5 154.58,57.62 154.58,58.55 154.69,58.66 157.03,58.66
+0.675VS on IN3 (solid shape): 184.56,68.06 184.56,66.16 184.37,65.97 183.1,65.97 182.97,66.09 182.97,68.19 183.16,68.38 184.24,68.38
+0.675VSP on BOTTOM (solid shape): 157.32,31.29 157.32,27.94 157.44,27.82 157.44,27.61 157.38,27.55 156.49,27.55 156.37,27.67 156.37,28.2 155.86,28.7 154.28,28.7 154.15,28.83 154.15,30.35 154.33,30.53 155.66,30.53 155.68,30.54 156.49,31.36 157.26,31.36
+1.2VSP_B+ on TOP (solid shape): 178.27,178.93 179.61,178.93 179.92,178.61 179.92,176.96 179.8,176.84 179.23,176.84 178.91,176.52 178.91,175.12 178.84,175.06 178.39,175.06 178.07,175.38 175.11,175.38 174.97,175.52 174.97,177.34 174.59,177.73 173.89,177.73 173.76,177.85 173.76,179.69 174.08,180.01 177.19,180.01
+1.05VS on TOP (solid shape): 64.16,100.06 64.16,93 63.48,92.32 62.4,92.32 62.16,92.55 62.16,99.98 62.38,100.19 64.04,100.19
+1.05VS on TOP (solid shape): 148.67,129.64 148.67,127.25 147.59,126.18 147.59,125.82 147.47,125.7 146.38,125.7 146.23,125.85 146.23,126.7 147.24,127.7 147.24,129.63 147.38,129.77 148.53,129.77
+1.05VS on TOP (solid shape): 91.53,132.47 91.53,131.88 91.34,131.69 90.92,131.69 90.7,131.91 90.7,132.45 89.44,133.72 88.35,133.72 87.96,133.33 86.93,133.33 86.54,133.72 86.54,134.72 86.9,135.08 88.93,135.08
+1.05VS on TOP (solid shape): 142.59,141.97 142.59,141.59 142.65,141.53 144.68,141.53 144.75,141.59 144.75,142.04 144.81,142.1 146.14,142.1 146.46,141.78 146.46,138.93 145.57,138.04 136.31,138.04 135.62,138.73 132.48,138.73 132.3,138.55 129.98,138.55 129.92,138.61 129.92,139.18 129.99,139.25 132.06,139.25 132.18,139.36 140.29,139.36 140.55,139.63 140.55,141.47 141.19,142.1 142.46,142.1
+1.05VS on TOP (solid shape): outline of 450 points within 119.04,95.78 121.19,115.91
+1.05VS on BOTTOM (solid shape): 88.1,134.86 88.1,133.72 87.98,133.59 86.77,133.59 86.58,133.78 86.58,134.86 86.64,134.93 88.04,134.93
+1.05VS on BOTTOM (solid shape): 149.1,137.04 149.1,128.41 148.68,127.99 147.43,127.99 147.05,128.37 147.05,134.56 142.62,138.99 142.62,140.84 142.92,141.14 145,141.14
+1.05VS on BOTTOM (solid shape): 86.05,114.63 86.29,114.63 86.37,114.54 86.37,114.38 86.56,114.2 87.42,114.2 87.47,114.14 87.47,113.02 87.35,112.9 86.11,112.9 86.04,112.97 86.04,113.24 85.93,113.35 85.41,113.35 85.25,113.52 85.25,114.56 85.37,114.69 85.99,114.69
+1.5VS on BOTTOM (solid shape): 108.86,31.58 108.86,28.96 108.77,28.87 108.34,28.87 108.31,28.89 108.32,29.4 108.29,29.43 106.97,29.43 106.96,29.41 106.96,28.88 106.94,28.86 106.34,28.86 106.22,28.97 106.22,31.63 106.38,31.79 108.66,31.79
+1.05VS on BOTTOM (solid shape): 85.72,125.79 85.72,123.92 85.29,123.49 81.79,123.49 81.26,122.97 81.26,122.39 81.18,122.3 80.85,122.3 80.46,122.69 80.46,122.87 80.21,123.12 78.83,123.12 78.58,123.36 78.58,124.67 78.8,124.88 80.1,124.88 80.64,124.34 83.33,124.34 84.84,125.86 85.65,125.86
+1.05VS on BOTTOM (solid shape): 121.54,144.77 121.54,142.93 121.68,142.79 123.14,142.79 123.23,142.88 123.23,143.7 123.38,143.85 124.27,143.85 124.41,143.72 124.41,140.3 124.33,140.22 123.44,140.22 123.25,140.41 123.25,141.08 122.94,141.39 120.85,141.39 120.62,141.16 120.62,139.39 120.37,139.13 116.51,139.13 116.26,139.39 116.26,140.06 116.54,140.34 118.08,140.34 118.37,140.63 118.37,140.9 120.4,142.93 120.4,144.73 120.58,144.9 121.4,144.9
+1.5VS on IN1 (solid shape): 108.54,31.49 108.54,29.96 108.3,29.72 106.1,29.72 105.87,29.95 105.87,31.56 106.25,31.94 108.09,31.94
+1.05VS on VCC (solid shape): outline of 8237 points within 116.49,110.92 146.08,144.97
+1.5VS on IN2 (solid shape): outline of 83 points within 94.01,150.67 114.49,151.86
+1.05VS on IN2 (solid shape): outline of 3397 points within 62.88,98.8 87.97,137.69
+1.05VS_APLLOPI on BOTTOM (solid shape): 126.78,143.06 126.78,137.99 126.52,137.73 124.71,137.73 124.65,137.8 124.65,140 124.65,140 124.65,142.24 124.96,142.55 124.96,143.79 125.07,143.9 125.93,143.9
+1.05VS_ASATA3PLL on BOTTOM (solid shape): 126.71,136.91 126.71,134.62 126.55,134.46 124.89,134.46 124.72,134.63 124.72,137.2 125,137.48 126.14,137.48
+1.05VS_ASATA3PLL on BOTTOM (solid shape): 124.55,144.58 124.55,144.12 124.47,144.03 123.28,144.03 123.09,143.84 123.09,143.18 122.98,143.07 122.17,143.07 122.08,143.16 122.08,144.83 122.2,144.95 124.18,144.95
+1.05VS_ASATA3PLL on IN3 (solid shape): 125.37,144.24 125.37,143.22 125.3,143.15 123.62,143.15 123.44,143.33 123.44,144.24 123.54,144.34 125.26,144.34
+1.05VS_ASATA3PLL on IN3 (solid shape): outline of 96 points within 124.64,130.11 126.66,137.94
+1.05VS_AUSB3PLL on BOTTOM (solid shape): 120.5,138.54 120.5,137.54 120.96,137.09 120.96,134.54 120.81,134.39 119.57,134.39 119.04,134.93 119.04,137.35 118.59,137.8 118.59,138.56 118.71,138.69 120.36,138.69
+1.05VS_AXCK_DCB on TOP (solid shape): outline of 471 points within 118.69,121.7 123.19,138.56
+1.05VSP on TOP (solid shape): 148.17,145.21 148.17,142.61 147.86,142.29 140.55,142.29 140.3,142.55 140.3,145.21 140.49,145.4 147.98,145.4
+1.5VSP on BOTTOM (solid shape): 110.77,28.96 110.77,27.79 111.29,27.27 111.29,26.47 111.2,26.38 109.76,26.38 109.64,26.26 109.64,24.23 109.08,23.68 104.99,23.68 104.89,23.77 104.89,28.3 105.3,28.7 108.84,28.7 109.16,29.02 110.71,29.02
+1.05VSP on BOTTOM (solid shape): 145.89,147.74 145.89,146.67 146.08,146.48 147.49,146.48 147.73,146.25 147.73,143.02 147.44,142.74 140.62,142.74 140.36,142.99 140.36,146.17 140.68,146.48 142.08,146.48 142.27,146.67 142.27,147.81 142.33,147.87 145.76,147.87
+1.8VGS on BOTTOM (solid shape): 186.69,89.41 186.69,87.97 186.59,87.87 185.81,87.87 185.75,87.94 185.75,89.37 185.91,89.53 186.58,89.53
+1.8VS on TOP (solid shape): 214.53,98.29 214.53,97.91 214.66,97.78 215.99,97.78 216.06,97.84 216.06,98.41 216.31,98.41 216.44,98.29 216.44,96.57 216.06,96.2 215.63,95.76 214.77,95.76 213.96,96.57 213.96,98.35 214.02,98.41 214.4,98.41
+1.8VS on BOTTOM (solid shape): 185.01,89.41 185.01,88.12 184.79,87.9 184.34,87.9 184.12,88.13 184.12,89.37 184.31,89.56 184.86,89.56
+1.8VS on IN1 (solid shape): 185.86,89.14 185.86,88.79 185.32,88.25 184.18,88.25 184.12,88.32 184.12,89.21 184.24,89.33 185.67,89.33
+1.8VS on IN1 (solid shape): 215.55,97.33 215.55,96.01 214.98,95.44 214.34,95.44 213.96,95.82 213.96,96.54 214.91,97.49 215.39,97.49
+1.8VSP on TOP (solid shape): 218.91,101.02 218.91,97.61 218.72,97.42 217.34,97.42 216.69,98.07 216.69,98.35 216.44,98.6 214.34,98.6 214.15,98.79 214.15,99.49 215.88,101.22 218.71,101.22
+1.8VSP on BOTTOM (solid shape): 220.37,100.35 221.45,100.35 221.45,99.05 221.36,98.96 220.34,98.96 220.24,98.85 220.19,98.81 220.14,98.76 219.17,97.78 217.26,97.78 216.9,98.14 216.9,99.66 218.09,100.85 219.87,100.85
+1.35V on TOP (solid shape): outline of 20963 points within 64.44,30.21 169.17,113.53
+1.35V on BOTTOM (solid shape): 151.03,31.99 151.03,30.52 150.48,29.97 147.16,29.97 147.16,29.98 146.14,29.98 145.89,30.23 145.89,30.42 145.7,30.61 143.86,30.61 143.73,30.48 143.73,30.17 143.6,30.04 143.22,30.04 143.03,30.23 143.03,30.99 144.36,32.32 150.7,32.32
+1.35V on BOTTOM (solid shape): 102.3,102 102.37,101.98 102.4,101.91 102.55,101.69 102.81,101.72 102.88,101.75 102.94,101.72 103.2,101.69 103.35,101.91 103.38,101.98 103.45,102 105.61,102 106.33,101.28 108.8,101.28 110.3,99.78 110.3,98.88 110,98.58 98.82,98.58 98.12,99.27 98.12,101.19 98.31,101.39 100.22,101.39 100.84,102
+1.35V_MEM_GFX on TOP (solid shape): 198.29,158.73 198.29,158.24 198.23,158.18 192.3,158.18 191.84,157.72 191.54,157.72 190.21,156.39 181.64,156.39 181.13,156.9 181.13,158.42 181.32,158.61 193.45,158.61 193.77,158.93 198.09,158.93
+1.35V_MEM_GFX on TOP (solid shape): 186.46,130.42 186.46,128.77 186.72,128.51 186.72,128 186.97,127.75 186.97,127.12 186.85,126.99 185.26,126.99 184.62,127.62 184.62,128.51 184.75,128.64 185.45,128.64 185.77,128.96 185.77,130.42 185.83,130.48 186.4,130.48
+1.35V_MEM_GFX on TOP (solid shape): 219.45,135.81 219.45,130.11 219.97,129.59 219.97,128.27 219.85,128.15 219.34,128.15 219.27,128.22 219.27,129.58 219,129.84 218.64,129.84 218.55,129.94 218.55,133.08 217.71,133.91 216.15,133.91 215.97,134.1 215.97,136.78 216.15,136.97 218.29,136.97
+1.35V_MEM_GFX on TOP (solid shape): 218.84,120.47 218.84,113 219.09,112.75 219.09,104.44 218.47,103.81 216.5,103.81 216.31,104 216.31,104.31 218.36,106.36 218.36,111.07 218.01,111.42 215.99,113.44 215.99,113.67 215.89,113.77 215.89,114.21 215.88,114.22 215.88,116.6 216.4,116.6 216.4,116.55 216.41,116.5 216.42,116.44 216.45,116.4 216.48,116.35 216.51,116.31 216.55,116.28 216.6,116.25 216.65,116.23 216.7,116.22 216.75,116.22 216.81,116.22 216.86,116.23 216.91,116.25 216.96,116.28 217,116.31 217.03,116.35 217.06,116.4 217.09,116.44 217.1,116.5 217.11,116.55 217.11,116.6 217.1,116.65 217.09,116.7 217.06,116.75 217.03,116.8 217,116.84 216.96,116.87 216.91,116.9 216.86,116.92 216.81,116.93 216.75,116.93 216.7,116.93 216.65,116.92 216.6,116.9 216.55,116.87 216.51,116.84 216.48,116.8 216.45,116.75 216.42,116.7 216.41,116.65 216.4,116.6 215.88,116.6 215.88,120.36 216.2,120.68 218.63,120.68
+1.35V_MEM_GFX on TOP (solid shape): 161.45,160.64 161.45,158.99 161.89,158.55 171.35,158.55 171.67,158.87 174.91,158.87 175.86,159.82 177.19,159.82 177.38,159.63 177.38,158.99 177.26,158.87 175.86,158.87 175.77,158.78 175.13,158.13 171.93,158.13 171.71,157.91 170.84,157.91 169.26,156.33 160.49,156.33 159.86,156.96 158.84,156.96 157.71,155.83 157.71,153.72 157.78,153.66 158.21,153.66 158.47,153.4 158.47,150.34 158.36,150.24 157.7,150.24 156.69,151.25 156.69,156.41 156.75,156.5 156.87,156.47 157.36,156.45 157.4,156.94 157.39,157.05 157.48,157.11 157.85,157.11 159.54,158.8 159.54,160.77 159.64,160.87 161.22,160.87
+1.35V_MEM_GFX on BOTTOM (solid shape): 214.08,153.87 214.08,152.63 213.58,152.13 211.97,152.13 211.77,152.33 211.77,153.69 212.18,154.11 213.84,154.11
+1.35V_MEM_GFX on BOTTOM (solid shape): 218.69,115.8 218.69,106.39 218.27,105.98 216.33,105.98 216.09,106.22 216.09,113.57 215.9,113.76 215.9,115.91 215.96,115.97 216.45,115.97 216.46,115.98 218.5,115.98
+1.35V_MEM_GFX on BOTTOM (solid shape): 218.84,141.33 218.84,128.3 218.63,128.09 217.09,128.09 216.55,128.64 216.55,133.7 216.01,134.23 216.01,136.12 217.82,137.93 218.15,138.26 218.15,141.26 218.28,141.39 218.78,141.39
+1.35V_MEM_GFX on BOTTOM (solid shape): 184.94,158.55 195.93,158.55 196.12,158.36 196.12,156.64 195.8,156.33 187.86,156.33 186.66,157.53 186.37,157.53 186.12,157.79 184.43,157.79 183.7,158.52 183.7,158.54 183.68,158.54 183.54,158.68 182.21,158.68 182.02,158.87 182.02,159.37 182.27,159.63 183.86,159.63
+1.35V_MEM_GFX on BOTTOM (solid shape): 177.38,159.63 177.38,159.06 177.19,158.87 175.8,158.87 175.67,158.74 175.67,158.42 173.57,156.33 167.22,156.33 165.69,157.85 161.51,157.85 161.45,157.91 161.45,158.61 161.51,158.68 162.33,158.68 162.37,158.64 171.67,158.64 171.7,158.68 172.24,158.68 172.49,158.93 174.21,158.93 174.97,159.69 177.32,159.69
+1.35V_MEM_GFX on IN1 (solid shape): outline of 23516 points within 162.02,100.19 218.13,157.79
+1.35VGPUP on BOTTOM (solid shape): 184.88,169.34 184.88,168.39 185.7,167.57 189.96,167.57 190.21,167.31 190.21,164.26 190.08,164.14 176.24,164.14 175.1,165.28 175.1,168.58 175.73,169.22 180.56,169.22 181.45,170.11 184.12,170.11
+1.35VP on TOP (solid shape): 151.67,29.77 151.67,28.28 151.43,28.03 147.6,28.03 147.29,28.35 147.29,29.77 147.54,30.02 151.41,30.02
+1.35VP on BOTTOM (solid shape): 156.18,28.12 156.18,27.61 156.43,27.36 157.32,27.36 157.38,27.29 157.38,27.17 157.33,27.12 155.97,27.12 155.74,27.35 155.74,28.06 155.86,28.18 156.11,28.18
+1.35VP on BOTTOM (solid shape): 153.01,29.59 153.01,28.07 152.56,27.62 150.28,27.62 149.45,26.8 149.45,15.56 148.94,15.05 143.67,15.05 143.55,15.18 143.55,28.44 142.9,29.09 142.9,29.59 143.09,29.78 152.82,29.78
+1.35VP on IN2 (solid shape): 148.81,27.67 148.81,26.98 148.68,26.85 146.84,26.85 146.65,27.04 146.65,27.42 146.97,27.74 148.75,27.74
+1.35VP on IN2 (solid shape): 156.24,28.06 156.24,27.29 155.92,26.98 154.52,26.98 154.27,27.23 154.27,27.67 154.4,27.8 155.54,27.8 155.92,28.18 156.11,28.18
+1.35VS_VGA on BOTTOM (solid shape): 217.59,152.33 217.59,147.07 217.44,146.92 214.38,146.92 214.08,147.22 214.08,151.5 214.82,152.25 214.82,153.87 214.92,153.97 215.95,153.97
+1.35VS_VGA on BOTTOM (solid shape): 181.77,163.82 181.77,163.44 181.83,163.37 183.73,163.37 183.86,163.5 183.86,163.82 183.99,163.95 186.91,163.95 187.04,163.82 187.04,163.44 187.1,163.37 189.07,163.37 189.13,163.44 189.13,163.82 189.26,163.95 190.08,163.95 190.47,163.56 190.47,161.98 190.21,161.72 180.69,161.72 180.24,162.17 180.24,163.82 180.37,163.95 181.64,163.95
+1.35VS_VGA on VCC (solid shape): outline of 33176 points within 162.02,103.18 217.26,164.01
+1.35VS_VGA on IN2 (solid shape): 198.71,161.05 208.62,161.05 216.95,152.73 216.95,151.98 216.22,151.25 215.2,151.25 207.91,158.55 197.58,158.55 193.48,162.65 189.64,162.65 188.97,161.98 180.88,161.98 180.56,162.29 180.56,164.07 181.21,164.72 195.04,164.72
+3V_WLAN on TOP (solid shape): 106.02,149.87 106.02,148.55 105.98,148.51 104.27,148.51 104.15,148.63 104.15,149.98 104.25,150.09 105.8,150.09
+3V_WLAN on TOP (solid shape): 93.75,151.15 93.75,149.76 93.44,149.46 93.44,148.66 93.59,148.52 93.59,147.9 93.52,147.84 91.89,147.84 91.52,148.21 91.52,150.95 91.84,151.27 93.63,151.27
+3V_WLAN on TOP (solid shape): 111.81,152.68 111.81,151.38 112.12,151.07 112.12,149.97 112.02,149.87 111.31,149.87 111.22,149.96 111.22,150.17 111.09,150.3 110.45,150.3 110.35,150.39 110.35,152.7 110.4,152.75 111.74,152.75
+3V_WLAN on TOP (solid shape): 118.22,151.9 118.41,151.71 118.41,149.52 118.23,149.34 117.16,149.34 117.15,149.34 116.97,149.38 116.79,149.34 116.78,149.34 116.57,149.34 116.49,149.37 116.38,149.48 116.38,150.09 116.2,150.28 115.61,150.28 115.48,150.41 115.48,151.04 115.48,151.44 115.68,151.64 115.94,151.9 117.86,151.9
+3V_WLAN on BOTTOM (solid shape): 93.01,151.15 93.01,149.39 92.76,149.14 91.8,149.14 91.48,149.46 91.48,150.86 91.83,151.2 92.96,151.2
+3V_WLAN on BOTTOM (solid shape): 118.28,151.68 118.28,150.19 117.49,149.4 116.32,149.4 116.08,149.16 115.72,149.16 115.58,149.3 115.58,151.52 115.85,151.78 118.18,151.78
+3V_WLAN on BOTTOM (solid shape): 105.01,151.15 105.01,149.25 105.2,149.06 105.38,149.06 105.38,149.06 105.51,149.04 105.63,149.06 105.64,149.06 105.8,149.06 105.94,148.92 105.94,148.54 105.89,148.48 104.46,148.48 104.22,148.72 104.22,149.05 104.36,149.19 104.36,151.09 104.47,151.2 104.96,151.2
+3V_WLAN on IN1 (solid shape): 111.83,152.69 111.83,151.96 111.83,151.96 111.83,151.47 112.25,151.05 114.22,151.05 114.93,151.76 118.38,151.76 118.76,151.38 118.76,149.68 118.47,149.39 116.19,149.39 116.06,149.27 113.21,149.27 113.12,149.28 113.03,149.27 112.44,149.27 112.31,149.29 112.19,149.27 107.25,149.27 106.75,148.76 106.59,148.6 104.3,148.6 104.09,148.81 104.03,148.97 103.9,149.08 103.58,149.39 91.49,149.39 91.17,149.71 91.17,151.59 91.35,151.77 94.47,151.77 94.55,151.73 94.57,151.64 94.91,151.2 95.26,151.64 95.28,151.73 95.36,151.77 104.76,151.77 105.25,151.27 105.28,151.27 105.57,151.2 105.81,151.38 105.9,151.43 105.99,151.38 106.43,151.22 106.65,151.64 106.66,151.73 106.74,151.77 110.15,151.77 110.35,151.96 110.35,152.71 110.39,152.75 111.76,152.75
+3VALW on TOP (solid shape): 46.45,36.01 46.45,33.4 46.19,33.15 45.24,33.15 44.86,33.53 44.86,35.82 45.24,36.2 46.26,36.2
+3VALW on TOP (solid shape): 207.48,53.65 207.48,52.31 207.29,52.12 203.74,52.12 203.36,52.5 203.36,53.52 203.74,53.9 207.23,53.9
+3VALW on TOP (solid shape): 199.61,57.52 199.61,56.19 199.23,55.81 198.21,55.81 197.7,56.31 197.01,56.31 196.82,56.5 196.82,57.58 196.43,57.96 195.29,57.96 194.34,58.92 194.34,59.74 194.66,60.06 197.07,60.06
+3VALW on TOP (solid shape): 46.96,91.26 46.96,82.74 46.51,82.3 45.69,82.3 45.49,82.49 45.49,91.02 40.66,95.86 27.94,95.86 27.58,95.5 26.56,95.5 26.46,95.6 26.46,97.09 26.59,97.22 41,97.22
+3VALW on TOP (solid shape): 192.88,57.81 192.88,57.27 193.26,56.88 193.26,56.44 193.13,56.31 192.75,56.31 192.56,56.5 192.56,57.01 192.43,57.14 191.69,57.14 191.31,57.27 191.05,56.97 191.05,56.95 190.94,56.84 188.98,56.84 188.85,56.97 188.85,58.07 188.94,58.15 192.53,58.15
+3VALW on TOP (solid shape): 191.29,19.56 191.37,19.52 191.39,19.44 191.6,19.04 192.04,19.18 192.81,19.18 192.94,19.05 192.94,18.48 193.45,17.97 193.45,14.99 194.4,14.04 199.74,14.04 200.05,13.72 200.05,7.37 199.61,6.92 192.12,6.92 190.53,8.51 190.53,17.85 190.66,17.97 190.66,19.43 190.78,19.56
+3VALW on TOP (solid shape): 200.85,41.12 200.85,40.23 199.95,39.32 199.94,39.31 199.92,39.3 199.92,38.51 200.1,38.33 200.1,37.19 199.95,37.05 198.76,37.05 198.23,37.58 198.23,39.25 198.53,39.55 199.36,39.55 199.56,39.76 199.59,39.74 199.97,39.88 199.83,40.25 199.77,40.32 199.8,40.41 200.04,40.65 200.04,41.22 200.12,41.3 200.67,41.3
+3VALW on TOP (solid shape): outline of 94 points within 138.46,13.59 143.41,26.02
+3VALW on BOTTOM (solid shape): 48.61,33.85 48.61,32.9 48.23,32.51 45.94,32.51 45.18,33.28 45.18,33.53 45.94,34.29 48.16,34.29
+3VALW on BOTTOM (solid shape): 196.69,58.89 196.69,58.28 196.31,57.9 194.56,57.9 193.54,58.92 193.54,59.79 193.62,59.86 195.72,59.86
+3VALW on BOTTOM (solid shape): 213.39,94.81 213.39,91.95 213.26,91.82 211.32,91.82 211.19,91.95 211.19,94.64 211.48,94.94 213.26,94.94
+3VALW on BOTTOM (solid shape): 106.85,13.37 109,13.37 109.06,13.31 109.06,12.34 108.85,12.13 102.93,12.13 102.68,12.37 102.68,13.38 103.37,14.07 106.15,14.07
+3VALW on BOTTOM (solid shape): 144.83,160.44 144.83,159.11 145.07,158.87 145.07,157.24 144.79,157.24 144.79,158.37 144.18,158.98 144.18,160.46 144.29,160.57 144.7,160.57
+3VALW on BOTTOM (solid shape): 47.81,89.43 47.81,88.03 47.4,87.62 47.4,84 47.15,83.75 43.54,83.75 43.47,83.81 43.47,84.44 43.57,84.54 45.01,84.54 45.75,85.28 45.75,87.95 45.95,88.15 45.95,89.47 46.07,89.59 47.65,89.59
+3VALW on BOTTOM (solid shape): 200.82,15.12 200.82,14.67 200.63,14.48 200.37,14.48 200.31,14.42 200.31,12.45 200.37,12.39 200.69,12.39 200.82,12.26 200.82,9.46 200.63,9.27 200.37,9.27 200.31,9.21 200.31,7.24 200.43,7.11 200.69,7.11 200.82,6.99 200.82,6.35 200.12,5.65 197.01,5.65 196.56,6.1 196.56,14.73 197.01,15.18 200.75,15.18
+3VALW on IN2 (solid shape): 200.05,11.12 200.05,8.89 199.23,8.07 194.59,8.07 193.89,8.77 193.89,10.92 194.4,11.43 199.74,11.43
+3VALW on IN2 (solid shape): 212.5,92.57 212.5,91 212.25,90.75 211.51,90.75 211.29,90.97 211.29,92.56 211.47,92.74 212.33,92.74
+3VALW on IN2 (solid shape): 208.82,53.52 208.82,52.5 208.5,52.19 208.05,52.19 207.74,51.87 207.74,49.77 207.61,49.65 205.96,49.65 205.71,49.9 205.71,53.39 206.09,53.77 208.56,53.77
+3VALW on VCC: 166.8,18.04 175.06,9.78 192.98,9.78 197.05,13.85 199.12,13.85 200.82,12.15 200.82,1.02 198.83,1.02 198.75,1.05 198.73,1.14 198.74,1.2 198.74,1.26 198.74,2.73 198.07,3.41 197.4,2.73 197.4,1.26 197.4,1.2 197.41,1.14 197.39,1.05 197.31,1.02 169.53,1.02 169.45,1.05 169.43,1.14 169.44,1.2 169.44,1.26 169.44,2.73 168.77,3.41 168.1,2.73 168.1,1.26 168.1,1.2 168.11,1.14 168.09,1.05 168.01,1.02 166.42,1.02 166.42,9.48 165.83,10.91 164.4,11.5 105.12,11.5 105.12,14.82 106.43,16.13 149.74,16.13 149.79,16.18 155.65,16.18 157.5,18.04
+3VALW_PCH on TOP (solid shape): 122.96,53.3 122.96,52.24 122.7,51.99 121.88,51.99 121.7,52.17 121.7,53.42 121.81,53.53 122.73,53.53
+3VALW_PCH on TOP (solid shape): 132.83,112.97 132.83,111.97 132.74,111.88 130.69,111.88 130.53,112.04 130.53,112.44 130.62,112.52 131.61,112.52 131.71,112.62 131.71,112.99 131.81,113.1 132.71,113.1
+3VALW_PCH on TOP (solid shape): 157.27,96.36 157.27,95.89 156.91,95.52 156.04,95.52 153.73,97.83 136.72,97.83 136.45,98.1 136.45,98.7 136.7,98.95 154.68,98.95
+3VALW_PCH on TOP (solid shape): 142.76,32.38 142.76,28.88 142.7,28.82 141.69,28.82 141.5,29.02 141.5,30.11 141,30.61 138.2,30.61 138.01,30.8 138.01,32.44 138.46,32.88 142.25,32.88
+3VALW_PCH on TOP (solid shape): outline of 107 points within 147.54,110.35 151.46,116.22
+3VALW_PCH on BOTTOM (solid shape): 122.97,54.16 122.97,53.11 122.72,52.85 121.89,52.85 121.71,53.04 121.71,54.28 121.82,54.39 122.74,54.39
+3VALW_PCH on BOTTOM (solid shape): 157.09,96.18 157.09,95.22 156.98,95.11 154.59,95.11 154.37,95.33 154.37,96.25 154.4,96.28 156.98,96.28
+3VALW_PCH on BOTTOM (solid shape): 143.81,116.71 143.81,115.8 143.63,115.62 141.58,115.62 141.45,115.76 141.45,116.26 141.73,116.55 142.95,116.55 143.2,116.8 143.72,116.8
+3VALW_PCH on BOTTOM (solid shape): 147.48,114.96 147.48,113.02 147.35,112.89 146.73,112.89 146.62,112.99 146.62,113.41 146.43,113.61 145.71,113.61 145.65,113.66 145.65,114.26 145.7,114.31 145.7,115.01 145.8,115.11 147.33,115.11
+3VALW_PCH on BOTTOM (solid shape): 148.81,111.3 148.81,108.75 149.04,108.52 149.04,106.61 148.85,106.41 147.55,106.41 147.55,106.42 147.37,106.42 147.27,106.52 147.27,107.25 147.67,107.65 147.67,108.76 147.67,108.83 147.67,108.91 147.67,111.07 147.96,111.37 148.75,111.37
+3VALW_PCH on BOTTOM (solid shape): 141.14,114.76 141.14,113.21 141.09,113.16 140.82,112.75 141.21,112.46 141.28,112.43 141.32,112.36 141.32,110.92 141.19,110.8 139.69,110.8 139.22,110.33 138.92,110.33 138.6,110.64 138.6,110.82 139.16,111.37 139.16,111.72 139.39,111.95 140.07,111.95 140.2,112.09 140.2,113 139.28,113.92 139.28,115.64 139.32,115.68 140.22,115.68
+3VALW_PCH on IN1 (solid shape): outline of 155 points within 131.72,112.64 143.6,116.99
+3VALW_PCH on IN1 (solid shape): outline of 239 points within 135.35,92.75 158.53,109.89
+3VALW_PCH on IN2 (solid shape): outline of 87 points within 141.45,101.67 152.3,117.62
+3VALW_PCH on IN2 (solid shape): outline of 482 points within 120.68,110.86 132.74,113.16
+3VALW_PCH on IN3 (solid shape): 151.29,116.13 151.29,114.52 150.24,113.48 146.54,113.48 146.29,113.73 146.29,114.75 146.58,115.04 149.05,115.04 150.46,116.46 150.95,116.46
+3VALWP on BOTTOM (solid shape): 204.24,14.1 204.24,12.39 205.07,11.56 209.64,11.56 210.09,12 213.13,12 213.26,11.88 213.26,6.42 212.31,5.46 201.9,5.46 201.07,6.29 201.07,15.05 201.2,15.18 203.17,15.18
+3VGS on TOP (solid shape): 175.62,117.09 175.62,116.53 175.73,116.41 176.64,116.41 176.76,116.53 177.18,116.53 177.52,116.2 177.52,116.18 177.56,116.03 177.65,115.91 177.65,115.33 177.64,115.23 177.67,115.12 177.67,114.85 177.48,114.67 175.99,114.67 175.87,114.54 175.73,114.43 175.66,114.27 175.64,114.24 175.61,114.23 175.2,114.23 175.13,114.31 175.13,114.85 175.31,115.04 175.64,115.04 175.89,115.3 175.89,115.81 175.81,115.9 174.88,115.9 174.74,116.03 174.74,116.96 174.95,117.17 175.54,117.17
+3VGS on TOP (solid shape): outline of 988 points within 175.22,96.56 187.67,108.3
+3VGS on BOTTOM (solid shape): 176.56,117.01 176.59,117 176.61,116.97 176.71,116.83 176.86,116.74 176.88,116.74 177.24,116.38 177.24,116.04 177.24,116.02 177.22,116 177.11,115.84 177.08,115.65 177.08,115.63 177.07,115.61 176.91,115.44 175.1,115.44 174.95,115.6 174.95,116.81 175.14,117.01
+3VGS on BOTTOM (solid shape): outline of 112 points within 179.51,93.02 188.27,98.95
+3VLP on BOTTOM (solid shape): 115.54,14.67 115.54,13.72 115.09,13.27 114.01,13.27 113.95,13.34 113.95,13.72 114.01,13.78 114.46,13.78 114.52,13.85 114.52,14.29 114.46,14.35 114.01,14.35 113.95,14.42 113.95,14.8 114.14,14.99 115.22,14.99
+3VS on TOP (solid shape): 56.1,42.03 56.1,39.49 55.97,39.36 54.64,39.36 54.51,39.49 54.51,42.09 54.7,42.28 55.85,42.28
+3VS on TOP (solid shape): 185.39,93.4 185.39,91.11 185.19,90.92 184.12,90.92 183.86,91.17 183.86,93.46 183.99,93.59 185.19,93.59
+3VS on TOP (solid shape): 199.93,19.43 199.93,16.58 199.55,16.2 197.83,16.2 197.45,16.58 197.45,19.37 197.7,19.62 199.74,19.62
+3VS on TOP (solid shape): 179.61,21.45 179.61,20.85 179.51,20.75 179.51,20.42 179.43,20.33 177.76,20.33 177.58,20.51 177.58,21.19 178.06,21.67 179.39,21.67
+3VS on TOP (solid shape): 51.71,19.56 51.71,17.24 51.62,17.15 48.61,17.15 48.29,17.47 48.29,19.1 48.64,19.45 48.64,20.02 48.77,20.15 51.12,20.15
+3VS on TOP (solid shape): 177.89,57.63 178.37,57.63 178.41,57.59 178.41,55.85 178.26,55.7 178.05,55.7 178.04,55.71 177.18,55.71 176.44,56.45 176.44,57.86 176.61,58.04 177.48,58.04
+3VS on TOP (solid shape): 103.82,73 103.82,72.4 103.9,72.33 104.18,72.33 104.36,72.14 104.36,71.41 104.18,71.23 102.44,71.23 102.15,71.52 102.15,72.22 102.03,72.35 101.02,72.35 100.97,72.39 100.97,73.04 101.02,73.09 103.73,73.09
+3VS on TOP (solid shape): 226.03,177.47 226.03,175.39 225.9,175.26 225.39,175.26 224.95,174.82 224.95,173.8 224.69,173.55 222.57,173.55 221.49,172.47 220.69,172.47 220.63,172.53 220.63,173.29 222.77,175.44 224.19,175.44 224.5,175.75 224.5,176.26 224.71,176.48 224.71,176.86 224.72,176.87 224.72,177.44 224.95,177.66 225.83,177.66
+3VS on TOP (solid shape): 101.72,151.51 103.45,151.51 103.59,151.37 103.59,150.43 103.49,150.34 100.9,150.34 100.31,149.75 95.6,149.75 95.43,149.58 95.43,146.94 94.84,146.36 93.78,146.36 93.71,146.44 93.71,147.01 93.83,147.13 94.46,147.13 94.63,147.3 94.63,148.69 94.51,148.81 94.51,151.13 94.6,151.22 94.8,151.22 94.8,151.21 94.91,151.2 95.02,151.21 95.03,151.22 97.69,151.22 98.96,152.49 100.74,152.49
+3VS on TOP (solid shape): outline of 392 points within 180.01,66.45 182.85,74.73
