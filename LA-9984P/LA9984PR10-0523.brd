# Allegro board LA9984PR10-0523.brd (continued)
## Nets (continued)
MS_D1_SD_D3: JREAD.3 JREAD.13 UR1.20
MS_D2_SD_CLK: CR6.1 JREAD.10 JREAD.14 RR2.2
MS_D2_SD_CLK_R: RR2.1 UR1.15
MS_D3: JREAD.7 UR1.12
MS_INS#: CR10.1 JREAD.8 UR1.9
O-USR: PR502.1 PR506.2 PU501.9
OCP_CPU: PR501.1 PR503.2 PU501.12
ODD_DA#: CS17.1 JBTB.7 JBTB1.5 RP54.1 UC1.T3
ODD_DETECT#: JBTB.10 JBTB1.4 RP37.1 UC1.V6
ODD_EN: CS16.1 QS2.3 QS3.1 RS6.1
ODD_EN#: QS3.2 UC1.Y1
ON/OFFBTN#: CE20.1 JPWR.3 RE49.1 SW1.3 SW1.4 SW2.3 SW2.4 UE1.114
PACIN#: QV14.5 QV14.6 RV74.2
PANEL_BKLEN: UC1.A9 UE1.76
PBTN_OUT#: RC49.1 UC1.AL7 UE1.106
PC_BEEP: DA8.1 RA19.1 RA79.2
PCH_AUDIO_EN: RC116.1 UC1.P1
PCH_AZ_BITCLK: R2359.2 UC1.AW8
PCH_AZ_CODEC_BITCLK: CC5.1 R2355.1 R2359.1 UA1.6
PCH_AZ_CODEC_RST#: R2358.1 RA6.1 UA1.11
PCH_AZ_CODEC_SDIN0: RA130.1 UC1.AY10
PCH_AZ_CODEC_SDOUT: R2356.1 UA1.5
PCH_AZ_CODEC_SYNC: R2357.1 UA1.10
PCH_AZ_RST#: R2358.2 UC1.AU8
PCH_AZ_SDOUT: R2356.2 RC3.2 RC8.2 UC1.AU11
PCH_AZ_SYNC: R2357.2 UC1.AV11
PCH_BATLOW#: RC31.2 UC1.AN4
PCH_DPWROK: RC33.1 RE37.1 UC1.AV5
PCH_GPIO9: RC125.2 UC1.AM3
PCH_GPIO12: T182.1(TP-1) UC1.AM7
PCH_GPIO14: T126.1(TP-1) UC1.AH4
PCH_GPIO25: T127.1(TP-1) UC1.AM4
PCH_GPIO35: RP37.2 UC1.U1
PCH_GPIO37: RP37.3 UC1.AC1
PCH_GPIO44: RC104.1 UC1.AK4
PCH_GPIO46: RC124.2 UC1.AG3
PCH_GPIO47: T174.1(TP-1) UC1.AB6
PCH_GPIO48: T124.1(TP-1) UC1.U4
PCH_GPIO49: T125.1(TP-1) UC1.Y3
PCH_GPIO66: RC118.2 RC122.1 UC1.D3
PCH_GPIO83: T177.1(TP-1) UC1.R6
PCH_GPIO84: T176.1(TP-1) UC1.L6
PCH_GPIO85: T175.1(TP-1) UC1.N6
PCH_GPIO89: T178.1(TP-1) UC1.N7
PCH_GPIO90: T179.1(TP-1) UC1.K2
PCH_GPIO93: T180.1(TP-1) UC1.J2
PCH_GPIO94: T181.1(TP-1) UC1.G1
PCH_HOT#: R2330.2 RE7.1 UC1.AU4
PCH_INTVRMEN: RC1.2 RC2.1 UC1.AV7
PCH_JTAG_JTAGX: RC59.1 RC62.2 RC130.1 UC1.AE63
PCH_JTAG_RST#: R2341.2 RC57.2 UC1.AU62
PCH_JTAG_TCK: RC65.2 RC135.1 RP46.4 UC1.AE62
PCH_JTAG_TDI: RC44.1 RP48.8 UC1.AD61
PCH_JTAG_TDO: RC43.1 RC63.2 RP48.7 UC1.AE61
PCH_JTAG_TMS: RC46.1 RP48.6 UC1.AD62
PCH_OPI_COMP: RC101.1 UC1.AW15
PCH_PCIE_RCOMP: RC91.2 UC1.A27
PCH_PLTRST#: CC33.1 UC1.AG7 UC3.1 UC3.2
PCH_PWR_EN: R416.1 RE36.1
PCH_PWROK: CC34.1 CE31.1 RE18.1 RP50.2 RP50.3 UE1.32
PCH_PWROK_R: RP50.7 UC1.AY7
PCH_RSMRST#_R: RC33.2 RC41.2 UC1.AW6
PCH_RTCRST#: CC4.2 CMOS1.2 RC6.2 UC1.AU7
PCH_RTCX1: CC1.2 RC4.1 RG3.2 UC1.AW5 YC1.1
PCH_RTCX1_R: RG3.1 UG1.9
PCH_RTCX2: CC2.2 RC4.2 UC1.AY5 YC1.2
PCH_SMB_ALERT#: R2329.2 UC1.AN2
PCH_SPI_CLK: R2333.2 UC1.AA3
PCH_SPI_CLK_R: C2326.1 R2333.1 U2302.6
PCH_SPI_CS0#: U2302.1 UC1.Y7
PCH_SPI_HOLD1#: RP39.4 U2302.7
PCH_SPI_HOLD#: R2335.2 RP39.5 UC1.AF1
PCH_SPI_MISO: RP39.7 UC1.AA4
PCH_SPI_MISO_1: RP39.2 U2302.2
PCH_SPI_MOSI: RP39.8 UC1.AA2
PCH_SPI_MOSI_1: RP39.1 U2302.5
PCH_SPI_WP1#: RP39.3 U2302.3
PCH_SPI_WP#: R2334.2 RP39.6 UC1.Y6
PCH_X1_R: RG6.1 UG1.5
PCIE_B+: PC1301.1 PJP1301.1 PU1300.8 PU1300.9 PU1300.10
PCIE_CRX_C_GTX_N0: CV44.2 UV1.Y32
PCIE_CRX_C_GTX_N1: CV46.2 UV1.W32
PCIE_CRX_C_GTX_N2: CV48.2 UV1.U32
PCIE_CRX_C_GTX_N3: CV50.2 UV1.U29
PCIE_CRX_C_GTX_P0: CV43.2 UV1.Y33
PCIE_CRX_C_GTX_P1: CV45.2 UV1.W33
PCIE_CRX_C_GTX_P2: CV47.2 UV1.U33
PCIE_CRX_C_GTX_P3: CV49.2 UV1.U30
PCIE_PRX_LANTX_N3: CL31.1 UC1.G11
PCIE_PRX_LANTX_N3_C: CL31.2 UL1.18
PCIE_PRX_LANTX_P3: CL30.1 UC1.F11
PCIE_PRX_LANTX_P3_C: CL30.2 UL1.17
PCIE_PRX_WLANTX_N4: JMINI.23 UC1.F13
PCIE_PRX_WLANTX_P4: JMINI.25 UC1.G13
PCIE_PTX_LANRX_N3: CC32.1 UL1.14
PCIE_PTX_LANRX_N3_C: CC32.2 UC1.C29
PCIE_PTX_LANRX_P3: CC40.1 UL1.13
PCIE_PTX_LANRX_P3_C: CC40.2 UC1.B30
PCIE_PTX_WLANRX_N4: CM49.1 UC1.B29
PCIE_PTX_WLANRX_N4_C: CM49.2 JMINI.31
PCIE_PTX_WLANRX_P4: CM44.1 UC1.A29
PCIE_PTX_WLANRX_P4_C: CM44.2 JMINI.33
PCIE_WAKE#: RC97.2 RL34.2 UE1.29 UL1.21
PCIE_WAKE#_R: RC34.2 RC97.1 UC1.AJ5
PECI_EC: RE43.2 UC1.N62
PECI_KB9012: RE43.1 UE1.118
PEG_CLKREQ#: QV28.1 RP42.6 UC1.U5
PEG_CRX_GTX_N0: CV44.1 UC1.F10
PEG_CRX_GTX_N1: CV46.1 UC1.F8
PEG_CRX_GTX_N2: CV48.1 UC1.H10
PEG_CRX_GTX_N3: CV50.1 UC1.E6
PEG_CRX_GTX_P0: CV43.1 UC1.E10
PEG_CRX_GTX_P1: CV45.1 UC1.E8
PEG_CRX_GTX_P2: CV47.1 UC1.G10
PEG_CRX_GTX_P3: CV49.1 UC1.F6
PEG_CTX_GRX_C_N0: CC18.1 UC1.C23
PEG_CTX_GRX_C_N1: CC20.1 UC1.B23
PEG_CTX_GRX_C_N2: CC22.1 UC1.B21
PEG_CTX_GRX_C_N3: CC24.1 UC1.B22
PEG_CTX_GRX_C_P0: CC19.1 UC1.C22
PEG_CTX_GRX_C_P1: CC21.1 UC1.A23
PEG_CTX_GRX_C_P2: CC23.1 UC1.C21
PEG_CTX_GRX_C_P3: CC25.1 UC1.A21
PEG_CTX_GRX_N0: CC18.2 UV1.Y37
PEG_CTX_GRX_N1: CC20.2 UV1.W36
PEG_CTX_GRX_N2: CC22.2 UV1.V37
PEG_CTX_GRX_N3: CC24.2 UV1.U36
PEG_CTX_GRX_P0: CC19.2 UV1.AA38
PEG_CTX_GRX_P1: CC21.2 UV1.Y35
PEG_CTX_GRX_P2: CC23.2 UV1.W38
PEG_CTX_GRX_P3: CC25.2 UV1.V35
PLT_RST#: CC30.1 CE36.1 JMINI.22 R159.1 RC51.1 UC3.4 UE1.13 UL1.19 UV13.2
PM_APWROK_R: RP50.6 UC1.AB5
PROC_OPI_RCOMP: RC134.1 UC1.AY15
PROJECT_ID: RC112.2 RC113.1 UC1.L5
PS_0: CV335.1 RV201.1 RV243.2 UV1.AM34
PS_1: CV329.1 RV237.2 RV238.1 UV1.AD31
PS_2: CV331.1 RV239.2 RV240.1 UV1.AG31
PS_3: CV333.1 RV241.2 RV242.1 UV1.AD33
PS_ID: PR3.1 PR4.2 UE1.16
PSID: PJPDC.1 PL2.1
PSID-1: PQ5.2 PR6.1 PR9.2
PSID-2: PQ5.1 PQ6.2 PR8.2
PSID-3: PQ6.3 PR4.1
PWM1: PU501.6 PU502.8
PWR_PWM_LED#: RD14.1 UE1.92
PWR_SRC_ON: CX4.2 QX2.3 RX2.2 RX3.1
PXS_PWREN: PR601.2 PR803.1 PR1103.1 PR1206.2 PR1300.1 QV24.2 QV25.2 RP54.4 RV105.2 UC1.P4
PXS_PWREN#: QV25.1 RV109.2
RASA0#: UV1.K23 UV4.G3 UV5.L3
RASA1#: UV1.K19 UV3.L3 UV6.G3
RASB0#: UV1.T10 UV7.L3 UV8.G3
RASB1#: UV1.Y10 UV9.L3 UV10.G3
REGN: PC709.1 PD701.2 PR707.1 PR713.1 PU701.16
RF_+1.2VSP: PR1105.1 PU1100.5
RING2: LA10.2 RA1109.1 UA1.17
RING2_R: CA40.1 DA12.2 JHP.3 LA10.1
RREF: RR1.1 UR1.1
RSVD_AL1: T136.1(TP-1) UC1.AL1
RSVD_AM11: T137.1(TP-1) UC1.AM11
RSVD_AP7: T139.1(TP-1) UC1.AP7
RSVD_AT2: T128.1(TP-1) UC1.AT2
RSVD_AU10: T141.1(TP-1) UC1.AU10
RSVD_AU15: T142.1(TP-1) UC1.AU15
RSVD_AU44: T132.1(TP-1) UC1.AU44
RSVD_AV44: T134.1(TP-1) UC1.AV44
RSVD_AW14: T144.1(TP-1) UC1.AW14
RSVD_AY14: T145.1(TP-1) UC1.AY14
RSVD_D15: T135.1(TP-1) UC1.D15
RSVD_F22: T138.1(TP-1) UC1.F22
RSVD_H22: T140.1(TP-1) UC1.H22
RSVD_J21: T143.1(TP-1) UC1.J21
RSVD_N23: T129.1(TP-1) UC1.N23
RSVD_R23: T130.1(TP-1) UC1.R23
RSVD_T23: T131.1(TP-1) UC1.T23
RSVD_U10: T133.1(TP-1) UC1.U10
RTC_VOUT: CG6.1 RG2.2 UG1.14
RUNPWROK: CC29.1 UC4.1 UC4.4 UC4.10 UC4.13 UE1.36
SATA_ACT#: RD15.1 UC1.U3
SATA_IREF: RC126.1 UC1.A12
SATA_PRX_DTX_N0: CS109.1 JHDD.5
SATA_PRX_DTX_N0_C: CS109.2 UC1.J5
SATA_PRX_DTX_N1: CS14.1 JBTB.5 JBTB1.7
SATA_PRX_DTX_N1_C: CS14.2 UC1.J8
SATA_PRX_DTX_P0: CS108.1 JHDD.6
SATA_PRX_DTX_P0_C: CS108.2 UC1.H5
SATA_PRX_DTX_P1: CS15.1 JBTB.3 JBTB1.9
SATA_PRX_DTX_P1_C: CS15.2 UC1.H8
SATA_PTX_DRX_N0: CS106.1 JHDD.3
SATA_PTX_DRX_N0_C: CS106.2 UC1.B15
SATA_PTX_DRX_N1: CS9.1 JBTB.4 JBTB1.10
SATA_PTX_DRX_N1_C: CS9.2 UC1.A17
SATA_PTX_DRX_P0: CS105.1 JHDD.2
SATA_PTX_DRX_P0_C: CS105.2 UC1.A15
SATA_PTX_DRX_P1: CS8.1 JBTB.6 JBTB1.8
SATA_PTX_DRX_P1_C: CS8.2 UC1.B17
SATA_RCOMP: RC131.1 UC1.C12
SD_CD#: CR9.1 JREAD.20 UR1.13
SD_CMD: CR11.1 JREAD.6 UR1.18
SD_D0: JREAD.18 UR1.11
SD_D1: JREAD.19 UR1.10
SD_D2: JREAD.1 UR1.21
SERIRQ: RC102.2 UC1.T4 UE1.3
SIO_EXT_SCI#: RC98.1 UC1.N5
SIO_SLP_S0#: UC1.AF3 UE1.89
SIO_SLP_S3#: CE27.1 UC1.AT4 UE1.6
SIO_SLP_S4#: T104.1(TP-1) UC1.AJ6 UE1.84
SIO_SLP_S5#: CE28.1 T103.1(TP-1) UC1.AP5 UE1.14
SKIP#: PR535.1 PU501.7
SKIP#1: PR535.2 PU502.1
SLATE_MODE_R: RC110.1 UC1.AL4
SLEWA_CPU: PR513.2 PR514.1 PU501.15
SM_RCOMP0: RC68.1 UC1.AU60
SM_RCOMP1: RC69.1 UC1.AV60
SM_RCOMP2: RC70.1 UC1.AU61
SML0CLK: RP49.1 UC1.AN1
SML0DATA: RP49.2 UC1.AK1
SML1_SMBCLK: QH1.1 RP40.3 UC1.AU3
SML1_SMBDATA: QH1.4 RP40.4 UC1.AH3
SNB_1.05V: PC301.1 PR302.2
SNB_VDDCI: PC1212.1 PR1207.2
SNUB_PCIE: PC1304.1 PR1303.2
SPK_L1-_CONN: CA30.1 JSPK.3 LA5.2
SPK_L2+_CONN: CA29.1 JSPK.4 LA6.2
SPK_R1-_CONN: CA32.1 JSPK.1 LA3.2
SPK_R2+_CONN: CA31.1 JSPK.2 LA4.2
SRTCRST#: CC3.2 ME1.2 RC5.2 UC1.AV6
SUS_STAT#/LPCPD#: RC29.2 UC1.AG4
SUSACK#: RC28.2 RC35.2 RC37.1 UE1.97
SUSACK#_R: RC37.2 UC1.AK2
SUSCLK: T102.1(TP-1) UC1.AE6
SUSP: Q8.1 Q2307.2 Q2308.2 R10.2
SUSP#: PR300.2 PR401.2 Q8.2 R16.1 R2313.1 R2318.1 UE1.116
SW_1.35V: PC200.2 PC207.1 PL200.2 PQ200.1 PQ200.2 PQ200.3 PQ201.5 PU200.16
SW_+1.2VSP: PC1103.2 PL1101.1 PQ1100.1 PQ1100.2 PQ1100.3 PQ1101.5 PR1104.1 PU1100.8
SW_CPU2: PC520.1 PL502.1 PU502.4
SW_VGA_CORE: PC807.2 PC815.1 PL802.1 PQ800.1 PQ800.2 PQ800.3 PQ801.5 PQ802.5 PQ803.1 PQ803.2 PQ803.3 PR829.1 PU800.16
SYS_PWROK: CC31.1 CE32.1 RC52.1 RP50.1 UE1.86
SYS_PWROK_R: RP50.8 UC1.AG2
SYS_PWROK_XDP: CC16.1 JXDP1.47 RC52.2 RC64.1
SYS_RESET#: RC26.2 UC1.AC3
SYSON: CE26.1 PR201.1 UE1.95
TDI_IREF: RC133.2 UC1.B12
TDI_XDP: JXDP1.56 RC44.2 RC45.1
TDI_XDP_R: RC45.2 RC63.1 UC4.5
TDO_XDP: JXDP1.52 RC43.2 RC62.1 RP44.4 UC4.2
TESTEN: RV133.2 UV1.AD28
THERM_CPU: PC509.1 PH502.2 PR512.2 PU501.14
THM_ALERT#: RV96.1 UV1.AG30 UV14.6
TL_BKOFF#: DX1.2 RX50.2 UX2.4
TL_BKOFF#_R: RX33.1 UX2.2 UX4.44
TL_ENVDD: RX7.2 RX51.2 UX4.20
TL_INVT_PWM: JLVDS.36 RX26.1 RX49.2 UX4.19
TMDS_L_TX0N: CX25.1 JHDMI.9 LX3.2
TMDS_L_TX0P: CX26.1 JHDMI.7 LX3.3
TMDS_L_TX1N: CX27.1 JHDMI.6 LX4.2
TMDS_L_TX1P: CX28.1 JHDMI.4 LX4.3
TMDS_L_TX2N: CX29.1 JHDMI.3 LX5.2
TMDS_L_TX2P: CX30.1 JHDMI.1 LX5.3
TMDS_L_TXCN: CX23.1 JHDMI.12 LX2.2
TMDS_L_TXCP: CX24.1 JHDMI.10 LX2.3
TMDS_TX0N: CX14.1 LX3.1 RP59.4
TMDS_TX0P: CX15.1 LX3.4 RP59.3
TMDS_TX1N: CX16.1 LX4.1 RP58.4
TMDS_TX1P: CX17.1 LX4.4 RP58.3
TMDS_TX2N: CX18.1 LX5.1 RP58.2
TMDS_TX2P: CX19.1 LX5.4 RP58.1
TMDS_TXCN: CX12.1 LX2.1 RP59.2
TMDS_TXCP: CX13.1 LX2.4 RP59.1
TMS_XDP: JXDP1.58 RC46.2 UC4.9
TON_1.35V: PR208.2 PU200.9
TOUCH_PANEL_INTR#: RP43.7 UC1.P3
TOUCH_RST: UE1.38
TOUCH_RST_N_GYRO_INT1: RC76.2 UC1.L1
TOUCHPAD_INTR#: RC74.2 UC1.U7
TP_CLK: JTP.2 RE9.2 UE1.87
TP_DATA: JTP.3 RE10.2 UE1.88
TP_DC_TEST_B2: T167.1(TP-1) UC1.B2
TRIP_+1.2VSP: PR1102.2 PU1100.2
TRST#_XDP: JXDP1.54 UC4.12
TS_FDO: RV235.2 RV236.1 UV1.AK32
UG_3V: PQ101.4 PU100.10
UG_5V: PQ103.4 PU100.16
UG_+1.2VSP: PQ1100.4 PU1100.9
UG_VGA_CORE: PQ800.4 PQ803.4 PU800.15
USB3RN1_JUSB2: LI4.1 UC1.G20
USB3RN1_JUSB2_R: DI4.1 DI4.10 JUSB2.5 LI4.2
USB3RN2_JUSB1: LI1.1 UC1.E18
USB3RN2_JUSB1_R: DI1.1 DI1.10 JUSB1.5 LI1.2
USB3RP1_JUSB2: LI4.4 UC1.H20
USB3RP1_JUSB2_R: DI4.2 DI4.9 JUSB2.6 LI4.3
USB3RP2_JUSB1: LI1.4 UC1.F18
USB3RP2_JUSB1_R: DI1.2 DI1.9 JUSB1.6 LI1.3
USB3TN1_JUSB2: CI10.2 UC1.C33
USB3TN1_JUSB2_C: CI10.1 LI6.1
USB3TN1_JUSB2_R: DI4.4 DI4.7 JUSB2.8 LI6.2
USB3TN2_JUSB1: CI3.2 UC1.B33
USB3TN2_JUSB1_C: CI3.1 LI3.1
USB3TN2_JUSB1_R: DI1.4 DI1.7 JUSB1.8 LI3.2
USB3TP1_JUSB2: CI11.2 UC1.B34
USB3TP1_JUSB2_C: CI11.1 LI6.4
USB3TP1_JUSB2_R: DI4.5 DI4.6 JUSB2.9 LI6.3
USB3TP2_JUSB1: CI4.2 UC1.A33
USB3TP2_JUSB1_C: CI4.1 LI3.4
USB3TP2_JUSB1_R: DI1.5 DI1.6 JUSB1.9 LI3.3
USB20_CAM_N7: LX6.1 RX21.1 UC1.AR13
USB20_CAM_N7_R: JLVDS.28 LX6.2 RX21.2
USB20_CAM_P7: LX6.4 RX22.1 UC1.AP13
USB20_CAM_P7_R: JLVDS.27 LX6.3 RX22.2
USB20_CR_N6: LR2.1 UC1.AP11
USB20_CR_N6_R: LR2.2 UR1.2
USB20_CR_P6: LR2.4 UC1.AN11
USB20_CR_P6_R: LR2.3 UR1.3
USB20_JUSB1_N1: LI2.1 UC1.AR7
USB20_JUSB1_N1_R: DI2.2 JUSB1.2 LI2.2
USB20_JUSB1_P1: LI2.4 UC1.AT7
USB20_JUSB1_P1_R: DI2.3 JUSB1.3 LI2.3
USB20_JUSB2_N0: LI5.1 UC1.AN8
USB20_JUSB2_N0_R: DI5.2 JUSB2.2 LI5.2
USB20_JUSB2_P0: LI5.4 UC1.AM8
USB20_JUSB2_P0_R: DI5.3 JUSB2.3 LI5.3
USB20_JUSB3_N2: LI7.1 UC1.AR8
USB20_JUSB3_N2_R: DI7.2 JUSB3.2 LI7.2
USB20_JUSB3_P2: LI7.4 UC1.AP8
USB20_JUSB3_P2_R: DI7.3 JUSB3.3 LI7.3
USB20_MINI1_N4: JMINI.36 UC1.AM15
USB20_MINI1_P4: JMINI.38 UC1.AL15
USB20_TOUCH_N5: UC1.AM13
USB20_TOUCH_P5: UC1.AN13
USB20_USBDB_N3: LI10.1 UC1.AR10
USB20_USBDB_N3_R: JDB.5 LI10.2
USB20_USBDB_P3: LI10.4 UC1.AT10
USB20_USBDB_P3_R: JDB.4 LI10.3
USB_EN#: CI13.1 CI16.1 CI25.1 CI26.1 UE1.26 UI2.4 UI3.4 UI4.4 UI5.4
USB_OC0#: CI15.1 CI17.1 RP55.1 UC1.AL3 UI2.5 UI3.5
USB_OC1#: CI24.1 CI32.1 RP55.2 UC1.AT1 UI4.5 UI5.5
USB_OC2#: RP55.3 UC1.AH2
USB_OC3#: RP55.4 UC1.AV3
USBRBIAS: RC90.1 UC1.AJ10 UC1.AJ11
VCIN0_PH: PH1.1 PR24.1 UE1.109
VCIN1_PH: PC13.2 PR23.1 PR26.2 PR27.2 UE1.102
VCOUT0_PH#: PC100.1 PR100.2 PR101.2 PR102.2 UE1.104
VCOUT1_PH: PR30.1 RE47.2 UE1.103 UE2.2
VGA_CLKREQ#_R: QV28.3 RV199.2 UV1.AN13
VGA_SMB_CK2: QV15.1 RV90.2 RV252.1 UV14.8
VGA_SMB_CK2_R: RV252.2 UV1.AJ23
VGA_SMB_DA2: QV15.4 RV91.2 RV251.1 UV14.7
VGA_SMB_DA2_R: RV251.2 UV1.AH23
VGA_X1_R: RG4.1 UG1.12
VL: PC106.1 PU100.13
VR12.5_VR_ON_R: R250.2 UC1.F60
VR_ENABLE: PC522.1 PR522.1 PU501.8
VR_HOT#: PC506.2 PR533.1 PU501.30 RE44.1
VR_ON: C80.1 CE34.1 DE1.3 PR522.2 R250.1 RE1.2 RE12.2
VR_ON_EC: RE12.1 UE1.121
VR_READY_R: R251.2 UC1.C59
VR_SVID_ALRT#: PR528.2 PU501.32 R252.2 R254.2
VR_SVID_CLK: PR526.2 PU501.31 R248.1
VR_SVID_DAT: PR530.2 PU501.1 R257.2
VRAM_ID0: RV67.2 RV68.2 UV1.AU1
VRAM_ID1: RV69.2 RV70.2 UV1.AU3
VRAM_ID2: RV71.2 UV1.AW3
VREF_CPU: PC507.1 PH502.1 PR502.2 PR504.2 PR507.2 PR514.2 PR531.1 PU501.27
VREFC1: CV388.2 CV397.1 RV29.1 RV37.2 UV4.J14
VREFC2: CV328.2 CV399.1 RV183.2 RV184.1 UV5.J14
VREFC3: CV349.1 CV350.2 RV193.2 RV194.1 UV3.J14
VREFC4: CV353.1 CV354.2 RV39.1 RV197.2 UV6.J14
VREFC5: CV21.2 CV22.1 RV5.1 RV6.2 UV8.J14
VREFC6: CV27.1 CV28.2 RV11.1 RV12.2 UV7.J14
VREFC7: CV33.1 CV34.2 RV17.1 RV19.2 UV9.J14
VREFC8: CV39.1 CV40.2 RV24.1 RV27.2 UV10.J14
VREFD1_1: CV387.1 CV393.2 RV28.2 RV34.1 UV4.A10
VREFD1_2: CV394.2 CV395.1 RV35.2 RV36.1 UV4.U10
VREFD2_1: CV396.2 CV398.1 RV38.2 RV181.1 UV5.A10
VREFD2_2: CV330.2 CV400.1 RV185.2 RV186.1 UV5.U10
VREFD3_1: CV389.2 CV390.1 RV32.2 RV33.1 UV3.A10
VREFD3_2: CV332.1 CV401.2 RV191.2 RV192.1 UV3.U10
VREFD4_1: CV351.1 CV352.2 RV195.2 RV196.1 UV6.A10
VREFD4_2: CV355.1 CV356.2 RV40.2 RV41.1 UV6.U10
VREFD5_1: CV13.1 CV18.2 RV1.2 RV2.1 UV8.A10
VREFD5_2: CV19.2 CV20.1 RV3.2 RV4.1 UV8.U10
VREFD6_1: CV23.1 CV24.2 RV7.1 RV8.2 UV7.A10
VREFD6_2: CV25.1 CV26.2 RV9.1 RV10.2 UV7.U10
VREFD7_1: CV29.1 CV30.2 RV13.1 RV14.2 UV9.A10
VREFD7_2: CV31.1 CV32.2 RV15.1 RV16.2 UV9.U10
VREFD8_1: CV35.1 CV36.2 RV20.1 RV21.2 UV10.A10
VREFD8_2: CV37.1 CV38.2 RV22.1 RV23.2 UV10.U10
VTTREF_1.35V: PC210.1 PU200.4
WCKA0_0: UV1.A32 UV4.D4 UV5.P4
WCKA0_1: UV1.D23 UV4.P4 UV5.D4
WCKA0B_0: UV1.C32 UV4.D5 UV5.P5
WCKA0B_1: UV1.E22 UV4.P5 UV5.D5
WCKA1_0: UV1.C14 UV3.P4 UV6.D4
WCKA1_1: UV1.E10 UV3.D4 UV6.P4
WCKA1B_0: UV1.A14 UV3.P5 UV6.D5
WCKA1B_1: UV1.D9 UV3.D5 UV6.P5
WCKB0_0: UV1.H3 UV7.P4 UV8.D4
WCKB0_1: UV1.T3 UV7.D4 UV8.P4
WCKB0B_0: UV1.H1 UV7.P5 UV8.D5
WCKB0B_1: UV1.T5 UV7.D5 UV8.P5
WCKB1_0: UV1.AE4 UV9.P4 UV10.D4
WCKB1_1: UV1.AK6 UV9.D4 UV10.P4
WCKB1B_0: UV1.AF5 UV9.P5 UV10.D5
WCKB1B_1: UV1.AK5 UV9.D5 UV10.P5
WEA0#: UV1.K26 UV4.L12 UV5.G12
WEA1#: UV1.L15 UV3.G12 UV6.L12
WEB0#: UV1.N10 UV7.G12 UV8.L12
WEB1#: UV1.AB11 UV9.G12 UV10.L12
WL_BT_LED: QD20.2 RD50.1 UE1.1
WL_BT_LED#: QD20.1 RD18.1 RD51.2
WL_BT_LED#_EC: QD18.1 QD19.1 RD46.2 RD49.2 RD51.1 RD52.1 UD1.4 UE1.64
WL_BT_LED#_EC2: RD48.2 UE1.74
WL_LED#: JMINI.44 QD18.3 RD45.2 RD48.1 UD1.1
WL_OFF#: QM30.3 RP54.3 UC1.AT5
WLAN_CLKREQ#: JMINI.7 RP42.7 UC1.N1
WLAN_RADIO_DIS#_R: JMINI.20 QM30.1 RM110.2
WOL_EN: RL27.2 RL38.1 UE1.98 UL2.3
XDP_DBRESET#: CC17.1 JXDP1.48 RC26.1 RC362.2
XDP_OBS0_R: JXDP1.21 RC141.1 UC1.J60
XDP_OBS1_R: JXDP1.23 RC141.2 UC1.H60
XDP_PRDY#: JXDP1.5 UC1.J62
XDP_PREQ#: JXDP1.3 RP44.3 UC1.K62
XDP_RST#_R: JXDP1.46 RC51.2
XDP_TCK: RP45.2 UC1.E60
XDP_TCLK: JXDP1.57 RC59.2 RC65.1 RP46.5
XDP_TDI: RP44.2 UC1.F63 UC4.6
XDP_TDO: RP45.1 UC1.F62 UC4.3
XDP_TMS: RP44.1 UC1.E61 UC4.8
XDP_TRST#: R2341.1 RC57.1 RP45.3 UC1.E59 UC4.11
XTAL24_IN: CC6.2 RC12.2 RG6.2 UC1.A25 YC2.3
XTAL24_OUT: CC7.2 RC12.1 UC1.B25 YC2.1
XTALIN: CV95.1 RG7.2 RV97.1 UV1.AV33 YV1.1
XTALIN_R: CG11.1 RG4.2 RG7.1
XTALOUT: CV94.1 RV97.2 UV1.AU34 YV1.3
XTLI: CL36.2 RG8.2 UL1.29 YL2.1
XTLI_R: CG7.1 RG5.2 RG8.1
XTLO: CL37.2 UL1.28 YL2.3
N197804: RV98.1 UV14.4
N14128350: PR1110.2 PU1100.1
N16944150: JKBBL.2 QE4.2 RE58.1
N16988653: PC605.1 PJP600.2 PU600.3
N16988706: PC601.1 PR605.2
N17002462: PC1200.1 PR1201.1 PR1206.1 PU1200.1
N17002482: PR1204.1 PR1209.1 PR1211.1 PU1200.4
N17002518: PR1208.2 PR1209.2 PR1210.1
N17002625: PC1210.1 PR1200.2
N17045846: PC807.1 PR802.2
N17045965: PR842.1 PU800.28
N17045986: PC809.2 PC813.2 PC817.2 PR813.2 PR820.1 PR846.1 PU800.7
N17046050: PR824.2 PU800.13
N17046121: PQ801.4 PQ802.4 PU800.18
N17046167: PC809.1 PC816.2 PR833.1 PR845.1 PU800.8
N17159315: RV84.1 UV1.AB34
N17216117: RV89.2 UV1.AM17
N17407779: CE12.1 R2354.1
N17434554: RE36.2 UE1.107
N17434577: RE7.2 UE1.66
N17438484: CA21.1 R2355.2
N17494823: CA1.1 CA2.1 QA5.2 RA3.2
N17607640: PC300.1 PR300.1 PR301.1 PU300.1
N17607660: PC307.2 PR305.2 PR307.1 PU300.4
N17608587: PC302.1 PR303.2
N17777752: RV244.1 RV245.1 UV1.V28 UV1.W29
N17839157: RV246.1 UV1.AF30
N17841799: RV247.1 UV1.AF31
N17860472: RV26.2 UV4.J13
N18009245: PC708.1 PC717.2 PR704.1 PU701.1
N18009258: PC719.1 PC722.2 PR710.2 PR716.3
N18009264: PL702.1 PR702.4
N18009271: PC707.1 PC717.1 PR717.1 PU701.2
N18009295: PC722.1 PR708.2 PR716.2
N18009369: PR714.2 PU701.9
N18009411: PQ702.4 PR706.1
N18009417: PC715.2 PR722.1
N18009452: PC723.1 PQ708.2 PR724.2
N18009461: PR715.2 PU701.8
N18107051: RV127.1 UV1.AM39
N18262754: RV207.1 UV1.AF33
N18284053: PJPDC.2 PJPDC.3 PL4.1
N18386761: RV31.2 UV3.J13
N18923200: DC1.2 RC10.1
N19505504: T117.1(TP-1) UC1.AD4
N19607621: QX5.2 RX15.1
N19636635: QA6.2 RA6.2 RA7.2
N19792982: QA5.5 QA5.6 RA2.2
N19794620: QA6.5 QA6.6 RA5.2
N20014303: PD1.6 PD2.3 PR17.1
N21178712: PQ1.3 PR5.2
N21178859: PC1302.1 PU1300.7
N21219517: RV64.2 UV1.AH16
N21220354: RV203.1 UV1.Y29
N21246320: PQ1201.1 PR1211.2
N21246524: PC1214.1 PQ1201.2 PR1212.2
N22321388: RE37.2 UE1.82
N22702729: LED2.1 RD15.2
N22702890: LED3.2 RD16.2
N22702897: LED3.3 RD17.2
N22703004: LED1.1 RD14.2
N22795339: LED4.1 RD18.2
N25368131: RV25.2 UV5.J13
N25669355: RV30.2 UV6.J13
N26889205: RV198.1 UV1.Y30
N32320781: PQ701.3 PR702.1
N32936693: PQ706.1 PR720.2
N39186606: RV125.1 UV1.AL21
N39195318: RV123.1 UV1.AW28
N39348342: RV122.1 UV1.AW18
N39890903: CV218.1 UV1.AK10
N39890907: CV219.2 RV137.1
N39890909: CV218.2 RV136.1
N39890911: CV222.1 RV143.2 RV144.1
N39890927: CV219.1 UV1.AL10
N39986171: QV24.1 RV107.2 RV108.1
N39986181: CV103.1 QV22.2 RV108.2
N40812716: CR3.2 UR1.6
N45520480: RV206.2 UV1.M27
N46608735: PQ701.2 PR701.1
N46608740: PC702.2 PQ701.4 PR721.2
N46608753: PC701.2 PC702.1 PR701.2 PR703.1
N46612327: PR708.1 PU701.13
N46612330: PR710.1 PU701.12
N46660696: PC520.2 PR534.1
N46662317: PR510.1 PU501.4
N46663656: PC504.1 PR516.2 PU501.2
N46665785: PC514.1 PR529.1
N46673636: PH501.2 PR515.1
N46674251: PL502.2 PR518.2
N46860163: PQ708.1 PR713.2 PU701.10
N46975913: PC501.1 PR536.2
N46975982: PR536.1 PU502.6
N46976065: PC501.2 PU502.7
N47007806: PC16.1 PQ2.3 PR28.2
N47007810: PC16.2 PQ2.2 PR29.1
N47007850: PQ2.5 PR31.1 PR33.2
N47007898: PC14.2 PQ3.5 PR32.1
N47008006: PQ1.5 PQ1.6 PR7.1 PR10.2
N47008110: PC15.1 PQ3.2 PR30.2
N47008134: PL2.2 PQ6.1 PR6.2
N47008301: PQ4.1 PR27.1
N47305899: PC815.2 PR805.1
N47415217: PC104.2 PR103.1
N47415258: PC103.1 PR113.2
N47415272: PC111.1 PR112.2
N47415370: PC110.1 PR111.2
N47417471: PC405.1 PJP400.2 PU400.3
N47417524: PC401.1 PR405.2
N47420895: PC207.2 PR203.1
N47445410: PR114.1 PU100.19
N47894294: CC8.2 RC23.1
N47894380: CC9.2 RC24.1
N47894401: CC10.2 RC25.1
N47938591: T118.1(TP-1) UC1.AN10
N47938593: T119.1(TP-1) UC1.AM10
N47938689: T120.1(TP-1) UC1.E15
N47938710: T121.1(TP-1) UC1.E13
N47964855: T153.1(TP-1) UC1.L60
N47964866: T154.1(TP-1) UC1.N60
N47964871: T155.1(TP-1) UC1.W23
N47964873: T156.1(TP-1) UC1.Y22
N47964879: T157.1(TP-1) UC1.AV62
N47964884: T158.1(TP-1) UC1.D58
N47965485: T146.1(TP-1) UC1.AV63
N47965487: T147.1(TP-1) UC1.AU63
N47965489: T160.1(TP-1) UC1.P20
N47965491: T162.1(TP-1) UC1.R20
N47965493: T159.1(TP-1) UC1.A5
N47965495: T148.1(TP-1) UC1.C63
N47965502: T161.1(TP-1) UC1.E1
N47965509: T149.1(TP-1) UC1.C62
N47965511: T163.1(TP-1) UC1.D1
N47965522: T150.1(TP-1) UC1.B43
N47965524: T164.1(TP-1) UC1.J20
N47965529: T151.1(TP-1) UC1.A51
N47965534: T152.1(TP-1) UC1.B51
N47965536: T165.1(TP-1) UC1.H18
N48037563: JDIMM1.197 RD6.2
N48037565: JDIMM1.201 RD7.2
N48039107: CD21.1 CD22.1 JDIMM1.126 RD4.1
N48051997: CD52.1 CD53.1 JDIMM2.126 RD10.1
N48052813: JDIMM2.197 RD13.1
N48052822: JDIMM2.201 RD12.1
N48120577: RX5.2 UX4.12
N55155843: QX1.1 RX3.2
N55200533: QX3.1 RP58.5 RP58.6 RP58.7 RP58.8 RP59.5 RP59.6 RP59.7 RP59.8
N55201771: JHDMI.13 RX12.2
N56393123: RL31.2 UL1.31
N56393790: T94.1(TP-1) UL1.27
N56393809: T95.1(TP-1) UL1.25
N56393828: T96.1(TP-1) UL1.26
N56394014: CL33.1 RL19.2 RL20.2
N56394031: CL41.2 TL1.3 TL1.6
N60531222: RP41.1 UC1.C35
N60531228: RP41.2 UC1.C34
N60531230: RP41.3 UC1.AK8
N60531232: RP41.4 UC1.AL8
N60754677: T111.1(TP-1) UC1.H61
N60754679: T112.1(TP-1) UC1.H62
N60754681: T113.1(TP-1) UC1.K59
N60754683: T114.1(TP-1) UC1.H63
N60754685: T115.1(TP-1) UC1.K60
N60754687: T116.1(TP-1) UC1.J61
N60931942: T97.1(TP-1) UC1.AF2
N60931944: T99.1(TP-1) UC1.AF4
N60931946: T98.1(TP-1) UC1.AD2
N61580896: Q2307.1 R2314.2
N61580898: Q2308.1 R2315.2
N63469417: CA65.2 CA69.1 RA79.1 RA81.2
N63469524: CA68.2 RA82.1
N63469526: CA67.2 RA80.1
N63469613: CA65.1 UA1.12
N63469617: RA51.1 UA1.13
N63469687: CA23.2 UA1.28
N63469697: RA153.2 UA1.15
N63469703: CA24.1 UA1.37
N63469709: CA24.2 UA1.35
N63469711: CA25.2 UA1.34
N63469717: CA62.2 UA1.27
N63469723: CA63.2 UA1.39
N63469729: CA64.2 UA1.7
N63469750: RA130.2 UA1.8
N63642793: C51.1 R264.2 UC1.AH11
N63643467: T53.1(TP-1) UC1.J13
N63643476: T55.1(TP-1) UC1.AH13
N63643505: T56.1(TP-1) UC1.AB8
N63643514: T58.1(TP-1) UC1.AD10
N63643523: T59.1(TP-1) UC1.AD8
N63656577: T38.1(TP-1) UC1.AB23
N63657072: T39.1(TP-1) UC1.P60
N63657081: T40.1(TP-1) UC1.P61
N63657090: T41.1(TP-1) UC1.N59
N63657099: T42.1(TP-1) UC1.N61
N63657120: T43.1(TP-1) UC1.T59
N63657126: T44.1(TP-1) UC1.AD60
N63657135: T45.1(TP-1) UC1.AD59
N63657146: T46.1(TP-1) UC1.AA59
N63657155: T47.1(TP-1) UC1.AE60
N63657164: T48.1(TP-1) UC1.AC59
N63657173: T49.1(TP-1) UC1.AG58
N63657182: T50.1(TP-1) UC1.U59
N63657191: T51.1(TP-1) UC1.V59
N64564173: PC1103.1 PR1101.2
N64564191: PC1106.1 PR1104.2
N64734520: T107.1(TP-1) UC1.AJ7
N64734538: T105.1(TP-1) UC1.AL5
N64734540: T106.1(TP-1) UC1.AP4
N93761952: RV163.2 UV8.J13
N93762059: RV162.2 UV7.J13
N93819115: RV171.2 UV10.J13
N93820861: RV169.2 UV9.J13

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JHDD 18 20 21 22; JHDMI 14; JKB 2 3 30; JKBBL 3; JLAN 4 5 7 8; JLVDS 38; JMINI 1 3 5 8 10 12 14 16 17 19 37 42 45 47; JXDP1 55; LED1 3; LED2 3; LED4 3; PD1 5; PU100 7; PU200 10; PU400 2 5; PU501 5; PU600 2 5; PU800 1; PU1200 2; PU1300 4; RP37 4 5; RP42 5; RP43 3 4 5 6; RP45 4 5; RP46 3 6; RP48 4 5; RP49 3 4 5 6; RP50 4 5; RP56 1 2; RP57 3 4 5 6; RP60 2 7; TL1 4 5 12 13; U2301 10 12; U2303 1; U2304 5 6 7 8 9 10 12; UA1 14 16 20 23 24 48; UC1 A31 A37 A41 A49 A53 AA23 AB21 AC2 AC4 AC20 AC58 AD23 AE59 AF20 AG5 AL2 AL11 AL32 AM5 AN3 AP1 AP15 AP32 AT3 AU2 AU12 AV2 AV10 AV50 AW10 AW49 AY8 AY42 AY43 B14 B31 B37 B41 B49 B50 B53 B54 C3 C4 C15 C17 C30 C31 C42 C43 C46 C47 C49 C50 C51 C53 D17 E2 E3 E4 E5 F4 F5 F15 F17 G2 G15 G17 H6 J4 J6 J58 K4 K10 K18 K21 L2 L3 L11 L59 M20 M21 N2 N58 R5 T2 U2 V21 Y2 Y4 Y5 Y20; UE2 1; UL1 3 6 7 9 10 11 22 24; UR1 7 14 17 19 23; UV1 AA29 AC10 AC30 AC31 AC32 AD30 AD32 AF32 AF35 AG12 AG32 AG33 AG36 AG38 AH12 AH24 AH26 AH35 AH37 AJ19 AJ20 AJ21 AJ24 AJ26 AJ27 AJ30 AJ31 AJ36 AJ38 AK13 AK17 AK19 AK20 AK21 AK24 AK26 AK27 AK35 AK37 AL19 AL27 AL29 AL30 AL31 AL36 AM19 AM20 AM21 AM26 AM27 AM29 AM30 AN7 AN14 AN20 AN21 AN26 AN36 AP6 AP8 AP10 AP12 AP34 AP35 AP37 AR1 AR3 AR6 AR8 AR10 AR12 AR14 AR16 AR20 AR22 AR24 AR26 AR30 AR32 AR34 AR35 AR37 AT7 AT9 AT11 AT15 AT17 AT19 AT21 AT23 AT25 AT27 AT29 AT31 AT33 AU5 AU6 AU8 AU10 AU12 AU14 AU16 AU20 AU22 AU24 AU26 AU30 AU32 AU35 AU39 AV7 AV9 AV11 AV13 AV15 AV21 AV23 AV25 AV31 AW5 AW6 AW8 AW10 AW12 AW37 E37 F35 F37 G36 G38 H32 H33 H35 H37 J32 J33 J36 J38 K16 K27 K29 K30 K32 K33 K35 K37 L10 L27 L29 L30 L32 L33 L36 L38 M12 M20 M21 M35 M37 N12 N29 N30 N32 N33 N36 N38 P29 P30 P32 P33 P35 P37 R36 R38 T29 T30 T32 T33 T35 T37 U12 U38 V12; UV3 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV4 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV5 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV6 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV7 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV8 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV9 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UV10 A5 A11 A13 B11 B13 E11 E13 F11 F13 M2 M4 N2 N4 R2 T2 T4 U2 U4 U5; UX4 2 23 24 33 34; YC2 2 4

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 875 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 4890 vias
v3: diameter 0.508, hole 0.254, TOP to BOTTOM, 764 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 133 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 101.1
  TOP w0.254: v2(83.15,40.08) v1(83.15,48.52) 83.15,52.77
  IN3 w0.254: v2(83.15,40.08) 158.69,40.08 v2(162.92,35.85)
  BOTTOM w0.254: PR202.1 v2(162.92,35.85)
1.35V_B+: length 6.3
  BOTTOM w0.254: 161.45,20.26 161.45,20.55 161.91,21.01 162.65,21.01 162.79,21.14 162.79,23.81 162.96,23.98 162.96,25.41 PR208.1
  vias: v1(160.33,20.14)
3/5V_B+: length 16.4
  TOP w0.203: PU100.12 209.7,19.82 209.9,19.62 v3(210.47,19.62)
  TOP w0.508: v2(216.5,24.39) v4(216.5,25.2) 216.5,25.68 216.21,25.97 211.74,25.97 211.1,25.34 211.1,19.99 210.73,19.62 v3(210.47,19.62)
  BOTTOM w0.508: PC105.1 210.35,19.51 v3(210.47,19.62)
3V_EN: length 11.3
  TOP w0.203: PU100.6 206.35,18.28 206.17,18.1 205.98,18.1 v3(205.85,17.97)
  TOP w0.254: v2(205.06,22.93) 204.25,23.73 PD101.2 204.25,26.94 PR100.1
  BOTTOM w0.254: v3(205.85,17.97) 206.17,18.29 206.17,20.86 v1(205.67,21.36) 205.06,21.97 v2(205.06,22.93)
3VALW_PCH:
  vias: v1(139.22,27.69)
3VS:
  vias: v1(194.4,17)
3VS_GATE: length 7.3
  TOP w0.102: R2318.2 v1(187.99,16.47)
  TOP w0.203: U2301.5 191.84,19.48 v2(191.74,19.37)
  TOP w0.254: v2(188.75,18.74) C2322.1 187.97,17.67 R2318.2
  IN1 w0.254: v2(188.75,18.74) 188.88,18.86 189.54,18.86 190.27,19.59 191.52,19.59 v2(191.74,19.37)
5V_EN: length 6
  TOP w0.203: PU100.20 206.35,22.21 v1(205.69,22.86)
  TOP w0.254: PR101.1 205.45,25.53 205.25,25.33 PD101.3 205.25,23.75 205.69,23.31 v1(205.69,22.86)
5VS:
  vias: v1(194.73,22.1)
5VS_GATE: length 7.7
  TOP w0.102: v1(187.8,22.29) 188.05,22.04 R2313.2
  TOP w0.203: U2301.3 v2(191.74,20.28)
  TOP w0.254: v2(188.75,19.37) 188.56,19.37 187.99,19.94 C2309.1 187.97,20.94 R2313.2
  IN1 w0.254: v2(188.75,19.37) 188.88,19.24 189.39,19.24 190.11,19.97 191.42,19.97 v2(191.74,20.28)
+0.675VS: length 107.9
  IN2 w1.016: 155.22,33.9 155.22,56 155.67,56.44
  IN3 w1.016: 156.62,58.07 170.93,58.07 173.06,60.2 179.73,60.2 183.67,64.14 183.67,66.41 ; 154.59,58.07 154.15,58.51 112.9,58.51 105.5,65.91 105.5,66.92
  vias: v2(105.5,68.43) v2(105.5,67.79) v2(155.6,58.35) v2(155.6,57.71) v2(183.86,68.14) v2(183.86,67.5) v3(154.78,31.87) v3(155.41,31.87) v4(184.24,72.84)
+0.675VSP: length 3.4
  TOP w0.102: v2(156.83,29.32) v1(156.14,29.32)
  IN2 w0.254: v2(156.83,29.32) v3(158.48,29.32)
  BOTTOM w0.203: v3(158.48,29.32) 158.11,28.95 PU200.2
+1.2VSP_B+:
  vias: v1(177.59,179.15)
+1.05V_PGOOD: length 154.5
  TOP w0.102: v2(147.35,154.17) v1(148.06,154.17)
  TOP w0.203: UE1.122 183.22,41.72 183.62,42.12 183.62,45.18 185.48,47.04 189.4,47.04 189.83,47.47 192.85,47.47 193.26,47.07 v2(193.26,46.47)
  IN2 w0.508: v2(147.35,154.17) 147.35,148.77 148.54,147.58 148.54,133.41 152.45,129.49 152.45,122.04 154.44,120.06 154.44,114.87 155.14,114.17 158.75,114.17 161.57,111.35 161.57,108.46 162,108.03 163.22,108.03 166.36,104.9 166.36,101.7 168.85,99.21 172.77,99.21 178.59,93.39 178.59,91.17 185,84.76 185,83.14 190.78,77.36 190.78,60.97 193.92,57.84 193.92,56.66 192.75,55.49 192.75,53.5 192.73,53.49 192.73,50.43 193.26,49.9 v2(193.26,46.47)
  BOTTOM w0.203: PU300.2 145.87,156.09 147.35,154.61 v2(147.35,154.17) 147.35,153.82 148.15,153.02 PR308.2
+1.5VS: length 348.4
  TOP w0.102: v3(106.99,30.56) v4(105.92,30.56)
  TOP w0.457: RC129.1 120.81,121.72 121.53,122.44 v2(121.53,122.64)
  TOP w0.508: v2(38.26,17.35) 38.26,17.44 37.76,17.95 RA8.1
  IN1 w0.508: v2(38.26,17.35) 38.64,16.97 38.64,15.43 40.11,13.96 57.94,13.96 61.12,17.14 65.43,17.14 67.65,19.36 82.6,19.36 94,30.75 106.29,30.75
  IN2 w0.254: 121.11,126.85 121.63,127.37 122.27,127.37 122.71,126.93 122.71,126.29 122.06,125.64 122.06,122.91 121.79,122.64 v2(121.53,122.64) 121.26,122.64 121.11,122.8 121.11,126.85
  IN2 w0.508: v2(38.26,17.35) 39.01,18.09 39.51,18.09 41.81,20.39 46.96,20.39 50.57,24.01 50.57,28.72 49.56,29.73 49.56,51.25 30.55,70.26 30.55,102.21 47.46,119.13 63.55,119.13 81.72,137.29 82.39,137.29 82.9,137.8 82.9,139 83.73,139.83 84.1,139.83 85.31,141.04 85.31,145.67 87.57,147.93 96.18,147.93 96.47,147.64 99.76,147.64 100.05,147.93 106.32,147.93 106.57,148.19 113.85,148.19 114.1,147.93 118.24,147.93 119.03,148.72 121.74,148.72 v2(122.39,148.07) 123.03,147.44 123.03,139.75 121.69,138.42 121.69,134.8 123.6,132.89 123.6,128.96 122.27,127.62 122.27,127.37
  IN3 w0.508: v2(122.39,148.07) 119.72,150.74 115.78,150.74 115.02,151.5 v2(114.01,151.5)
  BOTTOM w0.254: v2(121.53,122.64) 121.82,122.35 UC1.J15
  BOTTOM w0.508: v2(94.91,151.55) 94.79,151.55 94.3,151.07 JMINI.6 ; JMINI.28 v2(106.3,151.55) ; JMINI.48 114.3,151.21 v2(114.01,151.5)
  vias: v3(106.99,31.19) v3(107.62,31.19) v3(107.62,30.56) v3(108.26,31.19) v3(108.26,30.56)
+1.05VS: length 197.7
  TOP w0.203: UG1.3 63.12,43.71
  TOP w0.254: RP45.8 73.56,113.41 v2(73.17,113.02)
  TOP w0.508: v2(116.05,113.21) 116.05,113.26 113.76,115.56 109.19,115.56 108.23,116.51 105.74,116.51 C43.1 103.14,113.91 98.39,113.91 96.93,112.45 91.79,112.45 91.41,112.07 88.74,112.07 86.54,114.26 v2(86.08,114.26) ; RC58.1 88.75,121.59 RC60.1 87.85,122.04 v2(87.66,122.23) ; C57.1 v2(131.09,123.05) ; C50.1 123.86,120.33 v2(124.02,120.17) ; C53.1 124.55,120.8 v2(124.51,120.76) ; 63.12,43.71 63.12,43.32 63.41,43.02 CG2.1 63.66,42.36 v2(64.25,41.76) ; v2(123.44,122.61) 123.41,122.58 123.41,122.58 122.79,121.95 C61.1 ; v2(128.68,124.45) 129.3,125.07 C62.1 130.1,125.07 130.54,124.64 C60.1 ; PR533.2 84,136.7 v2(83.85,136.86) ; PC512.1 v2(86.95,136.83) ; C88.1 117.76,119.38 v2(118.22,118.93)
  IN2 w0.508: 64.3,116.47 64.29,116.46 46.89,116.46 31.4,100.97 31.4,70.63 58.27,43.75 62.26,43.75 v2(64.25,41.76) ; v2(125.87,114.09) 125.45,114.09 124.59,113.23 121.69,113.23 120.97,112.51 v2(120.97,112.4)
  BOTTOM w0.203: UC1.AG14 122.19,113.72 v2(122.01,113.9) ; v2(124.03,113.82) 124,113.84 123.22,113.84 123,113.62 UC1.AG13
  BOTTOM w0.254: UC1.AG17 120.59,112.78 v2(120.97,112.4) 120.98,112.42 120.98,112.42 121.35,112.78 UC1.AG16 ; v2(124.02,120.17) 124.51,120.67 v2(124.51,120.76) ; UC1.P9 125.69,120.25 UC1.N8 125.69,120.31 UC1.M9 v2(124.51,120.76) ; v2(124.51,120.76) 124.51,120.94 UC1.L10 125.25,121.68 UC1.K9 ; UC1.AE22 UC1.AC22 ; UC1.AE22 117.57,114.05 UC1.AE23 116.49,113.64 v2(116.05,113.21) ; UC1.AE22 v2(118.22,114.05) ; v2(123.44,123.3) 123.57,123.3 UC1.H11 ; UC1.H15 121.64,123.32 v2(121.6,123.32) ; v2(118.19,112.99) 117.94,113.24 UC1.AF22 ; UC1.AG8 125.25,113.11 UC1.AF9 125.25,113.17 UC1.AE8 125.69,113.91 v2(125.87,114.09) ; UC1.T21 118.59,118.55 v2(118.22,118.93) 118.59,119.3 UC1.R21 ; UC1.J11 123.74,122.35 123.49,122.61 v2(123.44,122.61) ; v2(120.61,122.68) 120.94,122.35 UC1.J17 ; JXDP1.43 62.7,96.82 v2(62.5,97.02) 62.88,97.39 v2(62.95,97.39) ; UC1.AE9 124.5,114.09 124.22,113.82 v2(124.03,113.82)
  BOTTOM w0.279: v2(63.21,99.37) 62.7,99.88 JXDP1.44 62.7,103.68 CC14.1
  BOTTOM w0.457: R286.1 v2(91.16,132.3)
  BOTTOM w0.508: PR533.2 84,136.7 v2(83.85,136.86) ; R256.1 79.92,120.74 v2(80.08,120.59) 80.74,120.59 R252.1
  vias: v2(63.85,99.37) v2(78.9,123.9) v2(79.53,123.9) v2(80.17,123.9) v2(84.26,124.36) v2(84.63,124.85) v2(85.44,114.26) v2(86.9,133.85) v2(87.53,133.85) v2(118.77,141.02) v2(119.21,141.47) v2(119.65,115.66) v2(119.65,115.02) v2(147.54,129.34) v2(147.54,128.75) v3(143.03,140.83) v3(143.03,140.2) v3(143.03,139.56) v3(143.03,138.93) v3(143.67,140.83) v3(143.67,140.2) v3(143.67,139.56) v3(143.67,138.93) v3(144.3,140.83) v3(144.3,140.2) v3(144.3,139.56) v3(144.3,138.93) v3(144.94,140.83) v3(144.94,140.2) v3(144.94,139.56) v3(144.94,138.93) v4(141.65,138.55)
+1.05VS_APLLOPI: length 32.7
  TOP w0.508: v2(118.22,116.49) 118.25,116.52 C69.1 119.02,116.64 119.02,119.5 118.33,120.18 118.33,120.64 117.45,121.51 117.45,122.53 116.74,123.24 116.74,125.4 117.12,125.78 117.12,127.43 117.26,127.57 117.26,128.84 v1(117.99,129.57) 118.53,130.11 118.53,131.48 v2(118.52,131.5)
  IN3 w0.508: v2(126.33,142.42) v2(126.33,141.78) 126.33,140.77 120.04,134.48 120.04,133.34 118.52,131.81 v2(118.52,131.5)
  BOTTOM w0.254: UC1.AA21 118.59,116.12 v2(118.22,116.49) 118.59,116.86 UC1.W21
+1.05VS_ASATA3PLL: length 22.2
  IN3 w1.016: 125.19,143.82 127.16,143.82 128.04,142.93 128.04,140.39 126.01,138.36 126.01,135.94
  BOTTOM w0.203: 123.88,127.11 123.76,127.11 UC1.B11
  BOTTOM w0.381: 123.88,127.11 124.09,127.11 124.37,127.39 124.37,128.22 125.43,129.27 125.43,130.15 v2(125.1,130.48) 125.1,132.41 C63.1
  BOTTOM w0.508: 125.44,136.07 125.44,135.56 124.68,134.8 124.68,133.8 RC131.2 124.19,133.54 123.69,134.04 RC126.2
  vias: v1(123.66,144.78) v2(123.66,144.25) v2(124.3,144.25) v2(125.76,134.86) v2(126.39,134.86)
+1.05VS_AUSB3PLL: length 24
  IN2 w0.508: v2(114.07,133.08) 114.53,133.54 118.79,133.54 120.62,135.37 v2(120.62,136.26)
  BOTTOM w0.102: 114.12,127.91 114.12,127.23 UC1.B27
  BOTTOM w0.254: UC1.B18 119.37,126.96 119.37,127.33 119.28,127.43 119.28,128.77 119.92,129.42
  BOTTOM w0.305: 114.12,127.91 114.12,128.99 114.64,129.51 114.64,130.41 RC91.1 113.74,132.12 114.07,132.45 v2(114.07,133.08)
  BOTTOM w0.508: 119.66,134.68 120.48,133.87 C58.1 120.48,131.22 120.25,130.99 120.25,129.74 119.92,129.42
  vias: v1(120.62,134.81)
+1.05VS_AXCK_DCB: length 4.8
  BOTTOM w0.254: v2(119.6,122.67) 119.74,122.67 UC1.J18 120.06,122.35 UC1.K19
  BOTTOM w0.508: v2(122.3,138.04) 121.75,138.04 121.3,138.48 C84.1 121.3,140.2 L4.2
  vias: v1(122.13,135.69)
+1.05VS_AXCK_LCPLL: length 16.4
  BOTTOM w0.254: UC1.A20 118.75,129.08
  BOTTOM w0.381: C85.1 119.71,133.37 119.71,130.04 118.75,129.08
  BOTTOM w0.508: 118.71,134.61 119.61,133.71 C85.1 ; 118.71,134.61 118.27,135.05 C86.1 117.31,137.54 L5.2 ; 118.71,134.61 118.65,134.61 117.18,133.15 v1(117.18,132.87) 116.46,132.14 RC13.2
+1.05VSP: length 18.1
  IN1 w0.254: v3(146.27,143.37) 148.49,143.37 149.89,144.77 149.89,148.83 150.65,149.59 150.65,155.31 150.23,155.73 v2(149.53,155.73)
  BOTTOM w0.254: v2(149.53,155.73) PR305.1 PC307.1
  vias: v1(147.76,142.61) v3(140.68,145.15) v3(141.32,145.15) v3(142.33,145.15) v3(142.97,145.15) v3(143.92,145.15) v3(144.55,145.15) v3(145.32,145.15) v3(145.95,145.15) v3(146.78,145.15) v3(147.41,145.15)
+1.5VSP: length 12.3
  TOP w0.254: PC404.1 PR403.1 110.54,18.93 111.48,19.88 v4(111.48,22.57) 111.48,26.75 110.49,27.74 v2(109.3,27.74)
+1.5VSP_ON: length 5.5
  TOP w0.102: v1(107.46,17.1) PC403.1
  TOP w0.254: PC403.1 PR404.1 PR401.1 107.88,20.17 108.25,19.8 v3(108.39,19.8)
  BOTTOM w0.254: v3(108.39,19.8) 108.25,19.66 PU400.7
+1.8VGS: length 406.8
  TOP w0.203: 63.99,47.4 63.92,47.32 UG1.11
  TOP w0.508: RV118.2 160.56,104.76 v2(160.05,104.25) 159.93,104.13 157.13,104.13 156.56,104.7 RV124.1 ; 161.56,116.24 161.37,116.24 160.81,115.67 RV241.1 161.3,114.55 162.12,113.74 LV12.2 162.92,113.4 v2(162.92,112.95) ; 161.56,116.24 LV13.2 ; 161.56,116.24 161.03,116.77 159.92,116.77 159.1,117.59 v2(158.91,117.59) ; LV17.1 153.38,113.02 153.76,112.64 153.76,111.64 153.58,111.46 153.58,110.78 153.86,110.51 154.62,110.51 154.76,110.65 156.48,110.65 156.87,111.04 RV243.1 v2(157.57,111.28) RV239.1 ; 63.99,47.4 63.99,48.29 CG1.1 64.39,48.48 v2(64.8,48.88) ; v2(192.5,100.63) v4(190.96,99.1) 190.65,98.79 v2(190.65,96.06) ; v2(168.68,102.48) 167.92,101.71 166.61,101.71 166.38,101.48 RV237.1 ; LV21.1 v2(203.72,156.83)
  IN1 w0.508: v2(192.5,100.63) 192.5,100.57 191.92,99.99 189.94,99.99 189.1,100.83 186.63,100.83 185.97,101.5 184.22,101.5 183.86,101.14 v2(183.22,101.14) 182.83,101.14 182.82,101.12 175.24,101.12 173.89,102.47 173.89,103.22 173.3,103.82 172.25,103.82 171.41,102.98 169.19,102.98 v2(168.68,102.48) ; v2(64.8,48.88) 65.08,49.16 140,49.16 143.13,46.03 162.6,46.03 167.71,51.13 171.35,51.13 173.93,53.71 v2(174.73,53.71)
  IN2 w0.508: v2(168.68,102.48) 168.68,103.47 162.33,109.82 162.33,111.94 162.92,112.53 v2(162.92,112.95)
  IN3 w0.508: v2(203.72,156.83) 203.72,158.21 203,158.93 164.9,158.93 159.91,153.94 159.91,143.55 157.9,141.55 157.9,129.58 160.57,126.91 160.57,119.25 v2(158.91,117.59)
  BOTTOM w0.508: 186.46,89.33 186.53,89.4 187.16,89.4 191.52,93.75 191.52,96.06 ; 167.92,101.71 163.86,101.71 162.25,103.31 160.98,103.31 v2(160.05,104.25) 159.89,104.4 159.89,105.18 159.54,105.53 LV16.1 LV14.2 ; 167.92,101.71 167.73,101.52 167.73,100.06 LV19.1 169.05,98.21 168.77,97.93 168.77,90.07 168.37,89.66 167.38,89.66 166.86,89.14 166.86,87.78 169.12,85.52 183.19,85.52 189.6,79.11 189.6,57.24 188.93,56.57 188.93,54.03 188,53.1 181.66,53.1 180.36,54.41 175.43,54.41 v2(174.73,53.71) ; 167.92,101.71 v2(168.68,102.48) ; RV119.1 183.22,101.14 v2(183.22,101.14) 183.72,101.14 LV20.1 RV93.2 ; RV71.1 RV69.1 ; RV71.1 192.88,101.01 v2(192.5,100.63) ; RV71.1 RV67.1 ; v2(158.91,117.59) 157.71,117.59 156.88,116.76 LV18.1 155.88,116.76 155.44,116.32 155.44,113.76 155.77,113.43 155.77,112.82 157.31,111.28 v2(157.57,111.28) ; LV22.1 191.75,96.29 191.52,96.06 ; 191.52,96.06 v2(190.65,96.06)
+1.8VS: length 32.6
  TOP w0.102: v2(184.43,89.08) v1(185.17,89.08)
  IN1 w1.016: 185.45,88.83 187.54,88.83 189.96,91.24 209.01,91.24 213.8,96.03 214.31,96.03
  vias: v2(184.43,88.49) v2(215.23,97.27) v2(215.23,96.64) v2(215.23,96.05)
+1.8VSP: length 19.9
  BOTTOM w0.254: v2(215.48,99.24) 217.6,101.36 222.26,101.36 223.36,100.26 223.36,92.11 PR603.1 PC604.1
  vias: v1(216.22,100.94) v2(218.66,98.67) v2(218.66,98.03)
+1.8VSP_ON: length 6.8
  TOP w0.102: PR601.1 218.29,94.59 v1(217.72,94.02)
  TOP w0.508: PR601.1 219.15,95.37 PR604.1 PC603.1 220.55,95.38 v2(221.01,94.92)
  BOTTOM w0.254: PU600.7 219.54,95.01 219.72,95.19 220.74,95.19 v2(221.01,94.92)
+1.35V: length 97.8
  BOTTOM w0.203: UC1.AY35 109.38,104.89 109.38,103.34 v2(109.86,102.86) ; UC1.AY44 103.09,104.9 103.09,104.17 103.32,103.94 v2(103.56,103.94) ; UC1.AR48 101.36,108.05 v2(101.03,107.73) ; v2(106.69,103.7) 106.27,104.12 106.27,104.93 UC1.AY40
  BOTTOM w0.229: v2(100.39,104.39) 99.98,104.8 UC1.AY50
  BOTTOM w0.254: v2(103.89,108.38) 104.06,108.38 UC1.AP43 ; UC1.AJ37 v2(107.9,112.52) ; v2(114.41,112.52) 114.82,112.52 UC1.AH26 ; UC1.AJ31 v2(111.81,112.52) ; UC1.AN33 110.22,109.02 v2(110.1,109.02) ; UC1.AJ33 v2(110.51,112.52)
  BOTTOM w0.356: JDIMM1.75 66.4,74.53 66.66,74.79 v2(67.39,74.79) 68.04,74.79 68.2,74.63 JDIMM1.81 ; JDIMM1.111 77.2,75.66 v2(76.74,76.13) v2(76.29,75.68) ; JDIMM2.117 157.55,74.62 157.26,74.92 v2(156.94,74.92) 156.83,74.81 156.05,74.81 155.75,74.51 JDIMM2.111 ; v2(158.62,74.86) 158.97,74.86 159.35,74.47 JDIMM2.123 ; JDIMM2.124 159.65,66.55 159.28,66.92 v2(158.62,66.92) 158.28,66.92 157.85,66.5 JDIMM2.118 ; v2(77.59,66.9) 77.5,66.81 JDIMM1.112 ; JDIMM1.105 75.4,74.79 v2(75.47,74.86) ; JDIMM2.76 145.25,66.29 145.24,66.3 145.24,66.89 v2(145.27,66.92) ; JDIMM1.88 70.3,66.86 v2(70.27,66.9) ; JDIMM2.112 156.05,66.28 v2(155.53,66.81) 154.67,66.81 154.25,66.39 JDIMM2.106 ; JDIMM2.88 148.85,66.69 v2(149.08,66.92) 148.9,67.11 147.54,67.11 147.05,66.62 JDIMM2.82 ; JDIMM1.82 68.5,66.9 68.1,67.3 v2(66.89,67.3) 66.77,67.3 66.45,66.98 66.45,66.97 66.37,66.89 66.37,66.45 66.45,66.37 66.7,66.12 JDIMM1.76 ; v2(151.16,66.73) 150.65,66.22 JDIMM2.94 ; JDIMM1.106 75.7,66.3 75.41,66.59 v2(73.61,66.59) 73.9,66.3 JDIMM1.100 ; JDIMM1.117 79,74.71 79.54,75.25 v2(80.42,75.25) 80.8,74.87 JDIMM1.123 ; JDIMM2.75 144.95,74.57 v2(145.27,74.89) 145.28,74.89 146.23,74.89 146.75,74.37 JDIMM2.81 ; JDIMM1.99 73.6,74.51 74.51,75.43 75.72,75.43 v2(75.91,75.24) ; JDIMM2.99 152.15,74.49 152.64,74.98 v2(152.94,74.98) 153.52,74.98 153.95,74.56 JDIMM2.105 ; JDIMM1.118 79.3,66.24 79.64,66.58 v2(80.38,66.58) 80.76,66.58 81.1,66.24 JDIMM1.124 ; JDIMM2.93 150.35,74.64 v2(150.08,74.91) 148.89,74.91 148.55,74.57 JDIMM2.87 ; v2(153.62,67.3) 153.59,67.34 153.19,67.34 152.45,66.6 JDIMM2.100 ; JDIMM1.94 72.1,66.72 v2(71.92,66.9) ; JDIMM1.93 71.8,74.6 v2(71.53,74.87) 70.34,74.87 70,74.53 JDIMM1.87
  BOTTOM w0.508: RC15.1 94.59,92.05 94.96,91.68 v2(95.41,91.68) 96.67,91.68 96.99,92 RC16.1 97.33,92.45 RC14.1
  vias: v2(65.15,71.45) v2(65.15,69.93) v2(66.45,63.47) v2(66.45,61.95) v2(66.45,60.42) v2(66.75,71.45) v2(66.75,69.93) v2(66.75,68.41) v2(67.97,63.47) v2(67.97,61.95) v2(67.97,60.42) v2(70.27,69.95) v2(70.27,68.42) v2(70.95,63.47) v2(70.95,61.95) v2(70.95,60.42) v2(71.92,69.95) v2(71.92,68.42) v2(73.56,63.47) v2(73.56,61.95) v2(73.56,60.42) v2(73.77,71.47) v2(73.77,69.95) v2(73.77,68.42) v2(75.12,71.85) v2(75.12,69.57) v2(75.2,63.85) v2(75.2,61.57) v2(75.78,62.71) v2(76.23,70.71) v2(77.59,69.95) v2(77.59,68.42) v2(77.63,63.47) v2(77.63,61.95) v2(77.63,60.42) v2(78.98,69.95) v2(78.98,68.42) v2(79.66,63.47) v2(79.66,61.95) v2(79.66,60.42) v2(80.51,71.47) v2(80.51,69.95) v2(80.51,68.42) v2(98.83,100) v2(101.69,100.06) v2(103.58,101.65) v2(105.31,101.61) v2(105.3,100.99) v2(108.22,100.61) v2(108.22,99.97) v2(110.01,99.56) v2(143.32,68.45) v2(143.32,66.92) v2(144.84,69.97) v2(144.84,68.45) v2(145.78,63.51) v2(145.78,61.99) v2(145.78,60.46) v2(146.58,69.97) v2(146.58,68.45) v2(147.43,63.51) v2(147.43,61.99) v2(147.43,60.46) v2(149.08,71.49) v2(149.08,69.97) v2(149.08,68.45) v2(149.08,63.51) v2(149.08,61.99) v2(149.08,60.46) v2(150.62,63.51) v2(150.62,61.99) v2(151.16,71.49) v2(151.16,69.97) v2(151.16,68.45) v2(152.72,62.75) v2(153.37,70.35) v2(153.37,68.06) v2(153.75,63.89) v2(153.75,61.6) v2(154.48,69.2) v2(154.65,81.9) v2(155.04,81.46) v2(155.48,81.02) v2(155.92,80.57) v2(155.87,69.97) v2(155.87,68.45) v2(156.04,63.51) v2(156.04,61.99) v2(157.43,69.97) v2(157.43,68.45) v2(157.56,63.51) v2(157.55,61.27) v2(157.55,59.75) v2(158.96,69.97) v2(158.96,68.45) v3(145.45,31.62) v3(146.09,31.62) v3(146.72,31.62) v3(147.41,31.61) v3(148.05,31.61) v3(148.75,31.62) v3(149.39,31.62) v3(150.09,31.62) v3(150.72,31.62) v4(83.32,97.32)
+1.35V_MEM_GFX: length 358.8
  TOP w0.305: UV7.G11 v2(207.56,133.12) ; v2(205.96,135.52) 206.36,135.92 UV7.K12 ; v2(212.36,132.32) 211.96,131.92 UV7.E5 ; UV5.G4 170.31,152.44 170.33,152.44 v2(170.69,152.07) ; UV7.P3 v2(213.16,139.52) ; UV9.L14 v2(204,116.32) ; UV7.P12 v2(206.76,139.52) ; UV3.D13 v2(193.59,145.59) ; UV3.L14 v2(187.6,143.83) ; UV7.E10 207.96,131.92 v2(208.36,132.32) ; v2(187.19,147.19) 187.59,146.79 UV3.L11 ; UV9.L4 212.64,116.25 212.64,116.25 v2(212.97,115.92) 213.37,115.52 UV9.K3 ; UV9.L13 205.37,116.45 205.96,117.04 206.09,117.04 UV9.M12 v2(205.77,117.52) ; UV9.M14 203.97,117.12 v2(203.97,117.12) ; UV3.P12 185.19,145.99 v2(184.79,146.39) ; v2(212.17,111.92) 211.77,111.52 UV9.E5 ; UV5.L1 167.08,154.92 v2(167.44,155.27) ; v2(164.28,148.06) 163.89,147.66 UV5.R10 ; v2(204.11,133.52) 204.11,133.52 UV7.G14 ; UV5.F12 171.11,146.06 v2(171.52,145.65) ; UV3.R10 184.4,147.59 184.8,147.99 v2(184.79,147.99) ; UV7.G4 212.74,133.49 212.74,133.48 v2(212.38,133.12) ; UV3.N10 v2(186.39,147.99) ; v2(205.77,115.12) 206.17,115.52 UV9.K12 ; UV3.B14 194.8,144.39 194.8,144.39 v2(194.8,143.75) ; UV9.M1 215.02,117.08 v2(215.55,117.08) ; v2(207.56,137.12) 207.16,136.72 UV7.L11 ; v2(213.96,137.92) 213.56,137.52 UV7.M3 ; v2(204.01,118.72) UV9.P14 ; v2(186.79,143.79) 186.8,143.79 UV3.M14 ; UV5.P11 v2(164.28,147.26) ; UV7.B14 204.76,129.52 204.75,129.51 v2(204.12,129.51) ; UV3.G1 190.5,155.09 v2(190.5,155.41) ; UV9.F12 206.17,112.29 v2(205.76,111.88) ; UV3.C5 194,151.6 v2(194.39,151.99) ; UV3.G13 190.79,145.19 v2(190.4,145.58) 190,145.99 UV3.H12 ; UV5.D3 172.69,153.26 v2(173.08,152.86) ; UV7.B1 215.21,129.52 v2(215.56,129.17) ; UV5.T3 v2(163.48,152.86) ; v2(193.59,152.79) 193.2,153.19 UV3.D3 ; v2(195.14,155.19) 194.8,154.85 UV3.B1 ; UV3.K3 188.39,153.2 v2(188,152.8) 187.66,152.46 187.66,152.46 UV3.L4 ; v2(193.59,146.39) 193.2,146 UV3.D12 ; UV5.G14 170.29,143.81 v2(170.28,143.81) ; v2(190.79,143.74) 190.8,143.75 UV3.G14 ; v2(208.17,111.92) 207.77,111.52 UV9.E10 ; UV9.G11 v2(207.37,112.72) ; v2(203.92,113.13) 203.92,113.12 UV9.G14 ; UV5.C10 173.48,147.66 ; 173.48,147.66 v2(173.08,147.26) UV5.D11 ; 173.48,147.66 v2(173.08,148.06) ; UV3.E5 192.39,151.59 v2(191.99,151.99) ; v2(168.28,155.88) 168.37,155.88 168.81,155.44 168.81,154.99 UV5.J1 ; UV7.L1 215.23,136.72 v2(215.58,136.37) ; UV7.G1 215.54,133.52 215.62,133.59 v2(215.67,133.59) ; UV3.H3 190,153.25 v2(190.34,153.59) 190.75,154 UV3.G2 ; UV9.D13 UV9.D14 v2(204.01,110.72) ; v2(195.2,152.8) 195.19,152.8 UV3.B3 ; UV9.G13 205.37,113.13 v2(205.76,113.52) 206.16,113.92 UV9.H12 ; v2(171.48,148.06) 171.88,147.66 UV5.E10 ; v2(213.16,129.11) 213.16,129.12 UV7.B3 ; v2(174.63,155.26) 174.29,154.91 UV5.B1 ; UV7.D13 UV7.D14 v2(204.2,131.12) ; v2(169.99,155.48) 169.99,155.15 UV5.G1 ; v2(212.97,119.12) 212.97,119.12 UV9.P3 ; UV5.P1 v2(164.68,155.43) ; v2(192.03,145.58) 191.63,145.99 UV3.F12 ; UV7.D11 v2(207.56,130.72) UV7.C10 207.96,130.32 v2(208.36,130.72) ; UV5.K12 167.88,146.06 v2(168.28,145.66) ; UV7.B12 v2(206.76,129.12) ; UV7.M1 215.21,137.47 v2(215.74,137.47) ; UV3.L1 187.6,154.86 v2(187.95,155.21) ; UV5.B14 174.29,144.46 174.29,144.45 v2(174.29,143.82) ; UV9.M3 213.37,117.12 v2(213.77,117.52) ; UV9.T14 v2(203.97,120.32) ; v2(185.19,143.83) UV3.P14 ; v2(213.16,136.32) 212.83,136.65 212.83,136.65 UV7.L4 ; UV9.J1 v2(215.37,114.32) ; v2(215.59,113.41) 215.26,113.41 UV9.G1 ; UV7.G13 205.56,133.53 v2(205.95,133.92) 206.35,134.32 UV7.H12 ; UV3.T1 183.59,154.81 ; v2(215.37,108.77) 215.02,109.12 UV9.B1 ; UV3.M3 186.79,153.2 v2(186.39,153.59) ; UV3.T12 v2(183.19,145.59) ; UV9.P11 206.97,118.72 v2(207.37,119.12) ; UV9.T12 206.17,120.32 v2(205.77,120.72) ; v2(215.75,132.7) 215.18,132.7 UV7.F1 ; UV7.M14 204.16,137.52 v2(204.16,137.52) ; UV9.B3 212.97,108.72 v2(212.97,108.72) ; v2(213.16,130.72) 213.56,131.12 UV7.D3 ; v2(164.68,143.9) UV5.P14 ; UV3.T14 v2(183.59,143.79) ; UV9.L2 214.18,116.32 v2(214.55,115.95) ; UV7.P11 v2(207.56,139.52) ; UV7.F3 v2(213.96,132.32) ; UV7.P2 UV7.P1 v2(215.73,139.12) ; v2(211.24,117.98) 211.24,117.97 211.72,117.97 UV9.N5 ; v2(195.19,146.39) 194.8,146 UV3.B12 ; UV5.K3 168.24,153.61 168.24,153.61 v2(168.28,153.66) ; UV5.B3 174.68,152.86 v2(174.69,152.86) ; UV3.P1 185.19,155.37 v2(185.19,155.37) ; v2(215.56,134.72) 215.56,134.72 215.17,135.12 UV7.J1 ; v2(212.97,110.32) 213.37,110.72 UV9.D3 ; UV7.F14 v2(204.12,132.72) ; UV9.G4 212.55,113.1 212.55,113.08 v2(212.19,112.72) ; UV9.G2 214.17,113.17 v2(213.77,113.57) 213.42,113.92 UV9.H3 ; UV7.R5 v2(211.56,140.32) ; UV3.K12 v2(188.79,145.59) ; UV3.T3 v2(183.99,152.79) ; UV5.E5 171.88,151.66 v2(171.48,152.06) ; v2(185.94,151.07) 185.94,151.06 185.94,151.54 UV3.N5 ; UV3.G11 v2(191.19,147.19) ; UV7.K3 213.92,135.56 213.92,135.56 v2(213.96,135.52) ; UV3.M1 186.84,154.84 v2(186.84,155.37) ; UV5.G2 170.23,154.06 v2(169.83,153.66) 169.49,153.31 UV5.H3 ; UV5.T1 163.08,154.88 ; UV7.L2 214.37,136.72 v2(214.74,136.35) ; UV3.E10 192.39,147.59 v2(191.99,147.99) ; UV9.P2 UV9.P1 215.54,118.72 v2(215.54,118.72) ; v2(204.2,139.12) UV7.P14 ; UV9.C5 v2(212.17,109.52) ; v2(184.79,147.19) 185.19,146.79 UV3.P11 ; UV3.P3 185.19,153.2 v2(184.79,153.59) 185.19,153.99 UV3.P2 ; v2(207.37,116.72) 206.97,116.32 UV9.L11 ; UV7.T14 v2(204.24,140.72) ; UV3.F1 191.62,154.82 v2(191.62,155.38) ; v2(167.45,154.44) 167.08,154.07 UV5.L2 ; v2(171.11,155.44) 171.11,154.88 UV5.F1 ; UV7.F12 206.36,132.69 v2(205.95,132.28) ; UV5.G13 170.28,145.26 v2(169.89,145.65) 169.49,146.05 UV5.H12 ; UV5.L14 v2(167.08,143.89) ; UV7.T12 v2(205.96,141.12) ; UV5.D12 v2(173.08,146.46) ; v2(172.69,143.9) UV5.D14 UV5.D13 ; v2(193.2,143.83) UV3.D14 ; UV7.N5 211.91,138.37 211.43,138.37 v2(211.43,138.37) ; v2(208.17,119.12) 208.17,119.12 UV9.R10 ; v2(215.81,131.06) 215.75,131.12 UV7.D1 ; v2(205.96,137.92) 206.36,137.52 UV7.M12 206.28,137.43 206.15,137.43 205.56,136.84 UV7.L13 ; UV5.N10 v2(165.88,148.06) ; UV3.F3 v2(191.99,153.59) ; UV5.F3 v2(171.48,153.66) ; UV5.P12 v2(164.28,146.46) ; UV9.D12 v2(206.57,110.32) ; UV3.R5 v2(183.99,151.19) ; UV7.T1 215.18,140.72 ; UV5.R5 v2(163.48,151.26) ; UV3.L13 187.47,145.19 186.88,145.79 186.88,145.91 UV3.M12 186.79,145.99 v2(186.39,145.59) ; v2(165.43,151.13) 165.43,151.12 165.43,151.61 UV5.N5 ; UV9.F1 214.99,112.3 v2(215.56,112.3) ; v2(172.74,155.5) 172.69,155.44 UV5.D1 ; v2(165.88,153.66) 166.28,153.26 UV5.M3 ; UV3.J1 v2(189.59,155.19) ; UV9.R5 v2(211.37,119.92) ; UV3.D11 193.2,146.8 v2(193.59,147.19) UV3.C10 193.99,147.59 v2(193.59,147.99) ; UV7.G2 214.36,133.57 v2(213.96,133.97) 213.61,134.32 UV7.H3 ; UV5.L11 v2(166.68,147.26) ; UV7.N10 v2(208.36,137.92) ; UV5.T12 v2(162.68,145.66) ; UV5.M14 v2(166.28,143.86) ; UV9.F14 v2(203.93,112.32) ; UV9.D1 215.56,110.72 v2(215.61,110.66) ; UV7.T3 v2(213.16,141.12) ; v2(165.88,145.66) UV5.M12 166.37,145.98 166.37,145.85 166.96,145.26 UV5.L13 ; UV9.F3 v2(213.77,111.92) ; UV5.P3 164.68,153.26 v2(164.28,153.66) UV5.P2 ; UV7.C5 v2(212.36,129.92) ; UV5.G11 v2(170.68,147.26) ; UV9.P12 206.17,118.72 v2(206.57,119.12) ; UV9.B12 v2(206.57,108.72) ; v2(208.17,110.32) 207.77,109.92 UV9.C10 v2(207.37,110.32) UV9.D11 ; UV9.T1 214.99,120.32 ; v2(191.2,152.01) 190.84,152.37 190.82,152.37 UV3.G4 ; UV3.L2 187.6,154 v2(187.96,154.37) ; UV3.F14 v2(191.6,143.76) ; UV7.D12 v2(206.76,130.72) ; UV5.C5 v2(173.88,152.06) ; v2(208.36,139.52) 208.36,139.52 207.96,139.92 UV7.R10 ; UV9.T3 v2(212.97,120.72) ; UV5.T14 v2(163.08,143.86) ; UV5.L4 167.15,152.53 167.15,152.53 v2(167.49,152.86) ; v2(203.93,109.11) 204.56,109.11 UV9.B14 ; UV9.N10 v2(208.17,117.52) ; UV5.M1 166.33,154.9 v2(166.33,155.44) ; v2(215.39,115.97) 215.04,116.32 UV9.L1 ; UV3.D1 193.2,155.38 v2(193.25,155.44) ; UV5.B12 v2(174.68,146.46) ; UV7.L14 v2(204.19,136.72) ; UV5.F14 v2(171.09,143.82)
  TOP w0.375: 183.59,154.81 183.23,155.18 v2(183.16,155.18) ; 214.99,120.32 215.36,120.69 v2(215.36,120.75) ; v2(215.55,141.15) 215.55,141.09 215.18,140.72 ; 163.08,154.88 162.72,155.25 v2(162.65,155.25)
  TOP w0.508: v2(189.27,129.93) 189.49,129.72 190.47,129.72 190.85,129.34 RV47.1 ; v2(211.86,100.45) CV36.1 ; CV36.1 211.48,101.19 211.35,101.06 RV138.1 ; CV36.1 RV21.1 ; CV153.1 CV142.1 171.5,134.15 171.5,133.12 172.12,132.49 172.14,132.49 v2(172.47,132.16) 172.17,132.16 171.31,131.3 CV143.1 ; CV389.1 RV32.1 201.51,159.06 201.87,158.7 v2(201.87,156.3) ; RV193.1 CV350.1 190.27,140.13 v2(190.66,140.51) ; RV49.1 190.16,118.18 v2(189.95,118.39) ; RV48.1 187.47,117.67 v2(186.89,117.1) ; RV42.1 RV43.1 174.46,128.88 v2(174.93,128.41) ; RV19.1 CV34.1 200.31,116.82 v2(200.69,117.2) ; CV155.1 187.51,114.78 v2(187.69,114.6) ; CV28.1 200.33,130.57 200.33,131.47 RV12.1 200.55,131.93 v2(200.94,132.32) ; CV156.1 186.08,120.26 185.96,120.39 v2(185.96,121.36) 186.72,122.13 186.72,124.06 v2(186.88,124.22) ; v2(187.65,111.89) 187.65,111.89 188.3,111.24 CV154.1 ; RV10.1 204.63,146.61 v2(204.44,146.8) 204.18,146.8 203.74,146.36 CV26.1 ; v2(185.7,111.93) 186.19,111.44 CV144.1 ; CV139.1 218.53,124.38 CV4.1 CV5.1 217.74,125.59 216.88,124.73 v2(216.88,124.7) ; RV183.1 CV328.1 171.07,140.2 v2(171.43,139.83)
  IN2 w0.508: v2(163.99,131.5) 164.24,131.75 165.38,131.75 165.89,132.26 168.81,132.26 169.57,131.5 171.66,131.5 172.32,132.16 v2(172.47,132.16)
  BOTTOM w0.254: UV7.M12 206.28,137.43 206.08,137.43 205.62,136.98 205.62,136.78 UV7.L13 ; v2(176.05,131.81) 176.14,131.9 UV1.G23 ; UV3.L13 187.54,145.25 187.34,145.25 186.88,145.71 186.88,145.91 UV3.M12 ; UV1.L12 185.45,128.7 v2(184.94,128.2) ; UV9.M12 206.09,117.04 205.89,117.04 205.43,116.58 205.43,116.38 UV9.L13 ; UV5.M12 166.37,145.97 166.37,145.77 166.83,145.32 167.02,145.32 UV5.L13
  BOTTOM w0.305: v2(212.17,111.92) 211.77,111.52 UV9.E5 ; v2(168.28,145.66) 167.88,146.06 UV5.K12 ; UV1.AK8 UV1.AL9 188.05,112.3 v2(187.65,111.89) ; v2(204.2,131.12) UV7.D14 ; UV5.T1 163.08,154.88 162.72,155.25 v2(162.65,155.25) ; UV3.L1 187.6,154.86 v2(187.95,155.21) ; v2(186.79,143.79) 186.8,143.79 UV3.M14 ; UV3.T14 v2(183.59,143.79) ; v2(184.79,147.19) 185.19,146.79 UV3.P11 ; UV9.K3 213.37,115.52 v2(212.97,115.92) 212.64,116.25 212.64,116.25 UV9.L4 ; v2(173.08,148.06) 173.48,147.66 UV5.C10 ; UV5.N10 v2(165.88,148.06) ; UV3.C5 194,151.6 v2(194.39,151.99) ; v2(215.39,115.97) 215.04,116.32 UV9.L1 ; UV1.U11 186.46,123.8 v2(186.88,124.22) ; UV7.K3 213.92,135.56 213.92,135.56 v2(213.96,135.52) ; UV5.G14 170.29,143.81 v2(170.28,143.81) ; v2(186.84,155.37) 186.84,154.84 UV3.M1 ; v2(214.55,115.95) 214.51,115.99 214.5,115.99 UV9.L2 ; UV9.G4 212.55,113.1 212.55,113.08 v2(212.19,112.72) ; UV5.M1 166.33,154.9 v2(166.33,155.44) ; UV1.G20 179.19,131.9 v2(179.63,132.34) ; v2(186.85,132.39) 186.36,131.9 UV1.G11 ; UV5.B1 174.29,154.91 v2(174.63,155.26) ; v2(164.28,153.66) 164.68,153.26 UV5.P3 ; UV5.F3 v2(171.48,153.66) ; v2(215.61,110.66) 215.55,110.72 214.97,110.72 UV9.D1 UV10.P2 ; UV5.L1 167.08,154.92 v2(167.44,155.27) ; v2(191.99,147.99) 192.39,147.59 UV3.E10 ; UV7.M14 204.16,137.52 v2(204.16,137.52) ; UV5.C5 v2(173.88,152.06) ; v2(172.74,155.5) 172.68,155.44 172.68,154.86 UV5.D1 UV4.P2 ; v2(195.14,155.19) 194.8,154.85 UV3.B1 ; v2(207.37,119.12) 206.97,118.72 UV9.P11 ; UV5.D11 v2(173.08,147.26) ; UV7.P3 v2(213.16,139.52) ; 189.27,129.92 188.86,129.51 UV1.K8 ; 189.27,129.92 v2(189.27,129.93) ; 189.27,129.92 189.66,130.3 UV1.J7 ; UV1.J9 188.06,130.3 v2(187.66,130.7) 187.26,131.1 UV1.H10 ; v2(191.6,143.76) UV3.F14 ; UV5.R10 163.89,147.66 v2(164.28,148.06) ; v2(190.03,113.51) 190.03,113.73 UV1.AJ7 ; UV5.H12 169.49,146.05 v2(169.89,145.65) 170.28,145.26 UV5.G13 ; v2(171.09,143.82) UV5.F14 ; UV1.L7 189.26,128.9 v2(189.26,128.93) ; UV1.L16 182.37,128.7 v2(181.96,129.11) ; UV4.D13 UV5.P14 v2(164.68,143.9) ; UV7.R5 v2(211.56,140.32) ; UV9.N5 211.72,117.97 211.24,117.97 v2(211.24,117.98) ; UV1.L12 185.06,129.1 UV1.K13 UV1.K11 ; v2(211.43,138.37) 211.43,138.37 211.91,138.37 UV7.N5 ; UV7.G11 v2(207.56,133.12) ; UV9.M14 203.97,117.12 v2(203.97,117.12) ; UV9.B1 215.02,109.12 v2(215.37,108.77) ; UV1.R11 186.71,125.95 v2(186.71,126.19) ; UV7.M12 206.36,137.52 v2(205.96,137.92) ; UV6.P2 UV3.D1 193.19,154.8 193.19,155.38 v2(193.25,155.44) ; v2(213.77,117.52) 213.37,117.12 UV9.M3 ; UV1.G17 181.22,132.15 v2(180.88,132.15) ; v2(213.16,136.32) 212.83,136.65 212.83,136.65 UV7.L4 ; v2(184.79,147.99) 184.8,147.99 184.4,147.59 UV3.R10 ; v2(169.99,155.48) 169.99,155.15 UV5.G1 ; v2(193.59,152.79) 193.2,153.19 UV3.D3 ; UV1.G26 174.41,131.9 174.77,132.26 175.03,132.26 v2(175.04,132.25) ; v2(208.17,110.32) 207.77,109.92 UV9.C10 ; UV3.L4 187.66,152.46 187.66,152.46 v2(188,152.8) 188.39,153.2 UV3.K3 ; UV7.D3 213.56,131.12 v2(213.16,130.72) ; UV7.L11 207.16,136.72 v2(207.56,137.12) ; UV1.L21 178.53,128.7 v2(178.98,128.25) ; UV5.L14 v2(167.08,143.89) ; UV5.B14 174.29,144.46 174.29,144.45 v2(174.29,143.82) ; v2(215.75,132.7) 215.73,132.72 UV7.F1 ; UV3.P1 185.19,155.37 v2(185.19,155.37) ; UV5.M12 v2(165.88,145.66) ; UV7.N10 v2(208.36,137.92) ; v2(190.5,155.41) 190.5,155.09 UV3.G1 ; v2(208.17,119.12) 208.17,119.12 UV9.R10 ; v2(214.74,136.35) 214.7,136.39 214.69,136.39 UV7.L2 ; UV7.D12 v2(206.76,130.72) ; v2(204.12,129.51) 204.75,129.51 204.76,129.52 UV7.B14 ; UV7.E5 211.96,131.92 v2(212.36,132.32) ; UV7.H12 206.35,134.32 v2(205.95,133.92) 205.56,133.53 UV7.G13 ; v2(193.59,146.39) 193.2,146 UV3.D12 ; UV7.G2 214.36,133.57 v2(213.96,133.97) 213.61,134.32 UV7.H3 ; UV1.N11 186.72,126.95 v2(186.72,127.2) 186.72,127.45 UV1.M11 ; v2(212.97,119.12) 212.97,119.12 UV9.P3 ; v2(186.89,117.1) 186.89,117.27 UV1.AD11 ; UV9.G11 v2(207.37,112.72) ; v2(195.2,152.8) 195.19,152.8 UV3.B3 ; v2(167.49,152.86) 167.15,152.53 167.15,152.53 UV5.L4 ; v2(171.11,155.44) 171.09,155.42 UV5.F1 ; UV9.C5 v2(212.17,109.52) ; UV9.F12 206.17,112.29 v2(205.76,111.88) ; v2(212.38,133.12) 212.74,133.48 212.74,133.49 UV7.G4 ; v2(204.19,136.72) UV7.L14 ; UV7.P12 v2(206.76,139.52) ; UV9.L11 206.97,116.32 v2(207.37,116.72) ; v2(184.79,146.39) 185.19,145.99 UV3.P12 ; UV8.P2 UV7.D1 215.16,131.12 215.74,131.12 v2(215.81,131.06) ; UV8.D13 UV7.P14 v2(204.2,139.12) ; UV3.P3 185.19,153.2 v2(184.79,153.59) ; v2(176.85,128.2) 176.46,128.59 UV1.L23 ; UV7.P11 v2(207.56,139.52) ; UV7.T12 v2(205.96,141.12) ; UV7.F12 206.36,132.69 v2(205.95,132.28) ; UV1.L26 174.64,128.7 v2(174.93,128.41) ; UV1.P7 189.66,126.26 v2(189.35,126.57) ; UV7.K12 206.36,135.92 v2(205.96,135.52) ; v2(213.96,137.92) 213.56,137.52 UV7.M3 ; v2(185.94,151.07) 185.94,151.06 185.94,151.54 UV3.N5 ; UV3.B14 194.8,144.39 194.8,144.39 v2(194.8,143.75) ; UV3.L2 187.93,154.33 187.93,154.33 v2(187.96,154.37) ; v2(171.52,145.65) 171.11,146.06 UV5.F12 ; UV5.T3 v2(163.48,152.86) ; v2(165.88,153.66) 166.28,153.26 UV5.M3 ; v2(215.58,136.37) 215.23,136.72 UV7.L1 ; UV9.F3 v2(213.77,111.92) ; UV9.P1 215.54,118.72 v2(215.54,118.72) ; UV3.F3 v2(191.99,153.59) ; UV9.M1 215.02,117.08 v2(215.55,117.08) ; v2(173.08,152.86) 172.69,153.26 UV5.D3 ; UV3.K12 v2(188.79,145.59) ; v2(183.16,155.18) 183.23,155.18 183.59,154.81 UV3.T1 ; v2(189.95,118.39) 189.66,118.68 UV1.AC7 ; UV7.C10 207.96,130.32 v2(208.36,130.72) ; UV3.M12 186.79,145.99 v2(186.39,145.59) ; v2(204.12,132.72) UV7.F14 ; UV9.T1 214.99,120.32 215.36,120.69 v2(215.36,120.75) ; v2(172.69,143.9) UV5.D14 ; UV5.B12 v2(174.68,146.46) ; UV5.G4 170.31,152.44 170.33,152.44 v2(170.69,152.07) ; v2(172.47,132.16) 172.12,132.16 UV1.G29 ; UV3.B12 194.8,146 v2(195.19,146.39) ; v2(208.17,111.92) 207.77,111.52 UV9.E10 ; UV5.M14 v2(166.28,143.86) ; UV7.M1 215.21,137.47 v2(215.74,137.47) ; UV1.AG10 187.26,115.03 v2(187.69,114.6) ; UV7.P1 v2(215.73,139.12) ; v2(215.56,129.17) 215.21,129.52 UV7.B1 ; UV9.N10 v2(208.17,117.52) ; v2(204.11,133.52) 204.11,133.52 UV7.G14 ; v2(206.57,119.12) 206.17,118.72 UV9.P12 ; UV5.R5 v2(163.48,151.26) ; v2(212.97,110.32) 213.37,110.72 UV9.D3 ; v2(215.56,112.3) 215.54,112.32 UV9.F1 ; v2(190.79,143.74) 190.8,143.75 UV3.G14 ; UV5.E5 171.88,151.66 v2(171.48,152.06) ; UV7.T1 215.18,140.72 215.55,141.09 v2(215.55,141.15) ; UV9.K12 206.17,115.52 v2(205.77,115.12) ; UV9.M12 v2(205.77,117.52) ; UV9.H3 213.42,113.92 v2(213.77,113.57) 214.17,113.17 UV9.G2 ; UV5.K3 168.24,153.61 168.24,153.61 v2(168.28,153.66) ; UV9.G14 203.92,113.12 v2(203.92,113.13) ; UV1.Y7 189.66,120.9 v2(190,120.56) ; UV5.B3 174.68,152.86 v2(174.69,152.86) ; v2(167.45,154.44) 167.41,154.4 167.41,154.39 UV5.L2 ; v2(191.99,151.99) 192.39,151.59 UV3.E5 ; UV3.F12 191.63,145.99 v2(192.03,145.58) ; UV3.L14 v2(187.6,143.83) ; UV3.G13 190.79,145.19 v2(190.4,145.58) 190,145.99 UV3.H12 ; v2(208.36,132.32) 207.96,131.92 UV7.E10 ; UV3.C10 193.99,147.59 v2(193.59,147.99) ; UV9.H12 206.16,113.92 v2(205.76,113.52) 205.37,113.13 UV9.G13 ; v2(204.01,110.72) UV9.D14 ; UV3.T3 v2(183.99,152.79) ; v2(205.77,120.72) 206.17,120.32 UV9.T12 ; v2(208.36,139.52) 208.36,139.52 207.96,139.92 UV7.R10 ; UV6.D13 UV3.P14 v2(185.19,143.83) ; v2(171.48,148.06) 171.88,147.66 UV5.E10 ; UV3.D11 193.2,146.8 v2(193.59,147.19) ; UV1.Y11 186.12,121.36 v2(185.96,121.36) ; UV9.B14 204.56,109.11 v2(203.93,109.11) ; UV5.L11 v2(166.68,147.26) ; v2(213.16,129.11) 213.16,129.12 UV7.B3 ; UV9.G1 215.26,113.41 v2(215.59,113.41) ; v2(191.2,152.01) 190.84,152.37 190.82,152.37 UV3.G4 ; UV1.U7 189.66,123.88 v2(189.97,124.19) ; v2(212.97,108.72) 212.97,108.72 UV9.B3 ; UV9.D11 v2(207.37,110.32) ; UV9.R5 v2(211.37,119.92) ; UV5.D12 v2(173.08,146.46) ; UV9.B12 v2(206.57,108.72) ; UV5.P11 v2(164.28,147.26) ; UV5.P12 v2(164.28,146.46) ; UV3.H3 190,153.25 v2(190.34,153.59) 190.75,154 UV3.G2 ; UV7.T3 v2(213.16,141.12) ; UV7.B12 v2(206.76,129.12) ; v2(203.93,112.32) UV9.F14 ; v2(204.01,118.72) UV9.P14 UV10.D13 ; v2(186.39,153.59) 186.79,153.2 UV3.M3 ; v2(189.57,115.93) 189.61,115.97 189.61,116.45 UV1.AF7 ; UV5.N5 165.43,151.61 165.43,151.12 v2(165.43,151.13) ; v2(184.48,132.09) 184.29,131.9 UV1.G14 ; UV3.R5 v2(183.99,151.19) ; UV7.G1 215.54,133.52 215.62,133.59 v2(215.67,133.59) ; UV5.H3 169.49,153.31 v2(169.83,153.66) 170.23,154.06 UV5.G2 ; v2(191.62,155.38) 191.6,155.36 UV3.F1 ; UV7.F3 v2(213.96,132.32) ; UV5.G11 v2(170.68,147.26) ; UV3.G11 v2(191.19,147.19) ; UV9.D12 v2(206.57,110.32) ; UV9.T14 v2(203.97,120.32) ; UV7.D11 v2(207.56,130.72) ; UV3.N10 v2(186.39,147.99) ; UV3.L11 187.59,146.79 v2(187.19,147.19) ; v2(193.2,143.83) UV3.D14 ; UV5.T14 v2(163.08,143.86) ; UV7.T14 v2(204.24,140.72) ; UV5.T12 v2(162.68,145.66) ; UV3.T12 v2(183.19,145.59) ; UV9.T3 v2(212.97,120.72) ; UV7.C5 v2(212.36,129.92) ; UV9.L14 v2(204,116.32) ; UV5.P1 v2(164.68,155.43)
  BOTTOM w0.508: v2(171.43,139.83) 171.07,140.2 CV328.1 RV183.1 ; CV32.1 203.48,102.67 v2(203.99,102.16) 204.37,102.54 RV16.1 ; RV140.1 162.02,132.65 RV139.1 162.84,132.64 v2(163.99,131.5) ; 195.43,157.99 CV356.1 RV40.1 ; RV6.1 CV21.1 200.5,132.77 v2(200.94,132.32) ; v2(204.44,146.8) CV137.1 ; RV19.1 CV34.1 200.31,116.82 v2(200.69,117.2) ; v2(216.18,145.66) 218.34,145.66 218.6,145.4 RV1.1 CV18.1 ; v2(211.86,100.45) 211.73,100.59 CV30.1 RV14.1 ; RV193.1 CV350.1 190.27,140.13 v2(190.66,140.51) ; RV141.1 v2(196.95,103.5) ; v2(216.88,124.7) 217.05,124.87 CV296.1 CV295.1 ; RV142.1 v2(197.96,104.57)
  vias: v2(167.41,157.54) v2(167.41,156.96) v2(168.05,157.54) v2(168.05,156.96) v2(168.68,157.54) v2(168.68,156.96) v2(169.32,157.54) v2(169.32,156.96) v2(187.73,157.29) v2(187.73,156.71) v2(188.37,157.29) v2(188.37,156.71) v2(189,157.29) v2(189,156.71) v2(189.64,157.29) v2(189.64,156.71) v2(212.13,153.08) v2(212.13,152.45) v2(212.76,153.08) v2(212.76,152.45) v2(216.11,115.75) v2(216.11,115.11) v2(216.11,114.48) v2(216.11,113.84) v2(216.3,136.13) v2(216.3,135.5) v2(216.3,134.86) v2(216.3,134.23) v2(216.75,115.75) v2(216.75,115.11) v2(216.75,114.48) v2(216.75,113.84) v2(216.88,136.13) v2(216.88,135.5) v2(216.88,134.86) v2(216.88,134.23) v4(156.87,155.2)
