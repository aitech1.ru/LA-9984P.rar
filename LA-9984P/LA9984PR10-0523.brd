# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35VGPUP: length 13
  TOP w0.102: v2(183.48,167.82) v4(182.81,167.82)
  IN3 w0.254: v2(183.48,167.82) 189.51,167.82 189.89,168.2 v2(189.89,173.09)
  BOTTOM w0.254: PR1107.2 v2(189.89,173.09)
+1.35VP: length 25.7
  TOP w0.102: v3(160.31,29.53) v1(161.26,29.53)
  IN2 w0.203: v3(160.31,29.53) 159.86,29.53 159.1,28.77 146.4,28.77 v3(145.96,28.32)
  IN2 w0.762: 154.71,27.36 148.36,27.36
  BOTTOM w0.203: PU200.19 156.13,27.24 v2(155.99,27.37) ; PU200.5 159.31,28.78 159.8,29.28
  BOTTOM w0.254: PR207.2 160.55,29.77 v3(160.31,29.53) 160.06,29.53 159.8,29.28
  vias: v2(155.99,27.95) v3(146.97,27.12) v3(147.61,27.12) v3(147.92,29.39) v3(148.56,29.39) v3(149.19,29.39) v3(149.83,29.39) v3(150.46,29.39) v3(151.1,29.39)
+1.35VS_VGA: length 0.9
  TOP w0.102: v2(188.05,162.8) 188.05,163.29 v4(188.36,163.59)
  vias: v2(181.19,162.36) v2(181.51,162.87) v2(181.83,162.36) v2(182.15,162.87) v2(182.46,162.36) v2(182.78,162.87) v2(183.1,162.36) v2(183.42,162.87) v2(183.73,162.36) v2(184.05,162.87) v2(184.88,163.65) v2(184.88,163.04) v2(185.51,163.65) v2(185.51,163.04) v2(187.1,162.29) v2(187.42,162.8) v2(187.73,162.29) v2(215.61,152.83) v2(215.61,152.2) v2(216.25,152.83) v2(216.25,152.2)
+3V_WLAN:
  vias: v1(91.85,148.45) v2(91.8,150.93) v2(91.8,150.35) v2(91.8,149.76) v2(104.5,148.82) v2(105.09,148.82) v2(105.67,148.82) v2(116.19,151.49) v2(116.77,151.49) v2(117.35,151.49) v2(117.94,151.49)
+3VALW: length 635.6
  TOP w0.203: UE1.125 180.56,40.52 179.59,39.55 CE5.2 ; v2(198.47,38.91) 198.06,39.32 UE1.33 ; UE1.96 182.72,53.35 182.59,53.47 v2(182.59,53.98) ; UE1.22 191.59,35.79 CE2.1 ; 185.49,35.85 CE6.2 185.49,36.35 185.64,36.5 186.27,36.5 186.39,36.61 UE1.9 ; UG1.2 62.72,43.98 62.46,43.73 62.46,43.55
  TOP w0.508: v2(182.59,53.98) 182.59,54.49 181.96,55.12 181.96,56.83 176.95,61.83 176.95,72.14 174.6,74.49 174.6,81.77 v2(170.02,86.35) ; CE2.1 v2(190.86,35.75) ; 194.47,59.04 194.47,59.11 193.74,59.83 193.06,59.83 192.61,59.39 192.61,57.91 192.62,57.9 ; v2(177.75,44.5) 177.75,44.5 177.88,44.63 RE71.1 ; CE5.2 179.43,38.71 v2(179.59,38.55) 179.62,38.52 179.62,37.1 RE11.2 ; 62.46,43.55 62.46,43.03 62.53,42.97 CG10.1 62.28,42.36 61.94,42.01 v2(61.85,42.01) ; 185.49,35.85 186.43,35.85 v2(186.53,35.75) ; v2(135.23,187.06) 134.21,187.06 133.63,187.63 PR3.2 ; PR28.1 128.38,167.96 127.85,167.44 v2(127.41,167.44) ; CE58.2 35,96.8 34.99,96.79
  TOP w1.524: 46.19,82.68 45.72,82.68 40.12,77.08 40.08,77.08 36.82,73.82 36.82,53.32 45.62,44.52 45.62,34.93 ; 204.75,53.01 200.56,53.01 198.78,54.79 198.78,56.63
  IN2 w0.457: v2(173.19,175.26) 171.67,173.74 171.67,164.28
  IN2 w0.508: v2(182.59,53.98) 182.02,53.41 182.02,53.02 178.28,49.28 178.28,47.77 178.59,47.46 178.59,46 177.75,45.16 v2(177.75,44.5) 177.75,44.34 174.27,40.86 v2(174.27,39.17) ; v2(201.32,152.95) 195.92,158.36 177.59,158.36 171.67,164.28
  IN2 w1.016: 211.86,91.43 211.86,86.68 219.8,78.74 219.8,63.09 212.1,55.39 210.88,55.39 208.56,53.07
  IN2 w2.032: 206.72,50.6 206.72,45.26 205.13,43.68 205.13,39.56 202.53,36.96 200.83,36.96 197.45,33.58 197.45,32.83 195.86,31.24 194.78,31.24 192.56,29.02 192.56,24.01 192.88,23.69 192.88,23.36 195.04,21.2 195.04,10.04
  IN3 w0.508: v3(186.91,179.2) 186.72,179.01 186.08,179.01 184.56,180.53 182.02,180.53 179.8,182.76 v2(177.32,182.76) 175.92,184.15 154.83,184.15 150.51,188.47 141.95,188.47 140.54,187.06 v2(135.23,187.06) ; v2(198.47,38.91) 196.41,36.86 196.41,36.21 195.98,35.78 194.24,35.78 193.51,36.5 192.1,36.5 191.35,35.75 v2(190.86,35.75) v2(186.53,35.75) 184.95,37.33 183.42,37.33 182.2,38.55 v2(179.59,38.55) 178.02,38.55 177.26,37.79 175.49,37.79 174.27,39 v2(174.27,39.17) ; v2(61.85,42.01) 61.61,42.26 61.18,42.26 60.27,43.17 53.77,43.17 46.08,35.47 v2(46.08,33.98) ; v2(144.49,160.33) 144.49,161.41 144.11,161.79 129.5,161.79 128.98,162.3 128.98,163.89 127.41,165.46 v2(127.41,167.44) ; v2(182.59,53.98) 182.77,53.8 188.46,53.8 189.07,54.41 189.07,56.63 190.28,57.84 191.87,57.84 192.81,56.9 194.8,56.9 v2(196.24,58.35) ; v2(212.17,92.44) 212.17,93.6 211.55,94.22 211.55,96.25 210.72,97.08 210.72,100.32 211.99,101.59 211.99,102.9 217.37,108.28 217.37,121.91 216.25,123.04 216.25,126.41 217.49,127.65 217.49,141.75 214.7,144.53 204.54,144.53 203.73,145.34 203.73,150.56 201.33,152.95 v2(201.32,152.95)
  BOTTOM w0.254: PU1200.7 187.5,179.48 187.23,179.2 v3(186.91,179.2) 186.59,179.2 185.96,178.56 PC1205.1
  BOTTOM w0.457: v2(173.19,175.26) 173.64,175.71 173.64,175.76 176.32,178.44 176.32,181.14 176.23,181.23 176.23,181.76 177.22,182.76 v2(177.32,182.76)
  BOTTOM w0.508: RV109.1 171.85,94.6 170.7,93.45 170.7,87.03 v2(170.02,86.35) ; PR16.2 135.72,187.06 v2(135.23,187.06) 134.97,186.79 134.97,179.31 132.43,176.77 127.92,176.77 127.41,176.26 v2(127.41,167.44)
  BOTTOM w1.524: 103.67,13.06 102.19,14.54 102.19,19.76 98.01,23.94 93.69,23.94 89.31,19.56 60.35,19.56 56.92,22.99 56.92,25.02 48.67,33.28 47.65,33.28
  vias: v2(45.49,33.34) v2(46.08,33.34) v2(46.19,84.06) v2(46.72,84.32) v2(195.29,59.23) v2(195.74,58.79) v2(206.47,53.33) v2(206.47,52.69) v2(207.1,53.33) v2(207.1,52.69) v2(211.48,92.44) v3(105.5,13.13) v3(105.5,12.5) v3(106.14,13.13) v3(106.14,12.5) v3(106.77,12.5) v3(138.84,14.54) v3(138.84,13.91) v3(139.47,14.54) v3(139.47,13.91) v3(140.11,14.54) v3(140.11,13.91) v3(197.32,10.92) v3(197.32,10.04) v3(197.32,9.15) v3(197.96,10.92) v3(197.96,10.04) v3(197.96,9.15) v3(199.04,13.02) v3(199.04,12.13) v3(199.04,10.92) v3(199.04,10.04) v3(199.04,9.15) v3(199.67,13.02) v3(199.67,12.13) v3(199.67,10.92) v3(199.67,10.04) v3(199.67,9.15) v4(34.29,96.38) v4(139.87,20.65) v4(194.97,10.35)
+3VALW_PCH: length 251.2
  TOP w0.254: C75.2 117.62,113.9 117.92,113.59 118.78,113.59 v2(119.61,114.42)
  TOP w0.508: v2(151.29,102.03) 151.29,105.92 150.97,106.24 R264.1 ; RC127.1 122.65,93.6 123.26,92.98 v2(157.08,92.98) ; C81.1 125.07,111.76 v2(125.11,111.72) ; C78.1 122.45,115.75 v2(122.24,115.96)
  TOP w1.016: 122.2,52.25 122.2,42.85 125.63,39.42 136.05,39.42 140.36,35.1 140.36,31.55
  IN1 w0.381: v2(119.61,114.42) 120.7,114.42 v2(122.24,115.96)
  IN2 w0.508: v2(119.61,114.42) 119.93,114.42 120.35,114.01 120.35,112.16 120.93,111.58 120.93,111.57 ; 121.06,110.94 121.06,105.36 122.52,103.89 122.52,98.1 112.73,88.31 65.51,88.31 v2(64.54,89.27)
  BOTTOM w0.254: UC1.AC9 UC1.AA9 125.23,116.01 124.51,116.01 ; UC1.AE21 119,114.05 UC1.AE20 119.2,114.05 119.57,114.42 v2(119.61,114.42) ; UC1.AH10 124.85,111.88 124.95,111.88 v2(125.11,111.72)
  BOTTOM w0.381: 124.51,116.01 124.46,115.96 v2(122.24,115.96) ; v2(145.49,116.25) 145.79,116.54 QH1.2 ; QH1.5 148.64,116.54 v2(148.85,116.75)
  BOTTOM w0.508: 138.78,110.54 138.52,110.54 136.74,108.76 136.74,108.68 v2(135.98,107.92) 135.92,107.86 135.92,106.3 R2330.1 ; v2(64.54,89.27) 64.03,89.78 RC64.2
  BOTTOM w1.016: 154.91,95.63 150.4,95.63 145.57,90.81 126.01,90.81 116.53,81.33 116.53,65.03 122.52,59.04 122.52,54.28
  vias: v2(121.95,53.33) v2(122.58,53.33) v2(131.95,112.85) v2(132.54,112.85) v2(141.76,115.89) v2(142.14,116.33) v2(146.71,113.91) v2(147.3,113.91) v2(147.54,107.05) v2(148.17,107.05) v2(150.61,115.81) v2(150.61,115.23) v2(156.23,95.76) v2(156.81,95.76) v4(154.32,98.21)
+3VALW_PCH_GATE: length 7.2
  TOP w0.203: U2304.3 v2(141.55,24.88)
  BOTTOM w0.102: R416.2 v1(140.35,30.08)
  BOTTOM w0.508: R416.2 140.35,28.27 C2314.1 140.81,27.56 140.36,27.12 140.36,26.07 v2(141.55,24.88)
+3VALWP: length 7.8
  TOP w0.508: v2(202.45,18.23) PC102.1 PR109.1
  IN3 w0.254: v2(202.45,18.23) 202.9,18.23 203.1,18.02 203.1,14.1 v2(201.96,12.96)
  vias: v1(209.2,5.87)
+3VGS: length 242.5
  TOP w0.381: QV15.5 QV15.2 177.89,97.39 v2(178.21,97.71)
  TOP w0.508: v2(183.48,96.82) 183.03,96.37 RV199.1 ; v2(179.92,94.72) RV90.1 ; QV28.2 184.13,96.77 v2(184.15,96.79) ; RV91.1 173.25,94.55 172.77,95.03 v2(172.77,95.47) ; v2(190.86,104.91) 189.64,103.69 v2(189.64,99.17) 189,98.53 186.53,98.53
  IN1 w0.508: v2(163.03,110.97) 163.03,111.99 163.53,112.5 163.53,115.05 165.57,117.09 165.57,118.01 166.94,119.37 167.29,119.37 167.62,119.7 167.62,120.87 166.3,122.19 162.81,122.19 158.46,126.54 156.08,126.54 155.29,127.33 155.29,129.21 156.68,130.61 156.68,135.24 160.09,138.65 160.09,152.73 157.13,155.69 v2(157.13,156.72)
  IN3 w0.508: v2(175.03,116.19) 174.66,116.19 174.34,116.5 170.71,116.5 169.83,115.62 169.06,115.62 168.43,114.98 166.78,114.98 166.08,114.28 166.08,113.75 165.44,113.11 164.75,113.11 164.34,112.7 164.34,111.34 163.97,110.97 v2(163.03,110.97) ; v2(177,116.25) 177,115.42 178.81,113.62 178.81,112.46 179.29,111.97 179.29,109.84 179.03,109.58 179.03,106.54 179.39,106.19 v2(179.39,104.95) ; v2(214.66,62.47) 217.09,62.47 218.17,63.55 218.17,74.86 215.8,77.23 215.8,85.22 213.71,87.32 213.71,90.33 212.23,91.81 210.99,91.81 210.1,92.7 201.39,92.7 196.31,97.78 196.31,101.65 194.77,103.19 191.78,103.19 190.86,104.11 v2(190.86,104.91)
  BOTTOM w0.381: v2(178.21,97.71) 178.55,97.37 UV14.1 ; UV13.5 161.27,111.1 161.59,110.78 CV326.2
  BOTTOM w0.508: RV235.1 175.92,103.13 v2(176.6,102.46) ; RV96.2 175.49,97.44 v2(175.99,96.95) 175.64,96.6 RV98.2 173.45,96.58 172.77,95.9 v2(172.77,95.47) ; v2(190.86,104.91) RV73.1 ; PR839.1 PR837.1 PR835.1 PR826.1 PR828.1 213.97,62.47 v2(214.66,62.47) ; RV74.1 189.97,99.5 v2(189.64,99.17) ; v2(163.03,110.97) 162.84,110.78 CV326.2 ; PR1213.1 172.85,184.38 172.05,183.58 172.05,166.44 176.3,162.18 176.3,160.72 176.11,160.53 175.57,160.53 RV105.1 174.35,160.5 173.7,161.15 161.56,161.15 v2(157.13,156.72) ; CV85.2 179.86,94.79 v2(179.92,94.72) ; v2(181.13,94.85) 180.94,95.04 CV102.1 ; v2(184.15,96.79) QV22.1
  vias: v2(183.45,98) v2(184.09,98) v2(184.72,98) v2(185.36,98) v2(185.99,98) v4(179.89,101.31)
+3VLP: length 252.9
  TOP w0.203: v2(180.14,46.45) 180.39,46.45 180.72,46.12 UE1.111 ; v2(204.76,20.23) 204.77,20.22 PU100.3 ; 61.8,47.07 62.09,47.07 62.32,46.85 UG1.15
  TOP w0.508: v2(167.99,45.78) 167.99,37.09 169.32,35.75 177.65,35.75 180.92,32.49 190.56,32.49 v4(191.72,31.33) 193.46,29.58 RE49.2 ; PC109.1 v2(204.76,20.23) ; 61.8,47.07 61.42,47.07 61.27,46.92 CG4.1 v2(60.35,46.05)
  IN1 w0.508: v2(115.22,14.16) 117.25,12.13 166.27,12.13 v2(172.62,18.48) 182.78,18.48 184.94,16.32 195.67,16.32 196.37,15.62 202.47,15.62 204.76,17.91 v2(204.76,20.23)
  IN2 w0.508: v2(115.22,14.16) 113.2,14.16 111.73,12.69 108.74,12.69 76.91,44.52 61.89,44.52 v2(60.35,46.05) ; v2(172.62,18.48) 172.69,18.54 172.69,32.56 167.99,37.26 v2(167.99,45.78)
  IN3 w0.508: v2(180.14,46.45) 179.45,46.45 178.16,45.15 168.61,45.15 v2(167.99,45.78)
+3VS: length 418.1
  TOP w0.203: CA58.1 43.91,22.58 43.32,22.58 43.29,22.62 UA1.1 ; v2(35.4,22.47) 35.55,22.62 UA1.36 ; CA60.1 43.69,25.82 UA1.9
  TOP w0.254: CR1.1 177.63,20.77 177.13,21.26 177.13,22.15 177.32,22.34 UR1.4
  TOP w0.381: v2(15.84,111.75) QX4.5 ; v2(16.09,109.4) 15.84,109.15 QX4.2 ; CD63.1 55.96,19.61 55.61,19.96 UD1.5
  TOP w0.406: UC3.5 148.44,105.57 v2(148.81,105.21) 149.3,105.21 CC11.1
  TOP w0.508: v2(218.16,168.73) CX9.1 218.41,169.55 219.42,170.56 220.43,170.56 220.75,170.88 UX1.4 ; PR1110.1 v2(189.21,172.52) ; v2(39.26,17.35) 39.26,17.53 38.51,18.28 38.51,18.58 38.18,18.91 37.94,18.91 RA9.1 ; RE10.1 RE9.1 v2(187.04,57.65) ; CA60.1 44.4,27.53 CA59.1 44.2,27.61 v2(43.81,28.01) ; v2(52.99,41.21) 52.99,26.53 48.87,22.42 47.03,22.42 v2(46.76,22.15) 46.64,22.02 46.64,20.37 46.41,20.14 44.71,20.14 44.35,20.5 CA57.1 44.35,22.14 CA58.1 ; v2(125.95,94.87) 125.43,94.35 RC128.1 ; v2(55.95,16.14) 55.17,16.92 QD19.2 55.17,17.76 55.1,17.83 RD47.1 CD63.1 ; C71.1 121.9,120.4 122.19,120.69 v2(122.48,120.69) ; JTP.1 58.3,111.55 58.07,111.32 v2(57.12,111.32) ; RA1.1 v2(43.78,32.45) ; RS7.1 218.76,54.8 v2(218.44,55.12) ; RE68.2 v2(34.76,117.92)
  TOP w1.524: 180.5,73.2 179.07,73.2 177.54,74.74 177.54,84.79 183.73,90.98 184.37,90.98 ; 55.27,39.8 55.27,26.41 50.32,21.45 50.32,19.24
  IN1 w0.508: v2(35.4,22.47) 36.53,22.47 37.37,23.31 40.39,23.31 40.86,23.78 42.04,23.78 42.95,22.86 46.32,22.86 46.76,22.42 v2(46.76,22.15) ; v2(51.45,17.38) 52.68,16.14 v2(55.95,16.14) ; v2(122.48,120.69) 122.75,120.69 123.06,120.38 123.06,118.53 123.39,118.2 124.03,118.2 v2(124.16,118.32)
  IN1 w1.524: 228.31,40.39 227.68,39.75 215.42,39.75 ; 211.17,40.01 211.17,39.5 206.72,35.05 199.86,35.05 195.84,31.03 192.92,31.03 188.94,27.05 188.94,26.1 183.73,20.89 180.75,20.89
  IN2 w0.508: v2(189.21,172.52) 189.64,172.09 194.26,172.09 195.89,170.46 197.43,170.46 199.44,168.44 200.96,168.44 v2(201.74,167.66)
  IN2 w1.524: 109.57,55.11 109.57,70.28 107.79,72.06 105.25,72.06 105.25,72.06
  IN2 w2.032: 219.08,143.48 218.81,143.21 218.81,113.11 217.64,111.94 217.64,107.94 212.69,102.99 212.69,101.84
  IN3 w0.508: v2(15.84,111.75) 15.84,109.65 v2(16.09,109.4) ; v2(46.76,22.15) 46.76,24.77 43.81,27.73 v2(43.81,28.01) 43.78,28.03 v2(43.78,32.45) ; v2(92.1,141.4) 91.79,141.4 91.34,140.96 91.34,139.63 91.62,139.35 v2(92.23,139.35)
  BOTTOM w0.203: PU501.21 92.11,139.23 v2(92.23,139.35) 92.03,139.55 91.86,139.55 91.79,139.63 PU501.20
  BOTTOM w0.254: UC1.U8 125.61,118.38 125.25,118.74 UC1.T9 124.62,118.85 124.16,118.39 v2(124.16,118.32) ; UC4.14 70.6,108.99 70.27,109.33 CC13.1 ; v2(122.48,120.69) 122.44,120.74 UC1.K14 UC1.K16 ; 145.39,111.35 145.32,111.42 144.48,111.42 144.36,111.31 RC107.2 ; UC1.Y8 125.87,116.65 v2(125.87,116.95) UC1.W9 125.25,117.01 125.66,117.42 UC1.V8
  BOTTOM w0.356: JDIMM2.199 182.15,71.95 v2(182.59,71.51)
  BOTTOM w0.432: QC1.2 v2(145.39,110.9) QC1.5
  BOTTOM w0.508: v2(39.26,17.35) 40,16.61 42.43,16.61 46.76,20.94 v2(46.76,22.15) ; v2(142.84,120.47) 142.84,119.94 142.55,119.64 R2335.1 R2334.1 ; RA7.1 16.68,27.98 17.12,28.42 17.73,28.42 18.24,28.93 19.61,28.93 20.3,28.25 RA2.1 22.5,29.2 22.75,29.45 27.64,29.45 31.33,33.14 33.96,33.14 34.78,33.96 42.27,33.96 v2(43.78,32.45) ; U2302.8 168.05,92.9 C2327.1 168.06,94.8 158.59,104.27 v2(158.59,104.91) ; v2(148.56,112.66) 148.5,112.66 147.93,112.09 R2332.1 147.93,111.91 R2331.1 ; RL33.1 43.4,89.21 v2(43.65,89.46) ; PR308.1 v2(149.77,153.02) ; RC362.1 v2(60.06,105.31) ; RE50.1 52.05,107.24 v2(52.3,107) ; v2(136.49,115.56) 136.5,115.57 RC121.1 ; v2(131.73,136.97) 131.57,136.82 RC75.1 ; v2(114.72,56.44) 114.72,82.12 125.95,93.36 v2(125.95,94.87) 125.45,95.37 RC3.1 ; v2(209.77,55.55) 209.91,55.69 PR808.1 PR842.2
  vias: v2(27.71,116.65) v2(28.1,116.14) v2(28.41,116.65) v2(55.01,41.85) v2(55.01,41.26) v2(55.59,41.85) v2(55.59,41.26) v2(68.15,110) v2(68.54,110.43) v2(83.94,139.17) v2(83.94,138.58) v2(84.67,138.61) v2(99.1,152.25) v2(99.74,152.25) v2(100.37,152.25) v2(103.47,71.86) v2(104.04,72.06) v2(104.04,71.47) v2(108.93,53.42) v2(109.52,53.42) v2(110.1,53.42) v2(120.41,151.69) v2(120.41,151.11) v2(121,151.69) v2(121,151.11) v2(130.78,133.88) v2(131.36,133.88) v2(131.94,133.88) v2(137.44,124.19) v2(138.01,124.19) v2(138.65,124.19) v2(139.54,116.65) v2(140.17,116.65) v2(177.38,57.65) v2(177.38,57.06) v2(177.38,56.44) v2(178.21,21.39) v2(178.79,21.39) v2(179.38,21.39) v2(182.59,70.88) v2(182.59,70.24) v2(184.1,93.33) v2(184.37,92.76) v2(184.69,93.33) v2(198.02,18.85) v2(198.02,18.27) v2(198.02,17.68) v2(198.02,17.1) v2(198.02,16.51) v2(198.61,18.85) v2(198.61,18.27) v2(198.61,17.68) v2(198.61,17.1) v2(198.61,16.51) v2(199.19,17.1) v2(199.19,16.51) v2(201.92,164.86) v2(202.53,164.86) v2(203.11,164.86) v2(211.41,98.95) v2(211.41,98.36) v2(211.84,41.21) v2(211.99,98.95) v2(211.99,98.36) v2(212.42,41.21) v2(213,41.21) v2(220.68,145.62) v2(220.68,145.04) v2(221.26,145.62) v2(221.26,145.04) v2(225.09,177.36) v2(225.09,176.77) v2(225.67,177.36) v2(225.67,176.77) v4(131.82,128.62)
+3VS_CAM: length 3.8
  TOP w0.102: v4(228.36,175.11) 227.65,175.82 RX27.2
  TOP w0.508: RX27.2 227.1,176.2 226.55,176.75 v2(226.51,176.75)
  BOTTOM w0.254: v2(226.51,176.75) JLVDS.29
+3VS_RT: length 19.9
  TOP w0.432: QX6.2 195.79,164.28 195.46,164.61 195.46,165.18 195.94,165.66 v2(196.71,165.66) ; v2(193.45,160.52) v1(193.45,163.29) 193.45,163.91 193.82,164.28 QX6.5
  TOP w0.508: v2(208.12,162.61) 207.48,163.25 LX7.2 ; v2(197.07,178.06) v2(197.07,176.65) 196.75,176.33 v2(196.75,175.02) 196.69,174.96 RX30.1
  BOTTOM w0.381: UX2.5 213.44,163.25 CX10.1
  BOTTOM w0.508: RX169.1 197.32,176.39 v2(197.07,176.65) ; v2(197.07,178.06) 197.51,178.06 198.54,179.09 RX168.1 ; v2(213.31,162.42) 213.57,162.68 CX10.1
  vias: v2(200.1,167.62) v2(200.69,167.59)
+5V_HDD:
  vias: v1(225.21,54.84)
+5V_PVDD: length 12.8
  TOP w0.203: UA1.46 40.74,20.81 v4(41.25,20.3) 42.26,19.29 CA54.1 ; v2(38.82,20.97) 38.74,21.05 UA1.41
  IN3 w0.508: v2(43.53,16.14) 43.4,16.27 43.4,19.05 41.49,20.97 v2(38.82,20.97)
+5V_USB_PWR1:
  vias: v2(24.67,69.47) v2(24.67,68.84) v2(24.67,68.2) v2(24.67,67.57) v4(25.96,71.34)
+5V_USB_PWR2:
  vias: v2(26.3,55.63) v2(26.3,54.99) v2(26.94,55.63) v2(26.94,54.99) v4(28.03,56.56)
+5V_USB_PWR3: length 1.1
  TOP w0.102: v2(14.19,33.33) v4(13.06,33.33)
  vias: v2(14.19,32.74) v2(14.77,33.33) v2(14.77,32.74)
+5V_USB_PWR4: length 2
  TOP w0.102: JDB.1 209.89,38.93 209.55,38.6 209.55,38.46 v4(209.08,37.99)
  vias: v2(208.82,40.2) v2(208.82,39.56) v2(209.45,40.2) v2(209.45,39.56)
+5VA: length 7.2
  TOP w0.102: v4(30.47,28.91) 30.82,28.56 RV59.2
  TOP w0.203: CA51.1 34.55,28.49 35.47,27.56 35.47,27 35.86,26.62 UA1.26
  TOP w0.508: RV59.2 CA71.1 33.25,28.49 CA51.1
+5VALW: length 379.8
  TOP w0.254: PU1100.7 183.93,174.8 PC1105.1 183.67,175.25 184.43,176.01 184.43,177.04 v2(185.26,177.87)
  TOP w0.508: PR8.1 135.61,188.08 140.43,188.08 141.44,189.09 151.17,189.09 156.31,183.96 160.41,183.96 161.35,183.01 v2(162.65,183.01) ; LED3.1 v2(38.53,12.7) ; LED1.2 v2(19.65,11.94) ; v2(50.46,16.08) 50.63,15.92 RD46.1 ; LED4.2 v2(47.63,12.7) ; R2347.1 v4(83.94,32.97) 83.94,27.03 v2(84.99,25.97) 86.07,25.97 86.83,26.73 R10.1 ; v2(216.04,56.72) 216.04,58.63 v4(215.44,59.23) 212.06,62.61 209.32,62.61 208.22,61.51 203.32,61.51 202.15,62.68 PR824.1 201.53,62.73 200.32,62.73 200.02,62.42 200.02,61.94 v2(200.12,61.84)
  IN1 w0.508: v2(19.65,11.94) 37.77,11.94 v2(38.53,12.7)
  IN1 w2.032: 197.7,26.99 197.7,28.39 202.47,33.15 207.51,33.15 208.63,34.26 208.63,34.27 210.75,36.39 212.18,36.39 213.13,37.34 215.36,37.34
  IN2 w0.508: v2(217.64,41.15) 215.61,43.18 215.61,56.29 v2(216.04,56.72) 221.45,62.13 221.45,79.43 219.88,81 219.88,89.79 223.23,93.14 223.23,125.32 223.75,125.83 224.38,126.47 224.38,147.65 208.82,163.22 208.82,166.25 205.92,169.14 199.69,169.14 197.25,171.57 196.34,171.57 191.39,176.53 189.63,176.53 189.18,176.07 186.42,176.07 185.26,177.23 v2(185.26,177.87)
  IN3 w0.508: v2(200.12,61.84) 200.12,65.97 198.72,67.36 193.56,67.36 192.02,68.9 192.02,81.35 188.43,84.94 v2(188.43,93.21) ; v2(162.65,183.01) 163.16,183.52 175.48,183.52 176.88,182.12 179.42,182.12 182.17,179.36 182.17,179.26 182.53,178.91 183.2,178.91 184.07,178.04 184.75,178.04 184.92,177.87 v2(185.26,177.87)
  BOTTOM w0.203: PU200.12 158.91,24.81 159.31,24.41 v3(159.31,24.21) 159.31,24.12 159.67,23.75 PC204.2
  BOTTOM w0.508: PR814.2 205.5,65.14 204.94,64.58 203.17,64.58 202.67,65.08 200.93,65.08 200.12,64.26 v2(200.12,61.84) PR822.2 ; v2(188.43,93.21) 189.26,94.03 RV107.1 ; PR206.1 v2(162.09,24.25)
  vias: v2(21.75,31.8) v2(21.75,31.22) v2(22.33,31.8) v2(22.33,31.22) v2(27.33,62.3) v2(27.33,61.66) v2(27.97,62.3) v2(27.97,61.66) v2(29.35,49.15) v2(29.35,48.52) v2(29.99,49.15) v2(29.99,48.52) v2(160.87,24.84) v2(160.87,24.25) v2(161.45,24.84) v2(161.45,24.25) v2(216.36,38.56) v2(216.94,38.56) v2(217.53,38.56) v2(218.11,38.56) v3(194.28,25.72) v3(194.28,24.83) v3(194.28,23.94) v3(194.91,25.72) v3(194.91,24.83) v3(194.91,23.94) v3(195.61,25.72) v3(195.61,24.83) v3(195.61,23.94) v3(196.24,25.72) v3(196.24,24.83) v3(196.24,23.94) v4(192.38,26.01)
+5VALWP: length 20.7
  TOP w0.203: PU100.14 209.64,20.62 210.06,21.05 v3(210.36,21.05)
  TOP w0.508: PR104.2 202.44,21.34 v3(202.41,21.38)
  IN2 w0.254: v3(202.41,21.38) 202.43,21.4 202.72,21.4 203.23,21.91 203.23,26.16 v2(202.66,26.74)
  IN2 w0.508: v2(202.66,27.43) 202.91,27.43 203.8,26.55 203.8,25.09 207.61,21.28 207.93,21.28 208.25,20.96 209.82,20.96 209.91,21.05 v3(210.36,21.05)
  BOTTOM w0.508: v3(202.41,21.38) PC108.2
  vias: v1(209.93,33.48)
+5VS: length 253.9
  TOP w0.508: v2(32.08,97.98) 32.48,98.38 CE58.1 ; v2(22.95,107.56) 14.51,107.56 14.02,108.04 RX17.2
  IN1 w1.016: 43.72,12.89 43.7,12.88 39.62,12.88 38.77,13.72 32.23,13.72 31.4,12.89 30.83,12.89
  IN2 w0.508: v2(44.8,105.59) 47.78,105.59 52.61,100.76 52.61,97.28 54.51,95.38 70.89,95.38 73.93,98.41 84.8,98.41 91.79,105.4 91.79,125.97 88.93,128.83 88.93,133.22 v2(88.92,133.22)
  IN2 w2.54: 198.78,27.12 198.78,28.9 205.67,35.78 211.19,35.78 211.8,36.39 224.84,36.39
  IN3 w0.508: v2(111.01,141.72) 110.8,141.72 110.37,142.15 110.37,145.11 108.17,147.31 94.47,147.31 91.66,144.5 91.66,142.42 90.71,141.47 90.71,135.01 v2(88.92,133.22)
  IN3 w1.016: 52.23,37.79 52.23,20.39 45.53,13.69
  IN3 w2.54: 198.78,27.12 198.78,28.9 205.67,35.78 211.19,35.78 211.8,36.39 224.84,36.39
  BOTTOM w0.203: PU502.2 111.4,142.04 111.08,141.72 v2(111.01,141.72)
  BOTTOM w0.508: RE60.1 227.63,158.41 227.27,158.77 v2(221.52,158.77) ; v2(88.92,133.22) 88.87,133.17 86.53,133.17 86.07,133.63 86.07,134.99 85.06,136.01 83.79,136.01 82.9,136.9 PC503.1
  vias: v2(16.73,112.26) v2(17.36,112.26) v2(22.89,112.76) v2(22.89,112.13) v2(26.89,104.08) v2(26.89,103.44) v2(29.29,12.83) v2(29.87,12.83) v2(31.78,44.07) v2(32.22,43.63) v2(44.16,105.59) v2(44.59,12.88) v2(45.18,12.88) v2(52.23,39.44) v2(52.23,38.85) v2(198.09,22.6) v2(198.09,22.01) v2(198.09,21.43) v2(198.09,20.84) v2(198.09,20.26) v2(198.67,22.01) v2(198.67,21.43) v2(198.67,20.84) v2(220.18,121.87) v2(220.18,121.29) v2(220.18,120.7) v2(220.18,120.12) v2(220.18,119.53) v2(226,47.84) v2(226,47.26) v2(226,46.67) v2(226,46.09) v2(226,45.51) v2(226,44.92) v2(226,44.34) v2(226,43.75) v2(226.91,37.33) v2(226.91,36.74) v2(226.91,36.16) v2(226.91,35.58) v2(227.5,37.33) v2(227.5,36.74) v2(227.5,36.16) v2(227.5,35.58) v4(35.7,103.72)
+5VS_KBL:
  vias: v4(38.12,109.69)
+5VS_ODD: length 0.8
  TOP w0.102: v4(225.52,112.59) 225.99,112.12 v2(225.99,111.97)
+AVCC33: length 9.4
  TOP w0.203: v2(200.12,173.03) 200.15,172.99 UX4.5
  BOTTOM w0.102: v1(197.4,171.06) 197.65,170.8 197.65,169.97 197.89,169.73 CX35.1
  BOTTOM w0.508: LX8.1 198.33,168.8 CX35.1 198.33,170.64 199.3,171.62 CX33.1 CX31.1 199.56,172.67 199.91,173.03 v2(200.12,173.03)
+AVDD: length 8.2
  TOP w0.102: LV12.1 162.06,114.65 161.64,115.07 v1(161.64,115.39)
  TOP w0.508: v2(167.09,117.42) 167.06,117.42 166.73,117.09 166.73,116.45 166.35,116.07 CV75.1 CV76.1 164.95,116.07 164.11,115.23 CV77.1 163.15,114.65 LV12.1
  BOTTOM w0.203: UV1.AD34 167.58,117.9 v2(167.09,117.42)
+DVCC33: length 8.8
  TOP w0.203: 206.15,167.88 206.15,168.4 205.72,168.83 UX4.22 ; 203.8,167.88 204.11,168.19 204.11,168.51 204.12,168.51 UX4.18
  TOP w0.254: 194.28,166.97 194.28,166.74 194.42,166.6 RP57.8 ; 194.28,166.97 194.41,167.1 RP57.7 ; 194.28,166.97 194.28,168.32 194.54,168.58 196.29,168.58 196.64,168.24 v2(196.76,168.24)
  vias: v1(197.87,175.9) v2(198.02,175.08) v2(198.62,175.1) v2(204.69,167.31) v2(207.04,165.6)
+V18R: length 5.8
  TOP w0.102: CE16.1 178.87,41.26 178.53,41.26 178.08,41.71 176.52,41.71 v1(176.28,41.47)
  TOP w0.203: UE1.124 180.05,40.92
  TOP w0.508: 180.05,40.92 179.97,40.83 CE16.1
+VCC_3IN1: length 25.8
  TOP w0.254: UR1.5 177.82,22.08 v2(177.7,21.96)
  TOP w0.508: CR8.1 188.9,31.02 188.32,30.43 v2(188.32,29.85) v1(186.8,29.85) v2(182.27,29.85) 182.26,29.86 CR7.1
  BOTTOM w0.508: v2(182.27,29.85) 182.35,29.77 JREAD.11 182.35,23.26 181.19,22.1 177.84,22.1 v2(177.7,21.96) ; v2(188.32,29.85) 188.32,27.74 189.19,26.87 JREAD.4
+VCC_PWR_SRC: length 30.4
  TOP w0.508: v2(116.61,144.4) 115.51,145.51 115.51,146.83 114.88,147.46 109.77,147.46 v2(109.35,147.04)
  IN2 w0.508: v2(109.35,147.04) 108.84,147.55 106.83,147.55 106.58,147.3 100.35,147.3 100.05,147.01 96.21,147.01 95.91,147.3 92.43,147.3 91.66,146.52 v2(91.66,145.4)
  BOTTOM w0.508: v2(91.66,145.4) PR508.1
  vias: v1(124.62,149.3) v2(117.25,144.4)
+VCCHDA: length 27.4
  TOP w0.508: RC129.2 v2(120.81,118.51) ; v2(121.8,112.41) 121.8,112.4 121.05,111.65 C77.1 121.05,105.55 121.89,104.71 121.89,99.32 122.46,98.75 v1(122.46,97.48) 122.46,95.46 RC127.2 RC128.2
  IN3 w0.508: v2(121.8,112.41) 121.8,112.61 121.31,113.1 120.74,113.1 120.31,113.53 120.31,118.01 v2(120.81,118.51)
  BOTTOM w0.254: v2(121.8,112.41) 122.11,112.1 UC1.AH14
+VCCIO_OUT: length 4.2
  TOP w0.508: v2(89.82,132.77) v4(89.82,132.06)
  BOTTOM w0.432: v2(89.82,132.77) 89.93,132.88 92.47,132.88 92.93,133.34 R245.2
+VCCIO_OUT_R: length 5.2
  BOTTOM w0.254: UC1.A59 94.38,128.02 92.75,129.65 92.75,131.57 R245.1
+VCCIOA_OUT: length 28.8
  TOP w0.102: v2(135.45,131.82) 135.08,132.18 v1(135.08,132.53)
  TOP w0.508: v2(118.67,125.3) 118.41,125.3 117.75,125.96 RC71.1
  IN1 w0.508: v2(135.45,131.82) 135.22,131.59 131.79,131.59 131.37,132.01 128.88,132.01 127.45,130.57 125.89,130.57 124.51,131.94 v2(122.8,131.94)
  IN2 w0.508: v2(122.8,131.94) 121.94,131.94 119.57,129.58 118.09,129.58 117.58,129.07 117.58,127.33 118.67,126.24 v2(118.67,125.3)
  BOTTOM w0.254: v2(118.67,125.3) 118.76,125.3 UC1.E20
  BOTTOM w0.508: v2(135.45,131.82) 135.45,131.32 135.12,130.99 RC78.1
+VCCRTCEXT: length 4.1
  TOP w0.089: v1(123.8,113.21) 124.11,113.21 124.68,113.78 C52.1
  TOP w0.254: v2(126.58,113.15) 126.58,113.21 126.16,113.63 125.68,113.63 125.66,113.65 124.98,113.65 C52.1
  BOTTOM w0.254: v2(126.58,113.15) 126.58,113.37 UC1.AE7
+VDD1DI: length 6.8
  TOP w0.508: v2(168.2,118.21) 167.57,118.21 v1(167.39,118.03) 166.32,118.03 CV79.1 CV78.1 164.82,117.85 164.62,117.65 CV80.1 163.08,117.65 LV13.1
  BOTTOM w0.254: UV1.AC33 168.2,118.64 v2(168.2,118.21)
+VDD_MEM15_REFDA: length 25.1
  TOP w0.102: v2(160.87,136.89) v1(160.16,136.89)
  IN3 w0.508: v2(160.87,136.89) 162.4,135.37 162.4,134.47 163.92,132.94 163.92,132.53 164.46,131.99 164.99,131.99 167.26,129.72 169.95,129.72 171.24,128.44 173.32,128.44
  BOTTOM w0.254: v2(180.92,129.19) 180.46,128.73 UV1.L18
  BOTTOM w0.508: CV220.1 RV146.1 RV139.2 160.74,132.64 160.3,133.08 160.3,136.57 160.63,136.89 v2(160.87,136.89)
+VDD_MEM15_REFDB: length 5.3
  BOTTOM w0.102: v1(197.95,103.62) 197.09,104.48 RV148.1
  BOTTOM w0.381: UV1.Y12 185.46,121.86 v2(185.08,122.24)
  BOTTOM w0.508: CV223.1 196.2,104.47 RV141.2 ; CV223.1 v2(195.43,105.28) ; CV223.1 RV148.1
+VDD_MEM15_REFSA: length 27.4
  TOP w0.102: v2(163.03,136.64) 163.03,136.77 v1(162.61,137.19)
  IN3 w0.508: v2(179.67,129.27) 179.11,129.27 178.65,128.8 176.53,128.8 176.3,128.58 175.61,128.58 175.01,129.17 171.71,129.17 168.56,132.32 166.46,132.32 165.32,133.46 164.3,133.46 163.03,134.73 v2(163.03,136.64)
  BOTTOM w0.254: v2(179.67,129.27) 179.46,129.06 UV1.L20
  BOTTOM w0.508: RV140.2 RV147.1 CV221.1 161.11,136.05 161.7,136.64 v2(163.03,136.64)
+VDD_MEM15_REFSB: length 24.1
  TOP w0.102: v2(185.01,121.2) 185.01,121.2 v1(185.54,121.72)
  IN3 w0.508: v2(196.12,108.64) 195.19,109.57 193.18,109.57 191.84,110.91 191.84,114.23 191.01,115.05 190.11,115.05 189.82,115.34 189.37,115.34 189.32,115.4 188.75,115.4 188.71,115.43 188.08,115.43 187.48,116.04 187.48,117.34 187.05,117.77 186.45,117.77 186.08,118.13 186.08,120.12 v2(185.01,121.2)
  BOTTOM w0.381: UV1.AA12 185.46,120.74 v2(185.01,121.2)
  BOTTOM w0.508: v2(196.12,108.64) 196.18,108.57 CV224.1 RV149.1 RV142.2
+VDDC_CT: length 30.1
  TOP w0.508: v2(173.99,115.21) 174.27,115.48 174.27,116.5 173.99,116.79 CV173.1 CV174.1
  IN3 w0.508: v2(176,100.31) 175.96,100.35 175.96,103.68 176.48,104.2 176.48,107.41 175.05,108.85 174.91,108.85 174.3,109.46 174.3,112.32 173.3,113.32 173.3,114.61 173.89,115.21 v2(173.99,115.21)
  BOTTOM w0.254: UV1.AF27 UV1.AF26 UV1.AG26 174.46,115.68 v2(173.99,115.21)
  BOTTOM w0.279: UV1.AG27 173.5,115.7 v2(173.99,115.21)
  BOTTOM w0.508: v2(176,100.31) 175.24,99.56 v1(175.1,99.56) 174.69,99.56 173.87,98.74 CV171.1 CV172.1 CV170.1 LV19.2
+VDDCI: length 27.3
  TOP w0.508: CV209.1 184.92,126.15 184.92,125.26 v2(184.88,125.22) ; CV204.1 184.25,124.54 v2(183.92,124.22) 183.51,123.81 CV208.1 ; CV324.1 177.12,127.44 v2(176.88,127.2) ; v2(183.83,119.19) 183.99,119.35 CV322.1 ; v2(182.88,127.17) 182.6,127.45 CV211.1 CV206.1 ; v2(181.96,127.13) 181.53,127.56 CV212.1
  BOTTOM w0.381: UV1.AD16 UV1.AC15 183.46,118.82 v2(183.83,119.19) 184.34,119.7 UV1.AB13 ; UV1.Y13 UV1.AA13 184.3,120.54 184.3,119.86 UV1.AB13 ; UV1.N13 UV1.N15 183.4,126.7 v2(182.9,126.2) 182.46,125.76 UV1.R16 ; UV1.N13 UV1.M15 ; UV1.N13 UV1.R12 185.47,125.7 v2(185.98,126.22) ; v2(185.01,118.24) 184.47,117.7 UV1.AD13 ; UV1.M18 UV1.N17 181.53,126.7 v2(181.96,127.13) ; UV1.M16 182.46,127.59 v2(182.88,127.17) ; v2(182.85,122.17) 183.38,122.7 UV1.V15 ; UV1.N22 177.46,126.78 177.04,127.2 v2(176.88,127.2) 176.46,127.62 UV1.M23 ; UV1.N20 179.42,126.7 v2(178.91,127.2) ; UV1.T15 183.47,124.7 183.92,124.24 v2(183.92,124.22) ; UV1.AB13 184.98,119.18 185.05,119.18 v2(185.06,119.18)
  BOTTOM w0.508: UV1.AC12 185.46,118.69 v2(185.01,118.24)
  vias: v1(179.7,111.18) v2(182.97,117.2) v3(193.45,181.82) v3(193.45,181.19) v3(193.45,180.55) v3(194.08,181.82) v3(194.08,181.19) v3(194.08,180.55) v3(194.72,181.82) v3(194.72,181.19) v3(194.72,180.55) v3(195.35,181.82) v3(195.35,181.19) v3(195.35,180.55)
+VDDCIP: length 33.8
  IN2 w0.254: v2(178.78,181.49) 179.54,182.25 183.92,182.25 186.85,185.17 186.85,190.19 187.35,190.69 196.37,190.69 197,190.06 197,184.98 196.31,184.28 v3(194.53,184.28)
  BOTTOM w0.508: PR1208.1 v2(178.78,181.49)
  vias: v3(193.89,189.11) v3(193.89,188.47) v3(193.89,187.45) v3(193.89,186.82) v3(193.89,185.8) v3(193.89,185.17) v3(195.61,189.3) v3(196.24,189.3) v4(196.52,186.22)
+VDDR4: length 17.8
  IN1 w0.508: v2(183.54,106.03) 184.3,106.79 184.3,108.31 183.86,108.76 183.86,113.77 184.14,114.05 184.14,115.32 v2(185,116.19)
  IN3 w0.508: v2(183.54,106.03) 184.11,105.46 184.11,101.43 v2(184.81,100.73)
  BOTTOM w0.508: LV20.2 185.01,100.93 v2(184.81,100.73)
  vias: v1(185.44,115.85) v2(184.94,117.2) v2(186.02,116.19)
GND: length 3272.1
  TOP w0.203: v2(63.01,47.32) 63.12,47.21 UG1.13 ; UE1.24 192.39,38.78 v2(192.14,39.03) ; UE1.35 196.05,40.12 v2(195.98,40.18) ; v2(202.91,173.22) 202.28,172.59 UX4.6 ; UA1.4 43.06,23.82 v2(43.21,23.67) ; v2(63.79,43.55) 63.79,43.72 63.52,44 UG1.4 ; U2304.11 v2(141.95,28.44) ; v2(184.16,52.11) 183.99,52.29 UE1.94 ; UG1.7 64.72,43.99 v2(65.07,43.63) ; UX4.16 203.32,168.59 v2(203.26,168.53) ; UE1.11 187.19,38.83 187.06,38.96 v2(187.06,39.1) ; v2(180.24,45.62) 180.24,45.62 180.55,45.32 UE1.113 ; U2301.11 v2(193.51,19.88)
  TOP w0.254: v2(208.36,134.69) 207.96,135.09 UV7.J10 ; UV9.J10 207.8,114.72 208.17,115.09 v2(208.17,115.1) ; UV3.J10 189.2,147.63 188.83,147.99 v2(188.82,147.99) ; v2(177.61,106.99) 177.12,107.48 RP47.4 ; RP45.7 73.42,113.91 v2(73.17,114.16) 73.42,114.41 RP45.6 ; v2(169.11,148.06) 168.71,147.66 UV5.J10
  TOP w0.305: v2(215.62,109.83) 215.53,109.92 UV9.C1 ; UV7.T5 v2(211.56,141.12) ; v2(171.49,146.44) 171.86,146.06 171.88,146.06 UV5.E12 ; UV9.U3 213.37,121.12 v2(213.37,121.64) ; UV5.N14 v2(165.48,143.86) ; v2(203.99,108.29) 204.02,108.32 UV9.A14 ; UV7.H13 205.55,134.32 v2(205.15,133.92) ; UV5.L5 166.98,151.55 166.98,150.93 v2(167.05,150.85) ; v2(167.89,143.87) 167.88,143.88 UV5.K14 167.84,144.5 167.84,145.21 UV5.K13 ; v2(171.92,155.5) 171.92,154.89 UV5.E1 ; UV9.H1 214.97,113.92 v2(214.57,113.52) ; UV7.A14 204.21,128.72 v2(204.18,128.69) ; UV3.G5 190.8,151.51 v2(191.17,151.14) 191.6,151.56 UV3.F5 ; UV3.U3 v2(182.27,153.19) ; UV9.M5 211.82,117.17 211.84,117.17 v2(212.18,117.51) ; v2(195.23,145.59) 195.23,145.63 195.59,146 UV3.A12 ; UV3.T10 183.6,147.59 v2(183.99,147.99) ; v2(208.36,140.32) 207.96,140.72 UV7.T10 ; v2(213.77,110.32) 213.37,109.92 UV9.C3 v2(213.77,109.52) ; UV7.L5 211.85,136.82 211.23,136.82 v2(211.16,136.75) ; UV5.F10 171.09,147.64 v2(171.47,147.25) ; v2(215.04,121.64) 215.04,121.19 UV9.U1 ; v2(192,146.37) 192.37,146 192.39,146 UV3.E12 ; UV3.E14 v2(192.4,143.77) ; UV7.E14 v2(204.13,131.92) ; UV7.B10 207.96,129.52 v2(208.36,129.92) ; v2(168.28,155.26) 167.89,154.86 UV5.K1 167.88,154.86 v2(168.28,154.46) 167.89,154.06 UV5.K2 ; UV3.B10 194.79,147.59 v2(194.39,147.99) ; UV3.C13 UV3.C14 v2(194,143.77) ; UV9.H13 205.37,113.9 v2(204.96,113.49) 204.57,113.88 UV9.H14 ; UV3.N3 v2(186.39,152.79) ; UV7.R14 204.19,139.92 v2(204.18,139.92) ; UV5.A1 175.52,154.86 175.61,154.77 v2(175.6,154.77) ; v2(206.55,111.92) 206.17,111.54 UV9.E12 ; v2(213.15,132.3) 213.54,131.92 UV7.E3 ; UV3.H13 190.01,145.19 v2(190.42,144.78) 190.03,144.39 UV3.H14 ; v2(211.4,108.72) 211.77,109.09 UV9.B5 ; UV5.R12 v2(163.48,146.46) ; UV5.N1 v2(165.48,155.43) ; UV5.F5 171.09,151.63 v2(170.66,151.2) 170.29,151.58 UV5.G5 ; UV3.T5 183.6,151.59 v2(183.99,151.99) UV3.R4 184.4,152.39 v2(184.79,152.79) UV3.R3 ; v2(206.57,120.72) 206.17,121.12 UV9.U12 ; UV5.T10 v2(163.48,148.06) ; UV7.R11 v2(207.56,140.32) ; UV7.R1 v2(215.73,139.92) ; v2(211.43,137.57) 211.91,137.57 UV7.M5 ; v2(213.33,142.04) 213.56,141.8 UV7.U3 ; UV5.A3 175.09,153.26 v2(175.48,152.86) ; UV3.C4 194,152.4 v2(194.39,152.79) ; v2(213.77,115.12) 214.17,115.52 UV9.K2 v2(214.57,115.12) 214.97,115.52 UV9.K1 v2(215.37,115.12) ; v2(171.5,152.85) 171.89,153.24 UV5.E3 ; UV9.A12 v2(206.57,107.92) ; UV9.R14 203.99,119.52 v2(203.99,119.52) ; v2(191.98,147.18) 191.6,147.57 UV3.F10 ; v2(166.23,151.13) 166.23,151.61 UV5.M5 ; v2(208.17,109.52) 207.77,109.12 UV9.B10 ; v2(207.56,137.92) 207.96,137.52 UV7.M10 208.36,137.12 207.96,136.72 UV7.L10 208,136.72 v2(208.36,136.36) ; v2(204.18,135.91) 204.18,135.92 UV7.K14 204.8,135.96 205.52,135.96 UV7.K13 ; v2(212.12,116.69) 211.77,116.34 UV9.L5 ; UV5.R11 v2(163.48,147.26) ; UV9.A1 214.97,107.89 214.88,107.79 v2(214.88,107.8) ; v2(215.73,138.32) 215.73,138.32 UV7.N1 ; v2(185.99,155.37) 186,155.37 UV3.N1 ; UV9.G5 211.69,113.12 v2(211.31,112.75) 211.74,112.32 UV9.F5 ; UV9.P10 v2(208.17,118.32) ; UV7.A1 215.16,128.28 215.07,128.19 v2(215.07,128.2) ; UV7.N14 v2(204.16,138.32) ; v2(205.96,129.08) 206.33,128.72 UV7.A12 ; UV5.B10 174.28,147.66 v2(173.88,148.06) ; UV5.R1 v2(163.88,155.43) ; UV9.R1 215.54,119.52 v2(215.54,119.52) ; UV7.R12 v2(206.76,140.32) ; v2(192.43,155.44) 192.43,154.83 UV3.E1 ; UV9.R3 v2(212.97,119.92) ; UV9.G10 v2(208.17,112.72) ; UV7.U14 204.24,141.52 v2(204.24,141.54) ; v2(169.89,144.85) 169.49,145.25 UV5.H13 ; v2(208.36,138.72) 207.96,139.12 UV7.P10 ; UV3.P10 v2(185.59,147.99) ; UV5.B5 174.32,151.66 v2(174.69,151.29) ; v2(213.96,129.92) UV7.C3 213.56,130.32 v2(213.96,130.72) ; UV9.R12 206.17,119.52 v2(206.57,119.92) ; UV7.R3 v2(213.16,140.32) ; v2(165.88,147.26) UV5.M10 166.68,148.06 UV5.L10 167.08,147.7 v2(167.45,148.06) ; v2(182.27,154.87) 182.72,154.87 UV3.U1 ; UV3.U14 v2(182.79,143.88) ; UV3.E3 192.4,153.17 v2(192.01,152.79) ; v2(215.23,142.04) 215.23,141.59 UV7.U1 ; v2(189.59,154.39) 189.99,154 UV3.H2 ; UV3.D10 193.19,147.59 v2(192.79,147.99) ; UV5.E14 v2(171.89,143.83) ; UV5.C13 UV5.C14 v2(173.49,143.83) ; v2(203.99,115.52) 203.99,115.52 UV9.K14 204.61,115.56 205.33,115.56 UV9.K13 ; v2(212.97,117.52) 213.37,117.92 UV9.N3 ; v2(165.88,152.86) 165.48,153.26 UV5.N3 ; UV9.A3 213.37,108.32 v2(212.97,107.92) ; UV3.N14 v2(186,143.79) ; v2(186.39,147.19) 186.79,147.59 UV3.M10 ; UV3.C11 194,146.8 v2(194.39,147.19) ; UV9.T10 207.77,120.32 v2(208.17,119.92) ; v2(215.81,131.88) 215.19,131.88 UV7.E1 ; UV5.C12 v2(173.88,146.46) ; UV7.F10 207.94,132.72 v2(207.55,132.33) ; UV7.C11 v2(207.56,129.92) ; v2(212.96,111.91) 213.35,111.52 UV9.E3 ; UV3.A14 195.6,143.96 195.66,143.89 v2(195.66,143.88) ; UV7.A3 213.56,128.72 v2(213.16,128.32) ; v2(204.13,130.32) UV7.C14 UV7.C13 ; UV7.K2 v2(214.76,135.52) 215.16,135.92 UV7.K1 v2(215.56,135.52) ; v2(173.08,153.66) 173.48,153.26 UV5.C3 v2(173.88,153.66) ; UV5.U1 162.21,154.93 v2(161.76,154.93) ; UV9.N14 v2(203.97,117.92) ; UV5.C11 v2(173.88,147.26) ; v2(211.37,120.72) 211.77,120.32 UV9.T5 ; v2(186.4,152.01) 186.74,151.66 186.74,151.65 UV3.M5 186.99,151.4 187.4,151.4 UV3.L5 ; UV3.N12 v2(186.39,146.39) ; UV5.H1 169.49,154.86 v2(169.88,154.46) ; v2(213.16,137.92) 213.56,138.32 UV7.N3 ; UV7.C1 215.72,130.32 v2(215.81,130.22) ; v2(195.2,151.22) 194.83,151.59 UV3.B5 ; UV7.U12 v2(206.76,141.12) ; v2(203.94,109.92) UV9.C14 UV9.C13 ; v2(188.79,155.19) UV3.K1 188.4,154.79 v2(188.79,154.39) UV3.K2 188.4,153.99 v2(188.79,153.59) ; v2(214.57,114.32) 214.17,113.92 UV9.H2 ; UV7.C12 v2(206.76,129.92) ; v2(207.37,119.92) 206.97,119.52 UV9.R11 ; UV5.P10 v2(165.08,148.06) ; v2(196.12,154.7) 196.12,154.7 196.03,154.8 UV3.A1 ; UV5.G10 v2(170.68,148.06) ; UV7.R4 v2(212.36,140.32) ; UV9.U14 v2(204.05,121.12) ; v2(211.59,129.11) 211.96,129.49 UV7.B5 ; UV5.U12 v2(162.68,146.46) ; UV3.C1 194.08,154.88 v2(194.08,155.31) ; UV7.D10 207.96,131.12 v2(208.36,131.52) ; UV5.R4 v2(163.48,152.06) ; UV9.C4 v2(212.97,109.52) ; UV3.R14 v2(184.39,143.82) ; UV9.M10 v2(207.37,117.52) ; UV5.R3 v2(164.28,152.86) ; UV9.N1 215.54,117.92 v2(215.54,117.92) ; v2(174.72,145.66) 175.09,146.03 UV5.A12 ; UV7.C4 v2(213.16,129.92) ; v2(195.99,152.79) 195.6,153.19 UV3.A3 ; UV9.F10 207.75,112.32 v2(207.36,111.93) ; UV7.H14 204.69,134.25 v2(204.13,134.25) ; UV3.U12 v2(183.19,146.39) ; UV5.H14 169.56,144.39 v2(169.56,143.83) ; UV9.N12 v2(206.57,117.52) ; UV9.E14 v2(203.94,111.52) ; UV5.C1 173.49,155.42 v2(173.58,155.51) ; UV7.H2 214.36,134.32 v2(214.76,134.72) ; v2(194.39,153.59) 194,153.2 UV3.C3 193.99,153.2 v2(193.59,153.59) ; UV5.C4 v2(173.88,152.86) ; UV3.H1 190,154.79 v2(190.39,154.39) ; v2(208.17,116.76) 208.17,116.72 UV9.L10 ; UV7.H1 215.16,134.32 v2(214.76,133.92) ; UV9.D10 207.77,110.72 v2(208.17,111.12) ; v2(215.61,111.49) 215,111.49 UV9.E1 ; UV3.R1 v2(184.39,155.37) ; v2(162.53,143.94) 162.28,144.18 UV5.U14 ; UV3.K13 188.35,145.15 188.35,144.44 UV3.K14 188.4,143.81 v2(188.4,143.81) ; v2(172.28,148.06) 172.68,147.66 UV5.D10 ; UV3.C12 194,146 v2(194.39,146.39) ; UV7.F5 211.93,132.72 v2(211.5,133.14) 211.88,133.52 UV7.G5 ; v2(175.11,143.88) 175.09,143.9 UV5.A14 ; UV7.E12 206.36,131.92 206.36,131.94 v2(206.74,132.32) ; v2(163.88,143.88) 163.88,143.88 UV5.R14 ; UV9.R4 v2(212.17,119.92) ; UV9.C12 v2(206.57,109.52) ; UV7.G10 v2(208.36,133.12) ; UV5.U3 v2(161.76,153.26) ; UV7.N12 v2(206.76,137.92) ; UV3.L10 187.2,147.99 v2(187.16,147.99) ; UV9.C11 v2(207.37,109.52) ; UV3.R12 v2(183.99,146.39) ; UV5.N12 v2(165.88,146.46) ; UV5.T5 v2(162.68,151.26) ; UV3.R11 v2(183.99,147.19) ; UV5.H2 169.48,154.06 v2(169.08,154.46) ; UV3.G10 v2(191.19,147.99)
  TOP w0.381: PQ2.4 131.17,169.52 131.35,169.34 v2(131.35,168.96) ; v2(179.61,53.67) 179.43,53.84 UE2.3 ; v2(78.96,52.39) 79.41,52.84 U2303.3 ; CV211.2 182.56,128.85 182.02,128.31 182.02,128.21 v2(181.96,128.14) ; UI4.1 20.34,32.45 20.54,32.25 v2(20.54,31.69) ; v2(27.08,49.28) 27.49,49.69 UI2.1 ; v2(27.42,64.9) UI3.1 ; v2(128.03,171.32) 128.03,171.01 128.22,170.82 PQ2.1 ; PQ3.4 131.3,164.31 131.8,163.81 PR32.2 ; CC33.2 147.14,108.78 UC3.3 147.14,107.75 v2(146.71,107.32) ; PQ1.1 128.22,175.06 127.98,174.82 127.42,174.82 PC5.2 ; UD1.3 v2(56.24,21.26)
  TOP w0.406: PD101.1 v2(204.75,26.61)
  TOP w0.457: PC856.2 180.2,124.81 v2(179.96,125.05)
  TOP w0.508: RV137.2 191.3,93.52 v2(190.85,93.97) ; v2(66.9,66.67) 67.61,65.97 CD16.2 68.98,65.97 CD5.2 ; CV123.2 159.25,101.84 CV125.2 CV124.2 161.4,102.32 v2(161.68,102.6) ; CA69.2 v2(44.4,31.55) ; v2(189.25,110.27) 189.22,110.29 CV154.2 ; v2(181.96,126.26) 182.35,125.87 PC858.2 ; v2(48.03,26.25) CA64.1 ; C76.2 122,114.67 v2(122.05,114.62) ; C77.2 121.96,111.01 v2(121.74,110.8) ; CI15.2 v2(30.62,69.28) ; CR3.1 180.62,19.34 v2(180.62,19.1) ; RV9.2 206.4,145.78 v2(205.96,146.23) 205.51,145.78 CV25.2 ; CE19.2 v2(178.79,58.23) CE15.2 ; v2(174.91,120.09) 175.37,119.64 PC854.2 PC844.2 ; CD29.2 v2(103.85,75.55) ; v2(118.44,111.9) 118.44,112.37 119.08,113.01 C67.2 ; PC840.2 182.96,124.21 v2(182.96,124.2) ; v2(64.29,37.77) 64.24,37.72 CA29.2 ; v2(117.57,98.5) 117.57,98.11 118.17,97.51 C64.2 C66.2 ; CD17.2 73.32,65.97 CD4.2 73.88,65.58 74.32,66.03 v2(74.32,67.17) ; CE28.2 190.1,33.92 190.86,34.69 v2(190.86,34.84) CE2.2 ; CG8.2 61.59,42.85 v2(61.83,42.85) ; v2(180.96,121.2) 181.62,121.86 PC842.2 ; CV75.2 CV76.2 165.15,115.16 v2(164.61,114.62) ; v2(186.3,60.85) 187.2,60.85 188.27,59.78 CE32.2 ; v2(71.91,75.36) 71.91,75.35 72.36,74.91 72.36,74.54 71.91,74.09 CD20.2 70.44,74.09 CD8.2 ; v2(42.89,21.91) 42.89,21.15 42.64,20.89 CA54.2 ; CV187.2 177.3,113.92 v2(177.3,113.33) ; v2(93.95,123.01) 93.95,123.24 93.77,123.42 RE1.1 ; v2(47.96,26.98) RA19.2 ; v2(209.45,166.1) 209.45,166.49 209.07,166.87 CX36.2 ; PC810.2 200.12,58.92 199.95,58.75 v2(199.95,58.35) ; CV35.2 RV20.2 214.96,101.19 v2(215.23,101.46) ; C69.2 118.9,115.3 118.46,114.86 v2(118.22,114.86) ; v2(170.68,44.53) 170.68,44.39 172.88,42.19 DE1.1 ; C88.2 117.86,118.11 v2(118.22,118.11) ; v2(91.94,100.04) 92.1,99.88 92.1,99.24 91.79,98.92 90.9,98.92 90.58,99.24 RC69.2 RC68.2 RC70.2 ; v2(170.02,166.3) PR712.2 ; CG5.2 65.32,50.29 v2(64.82,49.8) 64.42,49.39 CG1.2 ; CD6.2 v2(65.43,64.49) ; v2(167.48,140.58) 167.87,140.18 RV184.2 CV399.2 ; v2(191.96,140.58) 191.51,140.13 RV31.1 ; JDB.8 210.94,45.93 v2(211.5,45.38) 211.05,44.93 JDB.7 ; RE326.2 178.58,51.56 178.27,51.87 RE47.1 v2(177.56,52.36) ; v2(129.3,125.9) 129.39,125.99 C62.2 130,126.04 C60.2 ; CV144.2 186.27,109.39 v2(186.27,109.39) ; RR1.2 v2(174.4,19.91) ; CV190.2 176.19,117.57 PC861.2 176.04,118.29 v2(175.98,118.36) ; JKBBL.5 44.14,109.46 v2(43.84,109.16) ; v2(172.94,120.21) 172.68,119.95 PC872.2 172.18,120.82 PC873.2 ; RV34.2 CV387.2 158.13,155.45 v2(158.4,155.72) ; v2(120.23,120.58) 120.09,120.58 C83.2 ; v2(179.95,117.18) 180.51,117.74 PC847.2 ; RV242.2 CV333.2 159.6,114.74 160.1,114.74 v2(160.11,114.73) ; CC7.1 114.45,137.01 114.45,137.02 114.45,137.35 v2(114.27,137.53) ; RE58.2 v2(37.79,114.53) ; CX7.2 226.28,174.31 226.66,173.93 227.1,173.93 v2(227.17,173.87) ; PC860.2 182.35,122.75 v2(182.89,123.28) ; CD10.2 77.18,74.41 77.56,74.79 v2(78.01,74.79) 78.71,74.09 CD14.2 ; v2(173.81,122.22) 173.42,122.61 CV146.2 ; v2(93.83,148.89) 94.23,148.49 CM40.2 ; v2(173.95,118.35) 174.26,118.04 PC863.2 ; v2(184.06,34.41) 184.6,34.94 CE27.2 CE6.1 ; PR29.2 v2(129.76,172.01) ; CG7.2 66.86,42.52 v2(67.06,42.32) ; PC904.2 106.14,126.38 v2(106.43,126.09) ; DA12.1 16.41,24.77 v2(16.79,25.15) ; CX47.2 198.34,163.69 197.86,164.18 v2(197.86,164.43) ; v2(62.59,52.57) 63.26,51.89 CG11.2 ; PC871.2 173.58,120.94 v2(173.96,121.33) ; v2(147.92,66.54) 147.35,65.97 CD44.2 146.54,65.47 CD37.2 ; YG1.2 v2(58.53,42.27) ; CV88.2 CV87.2 171.49,107.03 v2(171.25,106.79) ; v2(88.61,125.36) 88.66,125.41 RC163.2 ; v2(174.84,113.9) 174.51,114.23 CV189.2 174.51,114.78 175.22,115.49 CV188.2 ; CG3.2 v2(67.64,46.26) ; v2(178.96,115.2) 179.11,115.05 PC862.2 ; CV115.2 CV114.2 162.32,108.83 v2(162.51,108.65) ; v2(174.91,123.27) 174.52,122.88 PC853.2 ; v2(66.12,111.07) 65.95,110.9 JTP.7 ; CR9.2 180.41,29.23 179.99,29.64 v2(179.81,29.64) ; v2(47.1,30.21) RA81.1 ; RD52.2 52.42,18.2 v2(52.19,17.97) ; v2(175.96,121.27) 176.42,120.81 PC845.2 ; v2(115.42,148.89) 115.74,149.2 115.74,149.27 115.87,149.39 CM46.1 ; CC31.2 133.77,112.91 v2(134.2,112.91) 134.38,113.08 CC34.2 ; PR604.2 PC603.2 220.45,94.46 220.63,94.29 v2(220.75,94.29) ; v2(180.01,119.09) 180.45,119.53 PC843.2 ; v2(60.57,17.67) 60.15,18.09 RD50.2 ; v2(204.83,166.22) 205.02,166.41 CX41.2 ; v2(177.9,128.17) 177.77,128.3 CV324.2 ; RC90.2 122.82,113.33 123.39,112.75 v2(123.39,112.42) ; C57.2 128.74,123.05 v2(128.68,122.99) ; CC15.2 60.87,91.84 v2(60.87,89.45) ; UX1.2 217.83,171.83 v2(217.58,171.58) ; v2(134.45,119.71) 134.6,119.86 RC113.2 ; JTP.4 v2(61.3,110.95) ; PR404.2 PC403.2 104.22,18.37 v3(103.9,18.68) ; PC1302.2 193.75,65.22 v2(194.12,65.58) ; PC852.2 177.82,118.18 v2(177.96,118.33) ; CV127.2 CV130.2 ; CV127.2 v2(156.68,112.95) ; CV127.2 CV126.2 155.72,113.71 CV131.2 ; CD36.2 150.16,65.47 CD43.2 150.65,66.09 150.33,66.41 v2(150.33,66.73) ; CD39.2 156.3,75.11 v2(156.05,75.36) 155.55,74.87 155.22,74.87 ; v2(103.34,69.16) 102.82,69.16 102.44,69.53 RD7.1 RD6.1 ; PC851.2 180,120.41 v2(179.96,120.37) ; v2(177.61,106.99) 178.32,107.7 RV64.1 ; v2(111.44,126.09) 111.15,126.38 PC906.2 ; CD11.2 74.97,73.6 CD13.2 75.31,74.25 75.21,74.25 74.86,74.6 74.86,74.7 74.83,74.73 v2(74.83,74.78) ; C78.2 C82.2 v2(122.15,116.96) ; v2(169.26,174.55) 169.64,174.93 PC719.2 ; CA60.2 45.75,26.53 v2(45.94,26.72) 45.88,26.79 CA59.2 ; v2(173.66,110.34) 173.69,110.37 CV109.2 ; CR5.2 v2(180.24,22.85) ; CD34.2 129.31,66.08 v2(129.82,66.58) ; v2(31.18,46.85) CI26.2 CI7.2 ; QE4.3 v2(38.58,118.23) ; CR8.2 v2(189.2,28.9) ; v2(177.96,123.2) 177.44,122.68 PC846.2 ; v2(65.29,34.67) CA31.2 64.19,35.03 CA30.2 ; v2(199.92,132.57) 200.33,132.98 CV27.2 RV11.2 ; R16.2 v2(89.36,21.2) ; v2(61.18,50.18) 61.88,50.18 CG6.2 ; C53.2 123.64,121.2 v2(123.45,121.01) ; CV149.2 171.21,128.63 CV151.2 169.82,128.07 v2(169.75,128) ; v2(117.73,111.85) 117.52,112.07 C75.1 ; PC13.1 131.22,182.81 v2(131.6,183.19) 131.09,183.69 PR26.1 ; v2(201.96,164.2) 202.21,163.95 CX45.2 ; JSPK.6 v2(70.26,32.62) ; CL33.2 v2(19.21,78.11) ; CV194.2 186.54,117.91 v2(186.98,118.35) 186.53,118.8 CV156.2 ; v2(207.17,100.76) 207.1,100.76 206.66,101.21 RV145.1 ; PC864.2 177.27,124.72 v2(176.95,125.04) ; C81.2 124.65,110.85 v2(125.05,110.45) ; RV207.2 164.99,113.78 v2(164.62,113.78) ; C73.2 121.2,118.04 v2(120.91,117.74) ; CV222.2 v2(209.07,102.61) ; RV25.1 172.37,140.2 v2(172.81,140.64) ; v2(200.75,111.86) 200.31,112.31 RV169.1 ; v2(199.44,130.95) 199.44,129.76 199.8,129.4 RV162.1 ; v2(193.59,34.09) 193.96,34.46 CE29.2 ; CE30.2 176.67,45.53 v2(176.39,45.81) ; v2(183.88,30.6) CR7.2 ; v2(197.67,166.06) 198.63,167.02 CX48.2 ; v2(201.27,41.25) 200.69,41.84 CE11.2 ; CG4.2 v2(59.44,46.09) ; v2(157.43,66.96) 157.43,66.61 157.89,66.16 CD50.2 157.33,65.41 CD38.2 ; CV79.2 CV78.2 164.59,116.94 v2(164.54,116.88) 163.91,116.25 CV80.2 ; CC6.1 118.92,136.09 118.51,135.68 v2(117.22,135.68) ; CD9.2 76.28,65.41 CD12.2 75.72,66.54 v2(76.1,66.92) ; PC859.2 180.37,122.75 v2(180.94,123.32) ; JPWR.4 v2(23.79,97.54) ; PC100.2 206.3,29.23 v2(206.49,29.42) 206.49,27.05 206.14,26.7 206.14,25.86 206.58,25.42 PR114.2 ; DA10.1 29.43,14.42 v2(28.79,13.78) ; C50.2 123.86,119.42 v2(123.9,119.47) ; v2(175.92,30.15) 175.43,29.66 CR11.2 ; PQ4.3 v2(127.52,182.36) ; v2(189.06,34.71) CE36.2 188.32,34.7 CE12.2 ; CE33.2 182.11,34.75 182.43,34.43 v2(182.74,34.43) ; PC1200.2 183.92,180.34 v3(183.35,179.77) 183.67,179.45 PR1202.2 ; PC711.1 PR711.1 v2(172.94,169.22) ; v2(169.06,118.24) 169.47,117.84 RV133.1 ; v2(202.52,17.34) PR107.1 PR108.2 ; v2(79.59,67.17) 79.59,66.22 CD18.2 ; PQ706.3 136.44,166.69 v2(135.98,166.23) ; PR724.1 171.07,177.91 170.83,177.66 PQ708.3 170.4,177.02 v2(169.95,177.47) ; v2(188.06,117.08) 187.51,116.53 CV155.2 ; v2(160.81,66.66) 161.19,66.28 CD53.2 CD52.2 ; CX9.2 217.25,168.73 v2(217.26,168.72) ; PR1201.2 v3(183.35,181.23) ; v2(179.86,19.1) 179.67,19.29 CR2.2 ; v2(186.72,140.51) 187.1,140.13 RV194.2 CV349.2 ; CV325.2 178.98,113.15 RV125.2 179.51,112.57 v2(179.67,112.73) ; v2(177.96,120.31) 178.21,120.56 PC850.2 ; CR10.2 183.14,23.04 v2(183.57,23.47) ; CA56.2 44.99,18.67 44.99,18.15 45.57,18.15 46.07,17.66 v2(46.07,16.58) ; PC841.2 182.42,119.52 v2(181.96,119.06) ; CS7.2 221.77,56.64 223.04,57.91 v2(223.8,57.91) ; CD42.2 144.69,74.23 145.51,74.23 146.14,74.87 147.02,74.87 v2(147.03,74.86) ; CV390.2 RV33.2 v2(200.96,156.39) ; JDB.6 211.66,43.93 v2(211.67,43.94) ; v2(166.52,108.81) 167.02,109.31 RV248.1 ; CV209.2 183.54,126.47 CV204.2 183.97,125.76 183.41,125.2 v2(182.96,125.2) ; v2(179.96,126.29) 180.26,125.99 PC857.2 ; QX1.3 222.98,177.81 v2(222.98,177.34) 223.23,177.34 223.61,176.96 223.61,176.25 CX1.2 ; v2(149.19,75.5) 149.13,75.5 148.49,74.87 149.05,74.31 CD41.2 ; v2(218.41,178.11) 218.41,178.55 218.84,178.98 RX20.2 ; v2(176.05,40.58) 175.89,40.74 CE35.2 ; v2(165.25,129.78) 165.34,129.87 CV97.2 ; v2(172.11,109.39) 172.81,108.69 CV108.2 ; v2(195.3,34.46) 195.75,34.9 RE18.2 195.93,34.9 CE31.2 ; PR32.2 v2(133.19,163.81) ; CV195.2 CV196.2 175.43,125.63 v2(175.97,125.09) ; v2(163.73,111.83) 164.03,112.14 164.03,113.53 CV77.2 ; CD21.2 CD22.2 82.58,66.09 v2(82.01,66.66) ; JTP.8 v2(55.65,110.18) ; v2(122.3,118.78) 121.69,119.39 C71.2 ; CV84.2 CV83.2 171.36,110.36 v2(171.29,110.28) ; CV120.2 158.15,105.52 CV122.2 CV121.2 159.61,105.17 v2(159.26,104.82) ; RV89.1 181.64,107.23 v2(181.68,107.27) 181.54,107.41 CV214.2 ; v2(201.07,39.61) 200.37,38.91 CE1.2 ; v2(48.23,23.42) CA22.2 CA21.2 ; v2(110.79,148.89) 110.73,148.95 CM48.1 ; CE16.2 177.87,40.83 v2(178.51,40.18) CE5.1 ; CE34.2 175.47,43.44 174.4,44.5 v2(172.86,44.5) ; CD3.2 51.27,66.22 v2(51.84,66.79) ; CI24.2 v2(15.45,37) ; v2(222.95,162.68) JKB.32 ; C80.2 91.1,119.7 v2(91.11,119.69) ; v2(151.29,124.19) 151.24,124.14 Q2308.3 ; Q8.3 v2(89.83,21.83) ; v2(175.96,120.07) 175.84,120.07 175.37,120.55 PC866.2 ; Q2307.3 183.94,61.06 v2(184.21,61.33) ; CC11.2 v2(150.41,104.76) 150.22,104.57 R159.2 ; LE2.1 194.62,57.51 RE5.1 CE8.2 196.31,57.29 v2(196.37,57.35) ; v2(213.91,50.68) 213.9,50.66 JDB.9 ; RV240.2 159.74,111.28 v2(160.07,111.61) 160.08,111.6 CV331.2 ; SW1.1 v2(195.35,29.44) ; SW1.6 200.23,33.82 v2(200.24,33.83) ; v2(200.69,113.26) 200.31,113.64 RV17.2 CV33.2 ; CA57.2 45.25,21.57 CA58.2 v2(46,22.15) ; v2(98.52,126.09) 98.16,126.44 PC901.2 ; CV193.2 186.59,113.83 v2(186.88,113.54) ; v2(63.41,40.6) CG2.2 CG10.2 ; PC1304.2 v2(196.23,66.23) 195.99,65.99 PR1301.2 ; v2(204.5,148.46) CV198.2 203.79,148.48 CV197.2 ; CD35.2 153.78,65.47 CD45.2 154.27,66.26 153.85,66.68 v2(153.62,66.68) ; CV211.2 CV206.2 ; CE20.2 195.75,33.72 v2(196.18,34.15) ; CX5.2 232.76,179.38 v2(233.33,178.8) ; CM47.2 104.69,150.75 v2(105.5,151.55) ; CV129.2 CV128.2 v2(155.22,117.84) ; CV400.2 158.66,147.87 158.33,148.2 158.33,149.14 158.13,149.34 RV186.2 157.64,149.66 156.11,151.18 v2(155.92,151.18) ; QD20.3 v2(56.37,16.97) ; v2(168.94,101.53) 168.41,101 RV238.2 CV329.2 ; CD63.2 56.87,18.32 v2(56.49,17.93) ; CI16.2 v2(19.46,36.2) ; v2(108.93,126.09) 108.64,126.38 PC905.2 ; CC4.1 133.03,96.77 v2(133.21,96.95) ; v2(150.53,108.38) 150.53,108.2 150.41,108.08 C51.2 ; PC907.2 113.66,126.38 v2(113.95,126.09) ; v2(173,125.08) 173.29,125.37 CV147.2 CV148.2 ; CR6.2 177.32,28.31 v2(177.51,28.12) ; RV206.1 176.25,127.55 v2(175.89,127.18) ; JPWR.5 v2(29.79,101.03) ; v2(137.44,166.74) 137.82,167.12 PC4.2 PC3.2 ; v2(134.28,185.55) PR9.1 ; v2(177.96,125.2) 177.84,125.2 PC865.2 ; v2(171.32,132.3) 171.32,132.37 170.58,133.11 170.58,134.15 CV142.2 CV153.2 ; CI13.2 v2(30.69,67.43) ; CX37.2 204.94,178.39 v2(205.13,178.19) 205.59,178.65 RX33.2 ; PC855.2 173.9,124.14 v2(173.83,124.21) ; CV116.2 158.52,109.57 v2(157.71,110.38) ; JPWR.6 v2(20.79,101.09) ; v2(181.96,117.35) 182.29,117.67 PC848.2 ; CE56.2 44.35,103.89 v2(43.97,103.51) ; v2(126.27,175.83) PR2.2 PC5.2 ; RM11.1 113.7,149.7 CM43.2 v2(113.08,151.49) ; SW1.5 199.8,27.94 v2(201.39,27.94) 201.17,28.16 SW1.2 ; v2(185.01,124.21) 184.89,124.21 184.42,123.74 CV208.2 184.42,122.73 CV203.2 184.41,122.66 CV205.2 ; CE26.2 183.18,56.69 v2(182.65,56.69) ; v2(163.99,174.55) PC709.2 ; RA32.2 v2(40.54,15.5) ; CX40.2 203.72,165.25 v2(204.18,165.71) 203.99,165.9 CX34.2 ; v2(82.2,58.87) 82.64,59.31 CD64.2 ; JSPK.5 v2(70.26,38.22) ; CG9.2 v2(59.41,44.41) ; PR402.2 109.98,20.06 v3(109.26,20.78) ; CV150.2 CV143.2 169.62,131.48 v2(170.46,132.31) ; YG1.4 v2(62.16,39.59) ; PC908.2 96.76,121.44 v2(95.45,121.44) ; CV110.2 162.91,104.95 v2(163.03,104.83) ; v2(177.96,19.23) CR1.2 ; RX9.2 v2(214.72,170.75) ; CD23.2 v2(78.45,58.28) ; v2(174.03,105.57) RV123.2 ; CX32.2 RX5.1 198.01,168.73 v2(197.6,169.14) ; v2(91.41,137.4) 90.95,136.95 R2.2 ; v2(182.96,119.2) 182.96,118.93 183.41,118.49 CV322.2 ; CD32.2 CD33.2 122.42,74.54 v2(122.77,74.89) ; v3(202.47,22.33) 202.57,22.23 PR105.2 ; v2(82.07,138.04) 82.5,137.61 PC523.2 ; v2(127.22,125.4) 126.91,125.71 RC87.1 ; v2(181.96,128.14) 181.63,128.47 CV212.2 181.27,128.52 CV210.2 180.45,128.49 CV207.2 ; CE57.2 v2(38.45,114.05) ; v2(95.45,117.54) 95.99,117.54 96.87,118.42 PC910.2 ; RV136.2 194.47,95.24 195.48,95.24 195.99,95.75 v2(195.99,95.94) ; CI6.2 v2(26.91,46.97) ; v2(152.24,75.63) 151.98,75.38 151.98,74.87 152.54,74.31 CD40.2 ; CA32.2 v2(65.24,31.98) ; v2(211.17,37.91) 212.8,36.28 JDB.10 ; v2(163.22,169.09) PC710.2 ; PC109.2 v3(203.3,20.23) ; v2(221.39,177.41) 221.29,177.51 RX23.2 ; v2(128.81,97.4) 128.81,97.27 129.31,96.77 CC3.1 ; CV199.2 v2(204.45,147.45) ; CR4.1 173.38,22.35 v2(173.83,21.91) ; JKBBL.6 v2(42.57,120.33) ; C87.2 119.8,116.46 v2(119.66,116.32) ; RA31.2 v2(35.53,33.21) ; v2(180.32,106.03) CV323.2 ; RC132.2 92.63,118.5 v2(92.65,118.52) ; v2(154.36,111.14) 154.5,111.28 RV201.2 CV335.2 ; v2(171.33,113.68) 171.91,114.26 RV204.2 171.91,115.09 172.68,115.87 CV174.2 CV173.2 ; R2351.1 84.42,54.23 v2(84.67,54.49) ; C61.2 121.87,121.33 v2(121.58,121.03) ; RC99.2 133.58,118.81 v2(133.53,118.76) ; v2(33.11,21.85) 33.11,22.92 CA25.1 ; C68.2 123.85,115.16 v2(123.78,115.09) 124.28,115.09 124.49,114.87 C52.2 ; CA74.2 v2(39.65,32.63) ; PC902.2 101.12,126.38 v2(101.41,126.09) ; RX25.2 v2(196.71,172.41) ; CA53.2 v2(42.45,15.84) ; v2(221.45,136.28) JKB.31 ; CI27.2 v2(23.78,36.73) ; v2(103.92,126.09) 103.63,126.38 PC903.2 ; CI17.2 v2(30.69,53.6) ; v2(182.75,107.27) CV213.2 ; v2(223.87,57.03) 224.01,56.89 CS5.2 CS6.2 ; CE18.1 v2(177.97,46.85)
  GND1 w0.203: 228.5,54.6 JHDD.17 ; JHDD.17 228.34,54.04 ; JHDD.17 229.6,53.49 ; JHDD.17 228.5,53.49 ; JHDD.17 229.76,54.04 ; JHDD.17 229.6,54.6 ; 153.02,192.53 PBATT.11 ; PBATT.11 153.95,188.87 ; PBATT.11 153.95,192.53 ; PBATT.11 153.02,190.7 ; PBATT.11 154.87,192.53 ; PBATT.11 154.87,190.7 ; PBATT.11 153.02,188.87 ; PBATT.11 154.87,188.87 ; 139.53,107.33 H32.1 ; H32.1 143.49,105.66 ; H32.1 141.2,107.95 ; H32.1 141.2,103.37 ; H32.1 138.91,105.66 ; H32.1 139.53,103.99 ; H32.1 142.87,103.99 ; H32.1 142.87,107.33 ; 8.38,23.13 JUSB3.5 ; JUSB3.5 8.38,24.88 ; JUSB3.5 9.97,23.13 ; JUSB3.5 9.97,24.88 ; JUSB3.5 8.38,24.01 ; JUSB3.5 11.55,24.01 ; JUSB3.5 11.55,23.13 ; JUSB3.5 11.55,24.88 ; 228.5,48.41 JHDD.13 ; JHDD.13 229.6,49.52 ; JHDD.13 229.76,48.96 ; JHDD.13 228.5,49.52 ; JHDD.13 229.6,48.41 ; JHDD.13 228.34,48.96 ; JUSB3.6 11.55,37.68 ; JUSB3.6 11.55,36.8 ; JUSB3.6 8.38,37.68 ; JUSB3.6 9.97,37.68 ; JUSB3.6 8.38,36.8 ; JUSB3.6 11.55,35.93 ; JUSB3.6 9.97,35.93 ; JUSB3.6 8.38,35.93 ; JUSB1.13 12.25,73.45 ; JUSB1.13 12.25,74.33 ; JUSB1.13 9.31,73.45 ; JUSB1.13 10.78,74.33 ; JUSB1.13 10.78,72.58 ; JUSB1.13 12.25,72.58 ; JUSB1.13 9.31,74.33 ; JUSB2.10 12.25,40.15 ; JUSB2.10 12.25,41.03 ; JUSB2.10 10.78,41.03 ; JUSB2.10 12.25,39.28 ; JUSB2.10 9.31,39.28 ; JUSB2.10 9.31,40.15 ; JUSB2.10 10.78,39.28 ; 25.39,122.64 H10.1 ; H10.1 28.44,122.64 ; H10.1 28.44,119.59 ; H10.1 24.84,121.11 ; H10.1 25.39,119.59 ; H10.1 26.92,119.03 ; H10.1 26.92,123.2 ; H10.1 29,121.11 ; 9.5,95.57 JHDMI.21 ; JHDMI.21 7.92,96.6 ; JHDMI.21 7.92,97.63 ; JHDMI.21 11.08,95.57 ; JHDMI.21 11.08,96.6 ; JHDMI.21 9.5,97.63 ; JHDMI.21 11.08,97.63 ; JHDMI.21 7.92,95.57 ; JMINI.43 112.3,153.58 ; JMINI.43 112.06,151.76 ; JMINI.43 112.3,151.76 ; JHDD.24 229.97,18.2 ; JHDD.24 228.26,19.92 ; JHDD.24 227,16.94 ; JHDD.24 228.26,16.49 ; JHDD.24 227,19.47 ; JHDD.24 229.52,16.94 ; JHDD.24 226.54,18.2 ; JHDD.24 229.52,19.47 ; H11.1 183.54,185.86 ; H11.1 180.86,188.54 ; H11.1 182.2,189.03 ; H11.1 183.54,188.54 ; H11.1 184.03,187.2 ; H11.1 182.2,185.37 ; H11.1 180.86,185.86 ; H11.1 180.37,187.2 ; JREAD.24 168.77,3.46 ; JREAD.24 169.49,2 ; JREAD.24 168.05,0.53 ; JREAD.24 168.77,0.53 ; JREAD.24 169.49,3.46 ; JREAD.24 169.49,0.53 ; JREAD.24 168.05,3.46 ; JREAD.24 168.05,2 ; 156.36,191.41 PBATT.1 ; PBATT.1 157.78,189.99 ; PBATT.1 156.36,189.99 ; PBATT.1 157.07,191.63 ; PBATT.1 157.07,189.77 ; PBATT.1 157.78,191.41 ; PBATT.1 158,190.7 ; PBATT.1 156.14,190.7 ; 223.78,167.18 H35.1 ; H35.1 226.62,170.02 ; H35.1 223.78,170.02 ; H35.1 225.2,170.53 ; H35.1 223.27,168.6 ; H35.1 227.13,168.6 ; H35.1 226.62,167.18 ; H35.1 225.2,166.67 ; PBATT.2 159.78,189.99 ; PBATT.2 158.14,190.7 ; PBATT.2 160,190.7 ; PBATT.2 159.07,189.77 ; PBATT.2 158.36,189.99 ; PBATT.2 159.07,191.63 ; PBATT.2 159.78,191.41 ; PBATT.2 158.36,191.41 ; 162.36,189.99 PBATT.4 ; PBATT.4 162.36,191.41 ; PBATT.4 163.78,191.41 ; PBATT.4 162.14,190.7 ; PBATT.4 163.78,189.99 ; PBATT.4 164,190.7 ; PBATT.4 163.07,191.63 ; PBATT.4 163.07,189.77 ; JUSB1.10 12.25,57.75 ; JUSB1.10 10.78,56.88 ; JUSB1.10 12.25,56.88 ; JUSB1.10 9.31,56.88 ; JUSB1.10 9.31,57.75 ; JUSB1.10 10.78,58.63 ; JUSB1.10 12.25,58.63 ; 95.5,151.76 JMINI.9 ; JMINI.9 95.5,153.58 ; JMINI.9 95.74,153.58 ; JUSB2.7 11.47,48.6 ; JUSB2.7 10.87,48.78 ; JUSB2.7 10.87,47.23 ; JUSB2.7 11.65,48 ; JUSB2.7 11.47,47.41 ; 120.02,158.76 JMINI.53 ; JMINI.53 121.93,160.32 ; JMINI.53 120.02,160.32 ; JMINI.53 121.93,158.76 ; JMINI.53 120.98,158.76 ; 62.29,25.14 H1.1 ; H1.1 63.63,28.31 ; H1.1 64.97,25.14 ; H1.1 64.97,27.82 ; H1.1 65.46,26.48 ; H1.1 61.8,26.48 ; H1.1 62.29,27.82 ; H1.1 63.63,24.65 ; 12.37,61.33 JUSB1.4 ; JUSB1.4 12.37,62.88 ; JUSB1.4 13.15,62.1 ; JUSB1.4 12.97,61.51 ; JUSB1.4 11.59,62.1 ; JUSB1.4 11.77,61.51 ; JUSB1.4 11.77,62.7 ; JUSB1.4 12.97,62.7 ; 1.91,55.85 JUSB2.12 ; JUSB2.12 4.65,56.73 ; JUSB2.12 4.65,55.85 ; JUSB2.12 3.28,56.73 ; JUSB2.12 1.91,56.73 ; H2.1 95.75,18.73 ; H2.1 94.41,18.24 ; H2.1 93.92,16.9 ; H2.1 97.09,18.24 ; H2.1 97.58,16.9 ; H2.1 95.75,15.07 ; H2.1 94.41,15.56 ; H2.1 97.09,15.56 ; H17.1 227.68,9.4 ; H17.1 225.85,11.23 ; H17.1 227.19,10.74 ; H17.1 227.19,8.06 ; H17.1 224.51,8.06 ; H17.1 224.02,9.4 ; H17.1 225.85,7.57 ; H17.1 224.51,10.74 ; JUSB3.4 9.97,27.79 ; JUSB3.4 10.64,26.23 ; JUSB3.4 9.97,26.02 ; JUSB3.4 10.85,26.9 ; JUSB3.4 10.64,27.58 ; JUSB3.4 9.29,27.58 ; JUSB3.4 9.08,26.9 ; JUSB3.4 9.29,26.23 ; 8.75,101.65 JHDMI.2 ; JHDMI.2 9.79,102.11 ; JHDMI.2 8.87,102.11 ; JHDMI.2 9.91,101.65 ; JHDMI.2 9.79,101.19 ; JHDMI.2 9.33,101.07 ; JHDMI.2 8.87,101.19 ; JUSB2.4 13.15,44.5 ; JUSB2.4 12.97,45.1 ; JUSB2.4 12.37,43.73 ; JUSB2.4 11.77,45.1 ; JUSB2.4 11.77,43.91 ; JUSB2.4 11.59,44.5 ; JUSB2.4 12.37,45.28 ; JUSB2.4 12.97,43.91 ; 7.92,113.67 JHDMI.22 ; JHDMI.22 11.08,113.67 ; JHDMI.22 9.5,113.67 ; JHDMI.22 11.08,115.73 ; JHDMI.22 9.5,115.73 ; JHDMI.22 11.08,114.7 ; JHDMI.22 7.92,115.73 ; JHDMI.22 7.92,114.7 ; 228.12,122.75 H20.1 ; H20.1 228.7,121.15 ; H20.1 231.9,121.15 ; H20.1 230.3,120.57 ; H20.1 228.7,124.35 ; H20.1 230.3,124.93 ; H20.1 232.48,122.75 ; H20.1 231.9,124.35 ; 1.91,57.75 JUSB1.11 ; JUSB1.11 1.91,56.88 ; JUSB1.11 4.65,56.88 ; JUSB1.11 4.65,57.75 ; JUSB1.11 3.28,56.88 ; 223.86,84.74 H8.1 ; H8.1 225.2,85.23 ; H8.1 226.54,84.74 ; H8.1 223.86,82.06 ; H8.1 223.37,83.4 ; H8.1 225.2,81.57 ; H8.1 227.03,83.4 ; H8.1 226.54,82.06 ; 230.56,171.44 H9.1 ; H9.1 233.73,170.1 ; H9.1 233.24,168.76 ; H9.1 230.56,168.76 ; H9.1 231.9,171.93 ; H9.1 230.07,170.1 ; H9.1 233.24,171.44 ; H9.1 231.9,168.27 ; H34.1 82.47,107.33 ; H34.1 83.09,105.66 ; H34.1 82.47,103.99 ; H34.1 79.13,107.33 ; H34.1 79.13,103.99 ; H34.1 80.8,107.95 ; H34.1 78.51,105.66 ; H34.1 80.8,103.37 ; 127.6,154.97 H16.1 ; H16.1 126.26,158.14 ; H16.1 128.94,158.14 ; H16.1 128.94,155.46 ; H16.1 129.43,156.8 ; H16.1 125.77,156.8 ; H16.1 126.26,155.46 ; H16.1 127.6,158.63 ; 228.5,36.82 JHDD.7 ; JHDD.7 229.76,36.26 ; JHDD.7 228.5,35.71 ; JHDD.7 229.6,35.71 ; JHDD.7 228.34,36.26 ; JHDD.7 229.05,36.98 ; JHDD.7 229.6,36.82 ; 86.27,158.76 JMINI.54 ; JMINI.54 88.18,158.76 ; JMINI.54 88.18,160.32 ; JMINI.54 87.23,158.76 ; JMINI.54 86.27,160.32 ; JUSB1.7 10.87,66.38 ; JUSB1.7 11.47,65.01 ; JUSB1.7 11.47,66.2 ; JUSB1.7 11.65,65.6 ; JUSB1.7 10.87,64.83 ; JUSB2.13 12.25,55.85 ; JUSB2.13 12.25,56.73 ; JUSB2.13 10.78,56.73 ; JUSB2.13 10.78,54.98 ; JUSB2.13 9.31,55.85 ; JUSB2.13 9.31,56.73 ; JUSB2.13 12.25,54.98 ; 79.13,132.73 H31.1 ; H31.1 80.8,128.77 ; H31.1 78.51,131.06 ; H31.1 80.8,133.35 ; H31.1 83.09,131.06 ; H31.1 82.47,129.39 ; H31.1 82.47,132.73 ; H31.1 79.13,129.39 ; JHDMI.8 9.79,105.11 ; JHDMI.8 9.79,104.19 ; JHDMI.8 8.87,105.11 ; JHDMI.8 9.91,104.65 ; JHDMI.8 8.75,104.65 ; JHDMI.8 8.87,104.19 ; 7.2,103.15 JHDMI.5 ; JHDMI.5 8.24,103.61 ; JHDMI.5 7.32,103.61 ; JHDMI.5 8.36,103.15 ; JHDMI.5 7.32,102.69 ; JHDMI.5 8.24,102.69 ; 175.27,188.87 PBATT.10 ; PBATT.10 175.27,190.7 ; PBATT.10 177.12,188.87 ; PBATT.10 176.19,188.87 ; PBATT.10 177.12,190.7 ; JHDD.1 229.6,29.2 ; JHDD.1 229.05,27.93 ; JHDD.1 228.34,28.64 ; JHDD.1 228.5,29.2 ; JHDD.1 229.6,28.09 ; JHDD.1 229.76,28.64 ; JHDD.1 228.5,28.09 ; JHDD.11 229.76,46.42 ; JHDD.11 229.6,45.87 ; JHDD.11 228.5,46.98 ; JHDD.11 229.6,46.98 ; JHDD.11 228.5,45.87 ; JHDD.11 228.34,46.42 ; 227,70.07 JHDD.23 ; JHDD.23 229.52,67.54 ; JHDD.23 227,67.54 ; JHDD.23 226.54,68.8 ; JHDD.23 228.26,70.52 ; JHDD.23 229.97,68.8 ; JHDD.23 228.26,67.09 ; JHDD.23 229.52,70.07 ; JHDD.4 229.6,33.01 ; JHDD.4 228.5,31.9 ; JHDD.4 228.34,32.45 ; JHDD.4 229.6,31.9 ; JHDD.4 229.76,32.45 ; JHDD.4 228.5,33.01 ; 228.7,98.05 H19.1 ; H19.1 231.9,94.85 ; H19.1 228.12,96.45 ; H19.1 230.3,98.64 ; H19.1 232.48,96.45 ; H19.1 228.7,94.85 ; H19.1 231.9,98.05 ; H19.1 230.3,94.27 ; 197.35,2 JREAD.23 ; JREAD.23 197.35,3.46 ; JREAD.23 198.79,2 ; JREAD.23 198.07,0.53 ; JREAD.23 197.35,0.53 ; JREAD.23 198.79,0.53 ; JREAD.23 198.79,3.46 ; JREAD.23 198.07,3.46 ; JMINI.29 106.7,153.58 ; JMINI.29 106.22,153.58 ; JMINI.29 106.94,153.58 ; H33.1 142.87,129.39 ; H33.1 141.2,128.77 ; H33.1 141.2,133.35 ; H33.1 138.91,131.06 ; H33.1 142.87,132.73 ; H33.1 143.49,131.06 ; H33.1 139.53,129.39 ; H33.1 139.53,132.73 ; 0.5,75.38 JLAN.9 ; JLAN.9 2.25,74.33 ; JLAN.9 4,75.38 ; JLAN.9 4,74.33 ; JLAN.9 0.5,74.33 ; JMINI.27 106.38,153.58 ; JMINI.27 105.9,153.58 ; JMINI.27 105.66,151.76 ; 0.82,96.6 JHDMI.20 ; JHDMI.20 3.98,96.6 ; JHDMI.20 2.4,95.57 ; JHDMI.20 0.82,95.57 ; JHDMI.20 3.98,95.57 ; 2.52,21.92 JUSB3.7 ; JUSB3.7 3.75,22.71 ; JUSB3.7 1.28,22.71 ; JUSB3.7 1.28,21.92 ; JUSB3.7 3.75,21.92 ; H6.1 205.62,94.88 ; H6.1 204.1,94.32 ; H6.1 202.58,94.88 ; H6.1 204.1,98.48 ; H6.1 206.18,96.4 ; H6.1 202.02,96.4 ; H6.1 205.62,97.92 ; H6.1 202.58,97.92 ; H12.1 34.03,111.4 ; H12.1 30.86,110.06 ; H12.1 33.54,112.74 ; H12.1 32.2,113.23 ; H12.1 32.2,109.57 ; H12.1 33.54,110.06 ; H12.1 30.86,112.74 ; H12.1 30.37,111.4 ; JUSB1.12 4.65,73.45 ; JUSB1.12 4.65,74.33 ; JUSB1.12 1.91,74.33 ; JUSB1.12 1.91,73.45 ; 0.5,95.23 JLAN.10 ; JLAN.10 4,94.18 ; JLAN.10 4,95.23 ; JLAN.10 2.25,95.23 ; JLAN.10 0.5,94.18 ; JUSB3.8 3.75,38.89 ; JUSB3.8 3.75,38.1 ; JUSB3.8 1.28,38.89 ; JUSB3.8 1.28,38.1 ; JUSB3.8 2.52,38.89 ; JUSB2.11 4.65,39.28 ; JUSB2.11 3.28,39.28 ; JUSB2.11 1.91,40.15 ; JUSB2.11 1.91,39.28 ; JUSB2.11 4.65,40.15 ; 228.34,56.58 JHDD.19 ; JHDD.19 229.6,56.03 ; JHDD.19 228.5,56.03 ; JHDD.19 229.76,56.58 ; JHDD.19 229.6,57.14 ; JHDD.19 228.5,57.14 ; 151.78,144.99 H7.1 ; H7.1 151.78,148.03 ; H7.1 153.3,144.43 ; H7.1 153.3,148.59 ; H7.1 151.22,146.51 ; H7.1 154.82,148.03 ; H7.1 155.38,146.51 ; H7.1 154.82,144.99 ; JHDMI.17 8.36,109.15 ; JHDMI.17 7.2,109.15 ; JHDMI.17 7.32,109.61 ; JHDMI.17 7.32,108.69 ; JHDMI.17 8.24,109.61 ; JHDMI.17 8.24,108.69 ; JHDMI.11 8.24,105.69 ; JHDMI.11 8.36,106.15 ; JHDMI.11 8.24,106.61 ; JHDMI.11 7.2,106.15 ; JHDMI.11 7.32,105.69 ; JHDMI.11 7.32,106.61 ; 103.5,151.76 JMINI.21 ; JMINI.21 103.5,153.58 ; JMINI.21 103.26,151.76 ; JMINI.15 98.38,151.76 ; JMINI.15 97.9,151.76 ; JMINI.15 98.38,153.58 ; JMINI.15 98.38,152.67 ; JMINI.15 97.9,153.58 ; JHDMI.23 2.4,115.73 ; JHDMI.23 0.82,114.7 ; JHDMI.23 0.82,115.73 ; JHDMI.23 3.98,114.7 ; JHDMI.23 3.98,115.73 ; 108.86,151.76 JMINI.35 ; JMINI.35 109.1,153.58 ; JMINI.35 109.1,151.76
  IN2 w0.508: v2(16.79,25.15) 16.79,27.12 v2(15.52,28.39)
  GND2 w0.203: JUSB2.10 12.25,41.03 ; JUSB2.10 9.31,40.15 ; JUSB2.10 12.25,40.15 ; JUSB2.10 12.25,39.28 ; JUSB2.10 10.78,39.28 ; JUSB2.10 9.31,39.28 ; JUSB2.10 10.78,41.03 ; 8.87,105.11 JHDMI.8 ; JHDMI.8 9.79,104.19 ; JHDMI.8 9.91,104.65 ; JHDMI.8 9.79,105.11 ; JHDMI.8 8.75,104.65 ; JHDMI.8 8.87,104.19 ; JHDMI.11 8.24,105.69 ; JHDMI.11 8.36,106.15 ; JHDMI.11 7.32,106.61 ; JHDMI.11 7.32,105.69 ; JHDMI.11 8.24,106.61 ; JHDMI.11 7.2,106.15 ; 9.08,26.9 JUSB3.4 ; JUSB3.4 9.97,27.79 ; JUSB3.4 10.64,27.58 ; JUSB3.4 9.29,26.23 ; JUSB3.4 10.85,26.9 ; JUSB3.4 9.97,26.02 ; JUSB3.4 9.29,27.58 ; JUSB3.4 10.64,26.23 ; JREAD.23 198.79,3.46 ; JREAD.23 198.79,2 ; JREAD.23 197.35,0.53 ; JREAD.23 197.35,3.46 ; JREAD.23 197.35,2 ; JREAD.23 198.79,0.53 ; JREAD.23 198.07,0.53 ; JREAD.23 198.07,3.46 ; 103.5,151.76 JMINI.21 ; JMINI.21 103.26,151.76 ; JMINI.21 103.5,153.58 ; PBATT.4 163.07,191.63 ; PBATT.4 162.36,189.99 ; PBATT.4 163.78,189.99 ; PBATT.4 162.36,191.41 ; PBATT.4 163.07,189.77 ; PBATT.4 162.14,190.7 ; PBATT.4 164,190.7 ; PBATT.4 163.78,191.41 ; 1.91,55.85 JUSB2.12 ; JUSB2.12 4.65,56.73 ; JUSB2.12 1.91,56.73 ; JUSB2.12 3.28,56.73 ; JUSB2.12 4.65,55.85 ; 9.33,101.07 JHDMI.2 ; JHDMI.2 8.87,101.19 ; JHDMI.2 9.91,101.65 ; JHDMI.2 9.79,102.11 ; JHDMI.2 9.79,101.19 ; JHDMI.2 8.87,102.11 ; JHDMI.2 8.75,101.65 ; 8.38,36.8 JUSB3.6 ; JUSB3.6 8.38,37.68 ; JUSB3.6 8.38,35.93 ; JUSB3.6 11.55,35.93 ; JUSB3.6 11.55,36.8 ; JUSB3.6 11.55,37.68 ; JUSB3.6 9.97,37.68 ; JUSB3.6 9.97,35.93 ; 11.77,62.7 JUSB1.4 ; JUSB1.4 13.15,62.1 ; JUSB1.4 12.37,62.88 ; JUSB1.4 12.97,61.51 ; JUSB1.4 11.59,62.1 ; JUSB1.4 12.37,61.33 ; JUSB1.4 12.97,62.7 ; JUSB1.4 11.77,61.51 ; 2.4,95.57 JHDMI.20 ; JHDMI.20 3.98,96.6 ; JHDMI.20 0.82,96.6 ; JHDMI.20 0.82,95.57 ; JHDMI.20 3.98,95.57 ; 228.12,96.45 H19.1 ; H19.1 231.9,98.05 ; H19.1 228.7,94.85 ; H19.1 230.3,98.64 ; H19.1 230.3,94.27 ; H19.1 232.48,96.45 ; H19.1 228.7,98.05 ; H19.1 231.9,94.85 ; JHDMI.23 3.98,115.73 ; JHDMI.23 0.82,115.73 ; JHDMI.23 0.82,114.7 ; JHDMI.23 3.98,114.7 ; JHDMI.23 2.4,115.73 ; JHDMI.22 11.08,114.7 ; JHDMI.22 7.92,115.73 ; JHDMI.22 11.08,115.73 ; JHDMI.22 9.5,115.73 ; JHDMI.22 7.92,113.67 ; JHDMI.22 11.08,113.67 ; JHDMI.22 7.92,114.7 ; JHDMI.22 9.5,113.67 ; 228.34,46.42 JHDD.11 ; JHDD.11 228.5,46.98 ; JHDD.11 229.6,45.87 ; JHDD.11 229.6,46.98 ; JHDD.11 228.5,45.87 ; JHDD.11 229.76,46.42 ; JHDMI.21 9.5,97.63 ; JHDMI.21 7.92,95.57 ; JHDMI.21 7.92,97.63 ; JHDMI.21 11.08,95.57 ; JHDMI.21 11.08,96.6 ; JHDMI.21 11.08,97.63 ; JHDMI.21 9.5,95.57 ; JHDMI.21 7.92,96.6 ; H33.1 142.87,129.39 ; H33.1 143.49,131.06 ; H33.1 139.53,129.39 ; H33.1 141.2,133.35 ; H33.1 142.87,132.73 ; H33.1 138.91,131.06 ; H33.1 139.53,132.73 ; H33.1 141.2,128.77 ; 0.5,75.38 JLAN.9 ; JLAN.9 4,75.38 ; JLAN.9 0.5,74.33 ; JLAN.9 2.25,74.33 ; JLAN.9 4,74.33 ; JMINI.29 106.94,153.58 ; JMINI.29 106.7,153.58 ; JMINI.29 106.22,153.58 ; 11.77,45.1 JUSB2.4 ; JUSB2.4 12.37,45.28 ; JUSB2.4 12.37,43.73 ; JUSB2.4 13.15,44.5 ; JUSB2.4 12.97,43.91 ; JUSB2.4 12.97,45.1 ; JUSB2.4 11.59,44.5 ; JUSB2.4 11.77,43.91 ; H11.1 183.54,185.86 ; H11.1 184.03,187.2 ; H11.1 180.86,185.86 ; H11.1 183.54,188.54 ; H11.1 182.2,189.03 ; H11.1 182.2,185.37 ; H11.1 180.86,188.54 ; H11.1 180.37,187.2 ; H12.1 33.54,110.06 ; H12.1 30.86,110.06 ; H12.1 34.03,111.4 ; H12.1 32.2,109.57 ; H12.1 30.86,112.74 ; H12.1 33.54,112.74 ; H12.1 32.2,113.23 ; H12.1 30.37,111.4 ; 227,70.07 JHDD.23 ; JHDD.23 229.52,70.07 ; JHDD.23 227,67.54 ; JHDD.23 229.97,68.8 ; JHDD.23 228.26,67.09 ; JHDD.23 226.54,68.8 ; JHDD.23 229.52,67.54 ; JHDD.23 228.26,70.52 ; H1.1 64.97,27.82 ; H1.1 61.8,26.48 ; H1.1 64.97,25.14 ; H1.1 65.46,26.48 ; H1.1 62.29,25.14 ; H1.1 62.29,27.82 ; H1.1 63.63,24.65 ; H1.1 63.63,28.31 ; 1.28,22.71 JUSB3.7 ; JUSB3.7 2.52,21.92 ; JUSB3.7 3.75,22.71 ; JUSB3.7 1.28,21.92 ; JUSB3.7 3.75,21.92 ; 151.78,144.99 H7.1 ; H7.1 154.82,144.99 ; H7.1 154.82,148.03 ; H7.1 151.22,146.51 ; H7.1 151.78,148.03 ; H7.1 153.3,148.59 ; H7.1 153.3,144.43 ; H7.1 155.38,146.51 ; JUSB1.13 10.78,74.33 ; JUSB1.13 9.31,73.45 ; JUSB1.13 12.25,72.58 ; JUSB1.13 12.25,74.33 ; JUSB1.13 12.25,73.45 ; JUSB1.13 9.31,74.33 ; JUSB1.13 10.78,72.58 ; 25.39,119.59 H10.1 ; H10.1 26.92,123.2 ; H10.1 24.84,121.11 ; H10.1 28.44,119.59 ; H10.1 25.39,122.64 ; H10.1 28.44,122.64 ; H10.1 29,121.11 ; H10.1 26.92,119.03 ; H9.1 233.24,168.76 ; H9.1 233.24,171.44 ; H9.1 231.9,171.93 ; H9.1 230.56,171.44 ; H9.1 231.9,168.27 ; H9.1 230.07,170.1 ; H9.1 230.56,168.76 ; H9.1 233.73,170.1 ; 224.51,8.06 H17.1 ; H17.1 227.19,10.74 ; H17.1 225.85,7.57 ; H17.1 224.02,9.4 ; H17.1 227.19,8.06 ; H17.1 225.85,11.23 ; H17.1 224.51,10.74 ; H17.1 227.68,9.4 ; 125.77,156.8 H16.1 ; H16.1 127.6,154.97 ; H16.1 126.26,155.46 ; H16.1 129.43,156.8 ; H16.1 128.94,158.14 ; H16.1 127.6,158.63 ; H16.1 128.94,155.46 ; H16.1 126.26,158.14 ; JHDD.24 229.97,18.2 ; JHDD.24 229.52,19.47 ; JHDD.24 227,16.94 ; JHDD.24 229.52,16.94 ; JHDD.24 227,19.47 ; JHDD.24 228.26,16.49 ; JHDD.24 226.54,18.2 ; JHDD.24 228.26,19.92 ; 10.87,64.83 JUSB1.7 ; JUSB1.7 11.65,65.6 ; JUSB1.7 11.47,65.01 ; JUSB1.7 10.87,66.38 ; JUSB1.7 11.47,66.2 ; 228.5,33.01 JHDD.4 ; JHDD.4 228.34,32.45 ; JHDD.4 228.5,31.9 ; JHDD.4 229.6,33.01 ; JHDD.4 229.6,31.9 ; JHDD.4 229.76,32.45 ; H32.1 142.87,103.99 ; H32.1 139.53,103.99 ; H32.1 141.2,103.37 ; H32.1 143.49,105.66 ; H32.1 139.53,107.33 ; H32.1 138.91,105.66 ; H32.1 142.87,107.33 ; H32.1 141.2,107.95 ; 1.91,73.45 JUSB1.12 ; JUSB1.12 1.91,74.33 ; JUSB1.12 4.65,73.45 ; JUSB1.12 4.65,74.33 ; 228.5,28.09 JHDD.1 ; JHDD.1 228.5,29.2 ; JHDD.1 229.6,29.2 ; JHDD.1 229.6,28.09 ; JHDD.1 228.34,28.64 ; JHDD.1 229.76,28.64 ; JHDD.1 229.05,27.93 ; JLAN.10 2.25,95.23 ; JLAN.10 4,95.23 ; JLAN.10 0.5,94.18 ; JLAN.10 4,94.18 ; JLAN.10 0.5,95.23 ; JUSB2.13 12.25,54.98 ; JUSB2.13 10.78,56.73 ; JUSB2.13 10.78,54.98 ; JUSB2.13 12.25,56.73 ; JUSB2.13 9.31,55.85 ; JUSB2.13 9.31,56.73 ; JUSB2.13 12.25,55.85 ; 1.91,39.28 JUSB2.11 ; JUSB2.11 4.65,39.28 ; JUSB2.11 3.28,39.28 ; JUSB2.11 4.65,40.15 ; JUSB2.11 1.91,40.15 ; H35.1 227.13,168.6 ; H35.1 223.78,170.02 ; H35.1 225.2,166.67 ; H35.1 226.62,167.18 ; H35.1 223.78,167.18 ; H35.1 226.62,170.02 ; H35.1 223.27,168.6 ; H35.1 225.2,170.53 ; 79.13,132.73 H31.1 ; H31.1 82.47,132.73 ; H31.1 80.8,133.35 ; H31.1 83.09,131.06 ; H31.1 78.51,131.06 ; H31.1 82.47,129.39 ; H31.1 79.13,129.39 ; H31.1 80.8,128.77 ; JUSB3.5 11.55,24.88 ; JUSB3.5 11.55,23.13 ; JUSB3.5 8.38,24.88 ; JUSB3.5 8.38,24.01 ; JUSB3.5 8.38,23.13 ; JUSB3.5 9.97,24.88 ; JUSB3.5 9.97,23.13 ; JUSB3.5 11.55,24.01 ; JHDD.7 229.6,36.82 ; JHDD.7 229.6,35.71 ; JHDD.7 228.5,35.71 ; JHDD.7 229.05,36.98 ; JHDD.7 229.76,36.26 ; JHDD.7 228.34,36.26 ; JHDD.7 228.5,36.82 ; 228.7,121.15 H20.1 ; H20.1 228.7,124.35 ; H20.1 231.9,124.35 ; H20.1 230.3,120.57 ; H20.1 231.9,121.15 ; H20.1 228.12,122.75 ; H20.1 230.3,124.93 ; H20.1 232.48,122.75 ; 228.5,49.52 JHDD.13 ; JHDD.13 229.76,48.96 ; JHDD.13 228.5,48.41 ; JHDD.13 229.6,48.41 ; JHDD.13 228.34,48.96 ; JHDD.13 229.6,49.52 ; JMINI.15 98.38,153.58 ; JMINI.15 98.38,152.67 ; JMINI.15 97.9,153.58 ; JMINI.15 97.9,151.76 ; JMINI.15 98.38,151.76 ; PBATT.11 154.87,192.53 ; PBATT.11 153.02,190.7 ; PBATT.11 153.02,188.87 ; PBATT.11 153.95,188.87 ; PBATT.11 153.95,192.53 ; PBATT.11 154.87,188.87 ; PBATT.11 154.87,190.7 ; PBATT.11 153.02,192.53 ; 204.1,94.32 H6.1 ; H6.1 202.58,97.92 ; H6.1 202.58,94.88 ; H6.1 205.62,94.88 ; H6.1 202.02,96.4 ; H6.1 205.62,97.92 ; H6.1 206.18,96.4 ; H6.1 204.1,98.48 ; 1.28,38.1 JUSB3.8 ; JUSB3.8 1.28,38.89 ; JUSB3.8 2.52,38.89 ; JUSB3.8 3.75,38.89 ; JUSB3.8 3.75,38.1 ; JUSB1.10 10.78,58.63 ; JUSB1.10 9.31,56.88 ; JUSB1.10 9.31,57.75 ; JUSB1.10 12.25,56.88 ; JUSB1.10 12.25,58.63 ; JUSB1.10 10.78,56.88 ; JUSB1.10 12.25,57.75 ; JHDMI.17 8.24,108.69 ; JHDMI.17 7.32,108.69 ; JHDMI.17 8.24,109.61 ; JHDMI.17 7.2,109.15 ; JHDMI.17 7.32,109.61 ; JHDMI.17 8.36,109.15 ; 105.66,151.76 JMINI.27 ; JMINI.27 105.9,153.58 ; JMINI.27 106.38,153.58 ; 112.3,151.76 JMINI.43 ; JMINI.43 112.3,153.58 ; JMINI.43 112.06,151.76 ; 1.91,57.75 JUSB1.11 ; JUSB1.11 3.28,56.88 ; JUSB1.11 1.91,56.88 ; JUSB1.11 4.65,56.88 ; JUSB1.11 4.65,57.75 ; JHDMI.5 8.36,103.15 ; JHDMI.5 8.24,102.69 ; JHDMI.5 7.32,103.61 ; JHDMI.5 8.24,103.61 ; JHDMI.5 7.2,103.15 ; JHDMI.5 7.32,102.69 ; PBATT.1 158,190.7 ; PBATT.1 156.36,189.99 ; PBATT.1 157.78,189.99 ; PBATT.1 156.36,191.41 ; PBATT.1 157.07,189.77 ; PBATT.1 156.14,190.7 ; PBATT.1 157.07,191.63 ; PBATT.1 157.78,191.41 ; 168.05,3.46 JREAD.24 ; JREAD.24 168.05,2 ; JREAD.24 168.77,0.53 ; JREAD.24 169.49,2 ; JREAD.24 168.05,0.53 ; JREAD.24 168.77,3.46 ; JREAD.24 169.49,3.46 ; JREAD.24 169.49,0.53 ; 120.02,160.32 JMINI.53 ; JMINI.53 121.93,158.76 ; JMINI.53 121.93,160.32 ; JMINI.53 120.98,158.76 ; JMINI.53 120.02,158.76 ; 158.14,190.7 PBATT.2 ; PBATT.2 160,190.7 ; PBATT.2 159.78,189.99 ; PBATT.2 159.07,191.63 ; PBATT.2 158.36,191.41 ; PBATT.2 159.78,191.41 ; PBATT.2 159.07,189.77 ; PBATT.2 158.36,189.99 ; JMINI.54 88.18,160.32 ; JMINI.54 86.27,158.76 ; JMINI.54 88.18,158.76 ; JMINI.54 87.23,158.76 ; JMINI.54 86.27,160.32 ; JUSB2.7 10.87,48.78 ; JUSB2.7 11.65,48 ; JUSB2.7 11.47,48.6 ; JUSB2.7 10.87,47.23 ; JUSB2.7 11.47,47.41 ; 175.27,188.87 PBATT.10 ; PBATT.10 177.12,188.87 ; PBATT.10 175.27,190.7 ; PBATT.10 176.19,188.87 ; PBATT.10 177.12,190.7 ; 78.51,105.66 H34.1 ; H34.1 82.47,107.33 ; H34.1 80.8,103.37 ; H34.1 79.13,107.33 ; H34.1 80.8,107.95 ; H34.1 83.09,105.66 ; H34.1 79.13,103.99 ; H34.1 82.47,103.99 ; JHDD.19 229.76,56.58 ; JHDD.19 228.5,56.03 ; JHDD.19 229.6,56.03 ; JHDD.19 228.34,56.58 ; JHDD.19 228.5,57.14 ; JHDD.19 229.6,57.14 ; JHDD.17 229.6,53.49 ; JHDD.17 229.6,54.6 ; JHDD.17 228.34,54.04 ; JHDD.17 229.76,54.04 ; JHDD.17 228.5,53.49 ; JHDD.17 228.5,54.6 ; 108.86,151.76 JMINI.35 ; JMINI.35 109.1,153.58 ; JMINI.35 109.1,151.76 ; H2.1 97.58,16.9 ; H2.1 97.09,18.24 ; H2.1 95.75,18.73 ; H2.1 95.75,15.07 ; H2.1 94.41,18.24 ; H2.1 93.92,16.9 ; H2.1 94.41,15.56 ; H2.1 97.09,15.56 ; 95.5,151.76 JMINI.9 ; JMINI.9 95.74,153.58 ; JMINI.9 95.5,153.58 ; H8.1 225.2,85.23 ; H8.1 225.2,81.57 ; H8.1 226.54,82.06 ; H8.1 227.03,83.4 ; H8.1 223.86,82.06 ; H8.1 223.37,83.4 ; H8.1 226.54,84.74 ; H8.1 223.86,84.74
  BOTTOM w0.102: 121.74,104.04 121.74,103.54 121.95,103.34 121.95,102.84 122.08,102.71 122.08,100.05 122.9,99.23 122.9,98.71 123.37,98.24 RC134.2 ; v2(155.41,134.93) v4(155.41,135.68) ; v2(23.79,97.54) v4(23.79,96.47) ; v4(24.36,109.45) RX13.2 ; RC101.2 124.31,98.24 124.74,98.68 124.74,99.45 124.57,99.62 124.3,99.62 123.23,100.69 123.23,102.8 122.44,103.59 122.44,104.18 122.13,104.49 ; v2(29.79,101.03) v4(30.5,101.03)
  BOTTOM w0.127: UC1.AV39 107.1,106.4 107.47,106.76 107.47,107.32 ; UC1.AV36 108.68,106.4 109.05,106.76 109.05,107.17 109.16,107.28 ; UC1.AV46 102.38,106.4 102.75,106.76 102.75,107.03 102.73,107.04 102.73,107.35 ; 105.94,107.28 105.9,107.24 105.9,106.76 105.53,106.4 UC1.AV41 ; 104.57,107.28 104.32,107.04 104.32,106.76 103.95,106.4 UC1.AV43 ; 101.33,107.28 101.17,107.13 101.17,106.76 100.99,106.58 100.99,106.43 UC1.AV49
  BOTTOM w0.152: UV1.AN6 190.46,110.48 190.86,110.09 190.86,109.51 UV1.AR5
  BOTTOM w0.178: v2(116.34,107.73) 116.58,107.5 116.84,107.24 116.86,107.22 UC1.AU22 117.72,107.22 117.74,107.24 118.02,107.24 118.04,107.22 UC1.AU20 ; v2(116.34,107.73) 115.96,107.34 UC1.AU24 ; v2(116.34,107.73) 116.66,108.05 UC1.AR23 ; UC1.AW37 107.93,105.59 108.27,105.93 v2(108.27,105.94) 108.28,105.94 108.58,106.24 UC1.AV36 ; UC1.AY26 114.61,104.32 114.42,104.13 v2(114.42,104.11) ; UC1.AL17 UC1.AM17 UC1.AN17 UC1.AP17 UC1.AR17 ; UC1.AP48 101.36,108.7 101.03,108.38 ; UC1.AJ56 96.2,111.96 95.88,112.28 UC1.AH57 95.55,112.28 95.2,112.28 94.9,111.98 UC1.AJ58 94.4,111.96 94.12,112.24 ; UC1.AN45 UC1.AN43 104.57,109.35 v2(104.84,109.08) 105.12,109.35 UC1.AN42 105.43,109.35 v2(105.76,109.03) ; UC1.AU24 115.44,107.22 115.43,107.24 115.14,107.24 115.12,107.22 UC1.AU26 114.2,107.22 114.18,107.24 113.9,107.24 113.88,107.22 UC1.AU28 ; UC1.AU24 UC1.AV24 UC1.AW24 UC1.AY24 115.96,104.41 v2(115.88,104.33) ; UC1.P59 94.25,119.72 v2(93.95,120.02) ; UC1.AW33 UC1.AY33 110.83,104.69 v2(110.65,104.51) ; UC1.AW33 110.83,106.52 UC1.AV33 ; UC1.AW33 110.58,105.92 UC1.AV34 ; v2(90.73,111.28) 90.95,111.28 91.28,111.62 UC1.AJ63 ; v2(110.11,107.79) 110.66,107.24 UC1.AU33 ; v2(110.11,107.79) 110.37,108.05 UC1.AR33 ; v2(110.11,107.79) 109.84,107.52 UC1.AT35 109.41,107.35 109.34,107.28 108.7,107.28 108.63,107.35 UC1.AT37 107.5,107.35 107.44,107.28 107.07,107.28 107,107.35 UC1.AT40 106.01,107.35 105.94,107.28 105.18,107.28 UC1.AT42 105.04,107.35 104.97,107.28 103.61,107.28 UC1.AT43 UC1.AT46 101.9,107.28 100.85,107.28 100.81,107.32 UC1.AT49 100.35,107.34 99.66,107.34 99.54,107.22 UC1.AU51 ; UC1.AR52 98.69,108.18 98.68,108.19 98.68,108.56 98.69,108.58 UC1.AP52 UC1.AN52 ; v2(108.21,110.48) 108.38,110.65 UC1.AL36 ; v2(98.17,111.14) 98.34,111.31 UC1.AK52 98.8,111.41 UC1.AJ52 ; UC1.AW44 103.21,105.59 103.54,105.93 v2(103.54,105.94) 103.56,105.94 103.86,106.24 UC1.AV43 ; UC1.AL60 93.93,109.92 93.94,109.9 93.94,109.61 93.93,109.6 UC1.AN60 93.93,108.67 93.94,108.65 93.94,108.17 v2(93.84,108.06) ; UC1.AL60 93.93,110.89 93.94,110.91 93.94,111.19 93.93,111.21 UC1.AJ60 93.93,112.05 94.12,112.24 ; UC1.AL60 UC1.AL61 92.8,110.4 v2(92.77,110.37) ; v2(98.18,110.33) 98.51,110.66 98.69,110.66 UC1.AL52 ; v2(118.56,106.06) 118.53,106.1 UC1.AV20 UC1.AU20 ; v2(90.95,112.89) 91.03,112.97 UC1.AG63 UC1.AG62 UC1.AG61 UC1.AG60 94.12,112.78 94.12,112.24 ; UC1.AY18 119.74,104.41 v2(119.67,104.35) ; UC1.AU30 112.02,107.38 UC1.AR31 UC1.AP31 UC1.AN31 ; UC1.AU30 111.66,107.22 111.64,107.24 UC1.AU33 ; UC1.AU30 112.59,107.22 112.6,107.24 112.89,107.24 112.91,107.22 UC1.AU28 ; UC1.AU51 UC1.AV51 UC1.AW51 UC1.AY51 99.3,104.66 99.2,104.56 v2(99.2,103.66) ; UC1.AU51 98.78,107.22 98.76,107.24 98.48,107.24 98.46,107.22 UC1.AU53 97.54,107.22 97.52,107.24 97.24,107.24 97.22,107.22 UC1.AU55 ; UC1.AN31 111.69,109.35 UC1.AN32 111.39,109.35 111.03,108.99 v2(111.03,108.95) ; UC1.AN31 UC1.AM31 UC1.AL31 112.02,111.12 v2(112.53,111.63) ; UC1.AW42 104.78,105.59 105.12,105.93 v2(105.12,105.94) 105.13,105.94 105.43,106.24 UC1.AV41 ; v2(108.21,109.18) 108.38,109.35 UC1.AN36 ; UC1.AV46 102.28,106.24 101.98,105.94 v2(101.97,105.94) 101.97,105.93 101.63,105.59 UC1.AW47 ; UC1.AW40 106.36,105.59 106.69,105.93 v2(106.69,105.94) 106.71,105.94 107.01,106.24 UC1.AV39 ; UC1.AU28 UC1.AV28 113.39,106.1 v2(113.43,106.06) ; UC1.AU33 110.88,107.21 UC1.AV33 ; v2(91.1,114.53) 91.23,114.4 UC1.AD63 ; UC1.AW35 109.54,105.59 v2(109.88,105.94) 110.19,106.24 UC1.AV34 ; UC1.AU55 UC1.AV55 96.73,106.1 v2(96.77,106.06) ; UC1.AU55 96.24,107.22 96.23,107.24 95.94,107.24 95.92,107.22 UC1.AU57 95,107.22 94.98,107.24 94.7,107.24 94.68,107.22 UC1.AU59 ; UC1.AN49 100.78,109.09 101.16,109.09 UC1.AN48 101.43,109.35 101.65,109.35 v2(101.98,109.63) ; UC1.Y59 94.25,116.72 v2(93.95,117.02) ; v2(93.84,108.06) 93.98,107.92 93.98,107.54 94.28,107.24 UC1.AU59 ; v2(93.84,108.06) 93.71,107.94 UC1.AT61 92.52,107.94 UC1.AT62 92.45,107.87 91.96,107.87 91.93,107.84 91.76,107.84 UC1.AT63 91.24,107.72 90.96,107.44 90.81,107.44 v2(90.48,107.1) ; UC1.AY57 95.52,104.4 v2(95.45,104.34) ; UC1.AU20 119.01,107.22 119.03,107.24 119.32,107.24 119.33,107.22 UC1.AU18 120.26,107.22 120.28,107.24 120.56,107.24 120.58,107.22 UC1.AU16 UC1.AV16 UC1.AW16 121.06,105.31 UC1.AY16 ; UC1.AH22 117.73,112.36 v2(117.73,111.85) 117.33,111.85 UC1.AJ23 ; UC1.AU59 UC1.AV59 UC1.AW59 ; UC1.AB7 126.34,115.82 v2(126.52,115.99) ; UC1.Y63 91.03,116.64 v2(90.86,116.48) ; UC1.AN63 91.16,109.19 90.93,108.95 v2(90.7,108.95) ; UC1.AY22 117.31,104.38 v2(117.37,104.32) ; UC1.AY30 112.18,104.41 v2(112.11,104.34) ; UC1.AN23 116.66,109.35 v2(116.34,109.03) 116.66,108.7 UC1.AP23 ; UC1.P63 91.16,119.64 v2(91.11,119.69) ; UC1.AV34 110.58,106.57 UC1.AV33 ; UC1.AW50 100.13,105.75 100.21,105.75 100.39,105.93 v2(100.39,105.94) 100.41,105.94 100.67,106.21 100.77,106.21 UC1.AV49 ; v2(97.72,104.04) 97.88,104.19 97.88,104.58 97.94,104.64 97.94,105.27 UC1.AY53 ; UC1.AM23 116.66,110 v2(116.34,110.33) 116.42,110.33 UC1.AL23 116.42,110.98 v2(116.33,110.98) 116.66,111.31 UC1.AK23 116.42,111.63 v2(116.34,111.63) 116.34,112.26 UC1.AH24
  BOTTOM w0.203: UC1.AR15 122.09,107.87 ; 122.09,107.87 122.07,107.87 v2(121.71,108.23) 121.55,108.39 UC1.AR17 ; 122.09,107.87 v2(121.76,107.54) 121.44,107.22 UC1.AU16 ; PU502.3 111.1,142.44 v2(111.03,142.37) ; v2(129.28,110.98) 129.28,111.11 128.99,111.4 UC1.AK3 ; UC1.AT49 100.37,107.9 UC1.AR49 100.71,108.05 101.03,108.38 ; v2(92.65,124.51) 92.95,124.21 UC1.F61 ; UC1.AU1 130.29,106.91 v2(130.84,106.37) ; v2(121.15,104.28) 121.13,104.29 121.13,105.23 UC1.AY16 ; UC1.AR11 123.84,107.66 123.33,107.66 v2(123.12,107.87) ; UC1.AN45 103.2,109.35 103.13,109.28 102.75,109.28 102.67,109.35 UC1.AN46 102.26,109.35 v2(101.98,109.63) ; v2(129.28,119.95) 129.28,119.98 128.98,120.28 UC1.N3 ; v2(97.28,108.38) 97.6,108.7 UC1.AP54 ; v2(91.07,122.76) 91.19,122.64 UC1.J63 ; UC1.R8 UC1.R10 ; UC1.V3 128.98,117.29 129.27,117 v2(129.27,116.95) ; UC1.A24 116.25,128.02 116.59,128.36 v2(116.6,128.36) ; v2(123.59,117.56) 123.59,116.61 123.72,116.47 UC1.Y10 ; UC1.AH20 118.63,112.1 v2(118.44,111.9) 118.32,112.02 UC1.AG21 ; UC1.N21 118.59,120.05 118.45,119.92 118.45,119.91 118.19,119.64 117.81,119.64 117.71,119.74 UC1.P22 v2(116.79,119.74) ; UC1.AL45 103.14,110.39 v2(102.94,110.39) 102.74,110.39 UC1.AL46 ; PU501.19 92.16,140.03 92.16,140.03 92.18,140.03 v2(92.18,140.01) ; v2(127.88,114.03) 127.64,113.8 UC1.AE5 ; UC1.AV14 122.37,106.24 v2(122.03,105.9) ; v2(129.28,113.98) 128.98,114.28 UC1.AD3 ; UC1.L61 92.95,121.21 v2(92.65,121.51) ; UC1.AN48 UC1.AP48 ; UC1.AW4 128.3,104.99 UC1.AY4 128.35,104.58 v2(128.49,104.44) ; UC1.W20 119.23,117.3 v2(119.63,117.71) 119.23,118.11 UC1.U20 ; UC1.A56 UC1.B56 ; v2(94.1,104.39) 94.19,104.48 UC1.AY59 ; v2(95.37,108.38) 95.7,108.7 UC1.AP57 ; v2(205.07,63.43) 204.84,63.2 204.84,62.16 204.99,62.01 PU800.17 ; v2(105.76,109.03) 106.08,109.35 UC1.AN40 ; v2(92.09,138.74) 92,138.83 PU501.22 ; UC1.B32 111.14,126.7 111.14,127.15 111.24,127.25 UC1.A32 ; v2(92.65,115.52) 92.95,115.22 UC1.AC61 ; UC1.AG1 v2(130.79,112.86) ; UC1.AP39 106.47,109.03 UC1.AN40 ; UC1.R22 v2(116.79,118.93) ; UC1.D2 129.63,125.57 v2(129.3,125.9) ; v2(88.61,125.36) 89.32,126.07 90.65,126.07 91.13,125.6 UC1.D63 91.71,125.54 UC1.D62 ; UC1.AM52 98.37,110.33 v2(98.18,110.33) ; UC1.AR43 104.21,108.05 v2(103.89,107.73) 103.54,107.38 UC1.AT43 ; UC1.AW60 93.95,105.59 UC1.AW59 ; v2(193.44,112.44) 193.4,112.47 192.49,112.47 UV1.AL2 ; UC1.A52 98.63,127.17 98.63,126.67 UC1.B52 ; v2(98.22,109.7) 98.36,109.7 98.69,109.37 UC1.AN52 98.8,109.35 98.94,109.22 99.32,109.22 99.45,109.35 UC1.AN51 99.78,109.35 99.89,109.25 100.27,109.25 100.37,109.35 UC1.AN49 ; UC1.A48 UC1.B48 ; UC1.AN40 106.47,109.68 UC1.AN39 ; UC1.AH16 121.16,111.88 120.77,111.88 UC1.AH17 120.48,112.1 v2(119.94,111.55) ; UC1.U22 v2(116.79,118.11) ; v2(124.04,104.17) 123.91,104.31 UC1.AY11 ; UC1.AL51 99.45,110.65 v2(99.13,110.33) ; v2(126.99,104.4) 126.9,104.49 UC1.AY6 ; v2(130.79,121.85) UC1.K1 ; v2(89.12,136.58) 89.02,136.68 PU501.29 ; v2(92.65,118.52) 92.95,118.22 UC1.U61 ; UV1.F25 174.7,132.7 174.31,132.31 174.09,132.31 174.09,132.3 v2(173.69,132.3) ; v2(113.11,112.52) UC1.AJ29 ; UC1.D59 94.38,125.36 94.9,124.83 UC1.F58 ; v2(130.81,118.85) UC1.T1 ; v2(125.03,105.94) 125.14,105.94 UC1.AV8 ; UC1.AL54 97.6,110.65 v2(97.28,110.33) ; UC1.E17 120.94,124.95 v2(120.61,125.28) ; UC1.P59 94.9,118.95 UC1.T58 ; UC1.AM1 v2(130.82,109.86) ; UC1.P63 UC1.P62
  BOTTOM w0.229: UC1.J22 116.71,122.18 v2(116.54,122.01) ; UV1.G6 190.08,131.52 190.08,130.68 v2(190.07,130.66) ; UC1.M22 v2(116.79,120.55)
  BOTTOM w0.254: v2(186.88,113.54) 187.26,113.93 UV1.AJ10 ; v2(186.88,113.54) 186.52,113.9 UV1.AJ11 ; v2(186.88,113.54) 186.44,113.1 UV1.AK11 UV1.AL11 ; v2(191.91,135.68) 191.91,135.26 UV1.A3 ; v2(178.4,135.89) 178.26,135.76 UV1.B21 ; v2(189.95,117.16) 190.02,117.1 UV1.AE6 ; v2(112.53,111.63) 112.85,111.96 UC1.AJ29 113.43,111.96 UC1.AH28 114.08,111.96 UC1.AJ27 ; v2(123.9,119.47) 124.04,119.33 UC1.R10 124.77,119.36 124.77,120.25 UC1.N10 ; UC1.AG11 123.41,113.19 UC1.AF12 ; UC1.AG11 123.81,112.88 UC1.AF11 124.54,113.61 124.71,113.61 124.72,113.61 UC1.AE10 ; UC1.AG11 123.76,112.78 v2(123.39,112.42) ; v2(112.49,123.86) 112.49,123.87 UC1.F30 UC1.D30 ; UC1.AR39 UC1.AP39 UC1.AN39 106.74,110.17 v2(106.58,110.33) 106.47,110.33 UC1.AL40 106.47,110.98 UC1.AL39 106.74,111.11 v2(107.25,111.63) 107.25,111.63 UC1.AH38 107.02,112.52 v2(106.6,112.52) ; UC1.AR39 106.69,108.33 UC1.AT40 ; UC1.AR39 107.14,108.38 v2(107.22,108.46) 107.4,108.46 UC1.AP38 ; UC1.AH36 108.79,112.52 v2(109.21,112.52) ; UV1.AV17 181.46,107.48 v2(181.68,107.27) 181.91,107.5 UV1.AW16 ; UV1.AR5 191.22,109.2 v2(191.63,109.61) ; UC1.AB10 124.37,115.09 v2(123.78,115.09) ; UV1.AJ28 171.54,113.9 v2(171.33,113.68) ; UV1.AL6 UV1.AK7 UV1.AL8 188.86,112.3 v2(188.48,111.93) 188.06,111.51 UV1.AM9 UV1.AN8 188.86,110.65 v2(189.25,110.27) 189.61,109.9 UV1.AP7 ; UC1.AT13 123.03,107.87 v2(123.12,107.87) ; v2(68.61,103.6) 68.7,103.51 JXDP1.20 ; v2(184.66,135.56) UV1.B13 ; UC1.AB22 117.67,115.46 118.09,115.04 118.09,114.99 v2(118.22,114.86) 118.59,114.49 UC1.AD21 ; UV1.A37 166.06,135.14 v2(165.66,135.55) ; UV1.G34 167.51,131.9 v2(167.16,131.55) 167.61,131.1 UV1.H34 167.48,130.91 167.48,130.49 UV1.J34 UV1.K34 167.66,129.4 v2(167.35,129.09) 167.66,128.78 UV1.L34 UV1.M34 UV1.N34 ; UC1.AH32 111.04,112.17 v2(111.04,111.63) ; v2(165.25,129.78) 165.26,129.78 UV1.K39 ; UV1.G33 UV1.F33 UV1.F34 167.66,132.97 v2(167.45,133.18) 167.23,133.4 UV1.E35 ; UC1.F58 94.9,124.02 v2(94.77,123.89) 95.19,123.47 UC1.H57 ; UV1.B9 187.86,135.33 v2(187.76,135.43) ; v2(168.11,121.8) 167.66,121.35 UV1.Y34 ; v2(114.4,110.3) 114.76,110.65 UC1.AL26 ; v2(164.71,132.59) 164.8,132.5 UV1.F39 ; v2(171.29,110.28) 170.87,110.7 UV1.AN30 ; UC1.L7 126.08,120.97 v2(126.08,120.7) ; UC1.AH49 100.86,112.17 v2(100.86,111.72) ; v2(193.47,114.23) 193.36,114.11 192.47,114.11 UV1.AJ2 ; v2(170.1,135.82) 170.31,135.61 170.31,134.75 UV1.B31 ; UV1.U34 UV1.T34 167.66,124.9 v2(167.08,125.49) 167.65,125.49 UV1.R34 UV1.P34 167.54,126.42 167.54,126.98 UV1.N34 ; UV1.U34 UV1.V34 ; UV1.U34 167.13,123.9 v2(167.07,123.96) ; v2(128.68,122.99) 128.98,123.29 UC1.G3 ; v2(101.98,111.72) 102.47,111.72 UC1.AJ45 103.03,112.28 UC1.AH44 103.68,112.28 UC1.AJ43 104.24,111.72 v2(104.77,111.72) ; v2(101.98,111.72) 102.05,111.79 UC1.AH46 ; v2(101.98,111.72) 101.63,111.72 UC1.AJ47 101.22,111.96 100.98,111.72 v2(100.86,111.72) ; UC1.E11 123.54,125.28 v2(123.46,125.28) 123.54,125.36 UC1.D12 ; UC1.AJ35 v2(109.21,112.52) ; v2(109.21,112.52) 109.62,112.52 UC1.AH34 109.86,111.85 v2(110.01,111.7) ; UV1.K7 189.66,129.52 190.44,130.3 UV1.J6 190.89,130.3 v2(191.05,130.46) ; UC1.AE58 95.42,113.64 v2(95.53,113.53) ; UV1.F29 171.66,132.64 v2(171.32,132.3) ; v2(186.09,135.87) 186.28,135.68 186.28,134.71 UV1.B11 ; UV1.H31 UV1.J31 UV1.K31 169.65,129.09 v2(169.65,129.01) 169.65,128.92 UV1.L31 170.06,128.31 v2(169.75,128) 170.06,127.68 UV1.N31 ; v2(119.94,111.55) 119.75,111.74 UC1.AH19 ; RP41.6 144,114.3 v2(144.17,114.48) 143.85,114.8 RP41.5 ; UC1.AL10 124.97,110.45 v2(125.05,110.45) ; UV7.J10 207.96,135.09 v2(208.36,134.69) ; v2(114.43,108.38) 114.49,108.38 114.81,108.7 UC1.AP26 ; UV1.H39 164.85,130.9 v2(164.74,131.01) ; UC1.D42 UC1.F42 104.97,123.87 v2(104.97,123.86) ; v2(184.5,129.27) 184.27,129.5 UV1.K14 ; UC1.L13 122.91,121.41 123.32,121.01 v2(123.45,121.01) 123.39,121.07 UC1.K12 ; v2(164.73,121.22) 164.75,121.22 164.84,121.3 UV1.Y39 ; UC1.D38 UC1.F38 107.48,123.87 v2(107.47,123.86) ; UV1.AA2 192.84,120.5 v2(192.94,120.6) ; v2(120.23,120.58) 120.06,120.75 UC1.L18 119.16,121.43 UC1.L20 ; UV1.V39 164.87,122.9 164.74,122.78 v2(164.73,122.78) ; RP41.7 143.96,113.8 v2(144.17,113.59) 143.88,113.3 RP41.8 ; v2(112.53,110.33) 112.58,110.33 112.9,110.65 UC1.AL29 ; UC1.AJ13 123,111.28 122.7,110.98 UC1.AL13 122.19,111.31 UC1.AJ14 121.74,111 v2(121.74,110.8) 121.55,110.99 UC1.AL17 ; v2(168.8,135.18) 168.66,135.05 UV1.B33 ; UV1.AN2 193.17,110.9 v2(193.27,110.8) ; DI1.3 DI1.8 v2(18.63,62.92) ; UV1.U6 190.19,123.63 190.19,123.48 v2(189.93,123.22) 189.93,122.98 190.46,122.45 UV1.W6 ; UV1.AN34 167.66,110.73 v2(167.21,111.19) 166.86,111.53 UV1.AM35 ; UC1.D12 UC1.D14 122.35,126.19 UC1.C14 122.36,126.39 122.36,127.45 UC1.A14 ; UC1.D12 123.92,126.17 UC1.C11 ; UC1.G8 125.92,123.65 v2(126.27,123.31) 126.61,123.65 UC1.G6 126.82,123.56 127.58,123.56 UC1.G5 ; JLVDS.3 213.51,177.85 v2(213.58,177.91) ; v2(167.32,116.73) 167.66,117.07 UV1.AE34 ; v2(167.1,127.15) 167.15,127.1 UV1.N34 ; UV1.L6 190.46,128.77 v2(190.15,129.08) ; UV1.AN10 UV1.AP9 188.05,109.9 v2(187.68,109.52) ; DI4.3 DI4.8 v2(19.52,49.77) ; v2(106.6,112.52) 106.19,112.52 UC1.AH40 105.82,112.15 v2(105.82,111.73) 105.53,111.73 UC1.AJ41 105.07,111.72 v2(104.77,111.72) ; v2(106.6,112.52) UC1.AJ39 ; UV1.AP27 173.26,109.95 v2(173.66,110.34) 173.31,110.7 UV1.AN27 ; UV1.AF39 165.02,116.5 164.64,116.88 v2(164.54,116.88) ; UV1.N6 190.72,127.1 v2(190.93,127.31) ; UV1.AW35 166.96,107.43 v2(167.41,106.98) 167.86,107.43 UV1.AW34 ; v2(126.97,109.22) 126.81,109.22 UC1.AN7 ; v2(186.27,109.39) 186.46,109.58 UV1.AP11 186.46,110.5 UV1.AN11 UV1.AM11 ; v2(117.18,108.38) 117.23,108.38 117.56,108.7 UC1.AP22 ; UC1.V58 v2(95.45,117.54) ; UC1.D34 UC1.F34 109.99,123.87 v2(109.98,123.86) ; UC1.AL33 110.88,110.33 v2(111.06,110.33) ; v2(184.69,133.34) 184.69,132.88 UV1.F13 ; v2(115,123.86) 115,123.87 UC1.F26 UC1.D26 ; v2(118.71,124.63) 118.77,124.63 UC1.F20 ; UV1.E39 UV1.C39 164.7,134.3 164.62,134.38 v2(164.62,134.54) ; v2(187.67,133.09) 188.06,132.7 UV1.F9 ; v2(93.95,123.01) 94.25,122.71 UC1.J59 ; UC1.B20 118.57,127.07 118.89,127.07 v2(118.91,127.1) 118.91,126.78 118.77,126.64 UC1.C20 ; v2(181.85,133.21) 181.85,132.89 UV1.F17 ; v2(172.43,110.41) 172.14,110.7 UV1.AN29 ; UV1.P39 v2(164.76,126.1) ; UV1.AW30 171.06,106.99 v2(171.25,106.79) ; UV1.J2 193.45,130.1 193.77,130.42 v2(193.77,130.54) ; UV1.AN19 180.41,110.84 180.41,110.85 180.64,111.08 v2(180.85,111.08) 181.12,111.08 181.46,110.74 UV1.AN17 ; UV1.G2 192.83,131.7 v2(192.94,131.81) ; UV1.AK39 165.1,113.3 v2(164.62,113.78) ; v2(216.51,176.91) JLVDS.9 ; v2(192.93,117.41) 192.82,117.3 UV1.AE2 ; UV1.AL23 176.83,112.3 v2(177.23,111.9) ; v2(190.78,113.52) 190.47,113.83 190.47,113.9 UV1.AJ6 ; v2(176.92,133.08) 176.88,133.08 176.49,132.7 UV1.F23 ; UC1.A24 UC1.B24 ; UC1.H13 122.59,123.33 v2(122.52,123.33) ; UV1.AV27 173.46,107.41 v2(173.83,107.04) 174.26,107.48 UV1.AW26 ; UV1.B29 171.86,134.72 171.67,134.91 171.67,135.52 v2(171.47,135.71) ; UV1.M39 164.8,127.7 v2(164.73,127.63) ; PU600.8 220.04,94.61 220.12,94.69 220.48,94.69 220.75,94.41 v2(220.75,94.29) ; v2(219.38,176.7) 219.51,176.56 JLVDS.15 ; UV1.AR28 172.4,109.1 v2(172.11,109.39) 172.46,109.74 UV1.AP28 ; v2(169.11,148.06) 168.71,147.66 UV5.J10 ; v2(183.62,107.06) 183.86,107.31 UV1.AW14 ; v2(186.08,132.4) 186.37,132.7 UV1.F11 ; UC1.AP29 112.59,108.38 v2(112.54,108.38) ; v2(183.25,132.14) 183.26,132.16 UV1.F15 ; UV1.F31 170.07,132.7 v2(170.46,132.31) ; v2(97.44,123.86) 97.45,123.87 UC1.F54 UC1.D54 ; v2(104.77,111.72) 104.65,111.84 UC1.AH42 ; UC1.L15 121.96,121.41 v2(121.58,121.03) 121.19,121.43 UC1.L17 ; UV1.AL14 183.68,112.3 v2(183.22,112.76) ; UC1.AJ56 96.53,111.96 UC1.AH55 97.18,111.96 UC1.AJ54 97.83,111.96 UC1.AH53 98.15,111.16 v2(98.17,111.14) ; UV1.AP16 182.46,109.9 182.12,110.24 v2(182.09,110.24) 181.99,110.24 181.66,109.91 UV1.AP17 ; UV1.AH39 165.11,114.9 164.82,114.62 v2(164.61,114.62) ; v2(119.66,116.32) 119.66,116.32 119.19,115.85 119.19,115.78 119.1,115.69 UC1.AB20 ; v2(109.16,109.03) 109.22,109.03 UC1.AN35 ; v2(100.86,111.72) 100.34,111.72 100.11,111.96 UC1.AJ50 99.78,111.96 UC1.AH51 99.13,111.96 UC1.AJ52 ; UV1.F27 173.29,132.7 v2(173.69,132.3) ; v2(192.06,124) 192.36,123.7 UV1.U2 ; UC1.V23 117.16,117.74 v2(116.79,118.11) ; UV1.AW22 177.46,107.14 v2(177.61,106.99) ; UC1.H17 120.68,123.33 v2(120.61,123.33) 120.44,123.49 120.41,123.49 120.25,123.65 UC1.G18 ; UC1.AF14 122.59,114.07 v2(122.05,114.62) ; v2(125.95,117.91) 125.95,117.81 UC1.V7 ; UC1.L58 v2(95.45,121.44) ; UC1.A11 123.91,128.42 124.27,128.78 v2(124.27,129.37) ; UV1.F19 179.78,132.98 v2(179.66,132.98) ; v2(127.87,126.97) 127.91,126.93 128.34,126.93 UC1.B4 ; RP51.6 129.95,133.65 v2(129.7,133.91) 129.45,133.67 RP51.5 ; v2(188.82,147.99) 188.83,147.99 189.2,147.63 UV3.J10 ; UV1.E5 191.14,133.38 190.69,133.38 190.47,133.15 190.45,133.15 190.42,133.12 190.05,133.12 v2(189.75,133.42) 189.66,133.33 UV1.F7 ; v2(118.22,118.11) 118.22,117.98 117.67,117.44 UC1.W22 ; UC1.V10 125.25,117.87 UC1.U9 ; UC1.B60 93.65,126.87 93.65,126.86 93.78,126.73 93.78,126.29 94.38,125.7 UC1.D59 ; v2(179.95,135.94) 179.86,135.85 UV1.B19 ; UV1.AR39 165.26,109.27 v2(165.65,109.66) 165.26,110.04 UV1.AP39 165.66,110.5 UV1.AN38 ; UV1.B7 189.48,134.71 189.48,135.71 v2(189.47,135.72) ; UC1.AL22 117.55,110.65 117.23,110.33 v2(117.18,110.33) ; v2(124.42,122.66) 124.73,122.35 UC1.J10 ; UV1.AC2 192.39,118.9 192.07,118.58 v2(192.04,118.58) ; JLVDS.6 215.01,177.13 v2(215.17,177.28) ; JXDP1.31 65.7,97.09 v2(65.43,97.35) ; v2(127.81,107.92) 127.66,107.92 127.38,108.19 UC1.AR5 ; v2(190.89,120.56) 190.72,120.56 UV1.AA6 ; v2(129.28,107.99) 129.28,108.1 UC1.AP3 ; v2(193.46,128.76) 193.32,128.62 192.58,128.62 UV1.L2 ; UV1.AP19 180.18,109.9 180.68,110.4 v2(180.82,110.4) 180.86,110.36 UV1.AP18 180.66,109.7 UV1.AR18 ; v2(190.94,125.67) 190.63,125.67 UV1.R6 ; UV1.AM31 170.06,111.5 v2(169.66,111.9) 169.27,112.3 UV1.AL32 UV1.AK31 ; UC1.D50 UC1.F50 99.96,123.87 v2(99.95,123.86) ; v2(190.94,118.61) 190.84,118.7 UV1.AC6 ; v2(175.41,107.04) 175.41,107.05 UV1.AW24 ; v2(178.46,133.08) 178.08,132.7 UV1.F21 ; UC1.D46 UC1.F46 102.46,123.87 v2(102.46,123.86) ; v2(130.78,115.69) 130.61,115.85 UC1.AA1 ; v2(113.11,112.52) 112.69,112.52 UC1.AH30 ; UC1.B36 108.73,126.74 108.71,126.81 108.71,127.08 108.73,127.14 UC1.A36 ; UV1.AE38 165.66,117.7 UV1.AD37 UV1.AD35 166.86,118.47 v2(167.03,118.64) 167.6,118.64 UV1.AC34 ; UV1.AG2 193.42,115.7 193.72,116 v2(193.72,116.03) ; UV9.J10 207.8,114.72 208.17,115.09 v2(208.17,115.1) ; UV1.AW20 179.06,107.08 180.11,106.03 v2(180.32,106.03) ; v2(164.77,124.4) 164.87,124.5 UV1.T39 ; UC4.7 71.1,106.82 v2(70.85,107.07) ; UC1.AF18 UC1.AF17 120.97,113.82 v2(121.02,113.87) 121.2,113.87 UC1.AF15 ; UC1.AA58 v2(95.45,116.24) ; v2(125.03,108.46) 125.01,108.46 UC1.AP10 ; UV1.B17 181.46,134.98 v2(181.07,135.37) ; JXDP1.26 67.2,99.81 67.01,99.62 65.94,99.62 65.7,99.86 JXDP1.32 ; v2(173.25,135.84) 173.46,135.63 UV1.B27 ; v2(193.39,125.3) 193.37,125.31 193.1,125.31 193.08,125.3 UV1.R2 ; v2(169.46,106.98) UV1.AW32 ; UV1.H9 v2(188.46,130.7) UV1.J8 ; UC1.AU53 97.95,107.49 98.51,108.05 UC1.AR52 ; v2(176.6,101.76) UV14.5 ; UV1.B25 175.06,135.1 v2(175.16,135.2) ; UV1.AJ33 168.46,113.88 v2(168.73,113.61) ; UV1.AP29 171.66,109.71 v2(171.41,109.46) 171.31,109.46 UV1.AP30 ; v2(192.05,121.78) 192.15,121.78 UV1.W2 ; UV1.AL34 167.6,112.24 167.32,112.24 v2(167.16,112.39) ; v2(119.09,108.38) 119.11,108.38 119.28,108.55 119.29,108.55 119.44,108.7 UC1.AP20 ; JLVDS.31 v2(227.51,176.79) ; UC1.D8 126.14,125.79 126.52,125.4 v2(127.22,125.4) 127.55,125.73 UC1.D5 ; v2(193.52,127.03) 193.39,126.9 UV1.N2 ; v2(181.96,136.13) 182.97,135.12 182.97,134.99 183.04,134.92 183.04,134.72 UV1.B15 ; v2(120.61,125.28) 120.18,125.71 UC1.D18 119.77,126.19 UC1.C18 119.79,126.39 119.79,127.09 119.71,127.16 119.71,127.53 UC1.A18 ; UV1.AB39 165.22,119.65 165,119.65 164.63,119.28 v2(164.63,119.15) ; UC1.AL57 95.51,110.65 v2(95.32,110.47) ; UC1.AJ25 115.71,112.43 116.03,112.75 116.24,112.75 116.26,112.76 v2(116.61,112.76) 117.1,112.76 UC1.AG23 ; UC1.AL20 119.46,110.65 119.13,110.33 v2(119.09,110.33) ; UV1.AG6 190.46,115.6 190.17,115.89 v2(190.17,115.89) ; v2(167.08,122.3) UV1.W34 ; UC1.B28 UC1.A28 ; v2(218.01,176.89) JLVDS.12 ; UV1.B23 v2(176.66,135.24) ; UC1.A40 UC1.B40
  BOTTOM w0.279: JXDP1.38 64.2,103.39 64.01,103.58 v2(64.01,103.63) ; v2(61.56,97.02) 61.2,96.66 JXDP1.49 ; JXDP1.26 67.2,103.56 v2(67.27,103.62) ; v2(72.99,103.6) 73.2,103.39 JXDP1.2 ; v2(65.43,97.35) 65.41,97.33 64.54,97.33 64.2,96.99 JXDP1.37 ; JXDP1.50 61.2,102.48 v2(60.94,102.74) ; JXDP1.13 v2(70.2,92.94) ; JXDP1.14 70.2,102.95 v2(69.82,103.33) ; JXDP1.19 v2(68.7,97.35) ; JXDP1.8 71.7,102.43 71.67,102.46 71.67,103.49 v2(71.55,103.61) ; v2(58.19,97.52) 58.7,97.02 JXDP1.59 ; JXDP1.7 71.7,93.42 72.18,92.94 v2(72.55,92.94) 73.2,93.59 JXDP1.1 ; JXDP1.25 v2(67.2,97.35)
  BOTTOM w0.305: UV3.C1 194.08,154.88 v2(194.08,155.31) ; UV7.L10 208,136.72 v2(208.36,136.36) ; UV1.C1 192.86,134.59 v2(193.39,135.12) ; UV5.B5 174.32,151.66 v2(174.69,151.29) ; UV5.A12 175.09,146.03 v2(174.72,145.66) ; UV7.A14 204.21,128.72 v2(204.18,128.69) ; UV3.E12 192.39,146 192.01,146.37 v2(192,146.37) ; UV5.E3 171.89,153.24 v2(171.5,152.85) ; UV1.W31 UV1.U31 169.73,124.03 v2(169.73,124.24) 169.73,124.57 UV1.T31 ; UV9.H2 v2(214.57,113.52) ; v2(204.13,134.25) 204.69,134.25 UV7.H14 ; v2(184.39,143.82) UV3.R14 UV6.C13 ; UV5.U12 v2(162.68,146.46) ; v2(163.88,143.88) 163.88,143.88 UV5.R14 UV4.C13 ; UV7.P10 207.96,139.12 v2(208.36,138.72) ; v2(205.98,140.33) 205.98,140.31 206.36,139.92 UV7.R12 v2(206.76,140.32) UV7.R11 v2(207.56,140.32) ; UV3.N1 186,155.37 v2(185.99,155.37) ; UV3.R3 v2(184.79,152.79) 184.4,152.39 UV3.R4 v2(183.99,151.99) UV3.T5 ; v2(162.68,151.26) UV5.T5 v2(163.48,152.06) UV5.R4 v2(164.28,152.86) UV5.R3 ; v2(180.87,112.4) 181.36,112.4 UV1.AL17 ; v2(203.99,108.29) 204.02,108.32 UV9.A14 ; UV3.N3 v2(186.39,152.79) ; UV7.E12 206.36,131.93 206.74,132.3 v2(206.74,132.32) ; UV7.E14 v2(204.13,131.92) ; UV3.L10 187.2,147.99 v2(187.16,147.99) ; UV9.R12 206.17,119.52 ; 206.17,119.52 v2(206.57,119.92) UV9.R11 206.97,119.52 v2(207.37,119.92) ; 206.17,119.52 206.17,119.53 205.78,119.91 v2(205.78,119.93) ; v2(205.15,133.92) 205.55,134.32 UV7.H13 ; UV9.U14 v2(204.05,121.12) ; UC1.V10 124.36,117.42 124.22,117.56 v2(124.14,117.56) ; UV5.L5 167.08,150.89 v2(167.05,150.85) ; v2(207.56,137.92) 207.96,137.52 UV7.M10 ; UV1.L11 186.71,128.7 v2(186.98,128.97) ; UV9.G10 v2(208.17,112.72) ; UV9.N12 v2(206.57,117.52) ; UV3.G5 190.8,151.51 v2(191.17,151.14) 191.6,151.56 UV3.F5 ; UV5.G5 170.29,151.58 v2(170.66,151.2) 171.09,151.63 UV5.F5 ; v2(188.79,154.39) 189.2,154.79 UV6.J1 ; UV7.N1 215.73,138.32 v2(215.73,138.32) ; UV7.C12 v2(206.76,129.92) ; UV5.N1 v2(165.48,155.43) ; v2(163.47,145.67) 163.49,145.67 163.88,146.06 UV5.R12 v2(163.48,146.46) UV5.R11 v2(163.48,147.26) ; UV3.A12 195.59,146 195.23,145.63 v2(195.23,145.59) ; UV3.E14 v2(192.4,143.77) ; UV7.B10 207.96,129.52 ; 207.96,129.52 v2(207.56,129.92) UV7.C11 ; 207.96,129.52 v2(208.36,129.92) ; v2(208.17,116.76) 208.17,116.72 UV9.L10 ; v2(192.43,155.44) 192.4,155.41 UV3.E1 ; UV9.D10 207.77,110.72 v2(208.17,111.12) ; UV9.A3 213.37,108.32 v2(212.97,107.92) ; UV3.C3 194,153.2 v2(194.39,153.59) ; UV3.P10 v2(185.59,147.99) ; UV3.H14 190.03,144.39 v2(190.42,144.78) 190.01,145.19 UV3.H13 ; v2(211.4,108.72) 211.77,109.09 UV9.B5 ; v2(213.33,142.04) 213.56,141.8 UV7.U3 ; UV5.T10 v2(163.48,148.06) ; v2(203.99,115.52) 203.99,115.52 UV9.K14 204.64,115.59 205.3,115.59 UV9.K13 ; UV7.E3 213.54,131.92 v2(213.15,132.3) ; UV7.C4 v2(213.16,129.92) ; UV9.K2 214.17,115.52 v2(213.77,115.12) ; UV9.U3 213.37,121.12 v2(213.37,121.64) ; v2(194.39,146.39) 194,146 UV3.C12 ; UV5.H13 169.49,145.25 v2(169.89,144.85) ; UV5.E1 171.89,155.47 v2(171.92,155.5) ; v2(183.99,147.19) UV3.R11 v2(183.99,146.39) UV3.R12 184.39,145.99 184,145.61 v2(183.98,145.61) ; UV9.L5 211.77,116.36 212.1,116.69 v2(212.12,116.69) ; v2(213.16,137.92) 213.56,138.32 UV7.N3 ; UV7.G10 v2(208.36,133.12) ; JBTB1.12 v2(231.61,107.63) ; UV7.D10 207.96,131.12 v2(208.36,131.52) ; UV3.M10 186.79,147.59 v2(186.39,147.19) ; UV7.A12 206.33,128.72 v2(205.96,129.08) ; UV9.E14 v2(203.94,111.52) ; UV9.A1 214.97,107.89 214.88,107.79 v2(214.88,107.8) ; v2(171.47,147.25) 171.09,147.64 UV5.F10 ; UV9.E1 215.58,111.52 v2(215.61,111.49) ; UV9.C12 v2(206.57,109.52) ; UV5.C12 v2(173.88,146.46) ; v2(208.17,109.52) 207.77,109.12 UV9.B10 v2(207.37,109.52) UV9.C11 ; v2(195.2,151.22) 194.83,151.59 UV3.B5 ; v2(165.88,152.86) 165.48,153.26 UV5.N3 ; UV7.N12 v2(206.76,137.92) ; UV3.U14 v2(182.79,143.88) ; UV9.H13 205.37,113.9 v2(204.96,113.49) 204.57,113.88 UV9.H14 ; UV5.E12 171.88,146.06 171.5,146.44 v2(171.49,146.44) ; UV5.A3 175.09,153.26 v2(175.48,152.86) ; UV9.T10 207.77,120.32 v2(208.17,119.92) ; UV4.J1 168.68,154.86 v2(168.28,155.26) 167.89,154.86 UV5.K1 167.88,154.86 v2(168.28,154.46) 167.89,154.06 UV5.K2 ; UV3.K2 188.4,153.99 v2(188.79,153.59) ; UV3.U12 v2(183.19,146.39) ; UV9.A12 v2(206.57,107.92) ; UV7.A1 215.16,128.28 215.07,128.19 v2(215.07,128.2) ; 174.28,147.66 v2(173.88,147.26) UV5.C11 ; 174.28,147.66 v2(173.88,148.06) ; 174.28,147.66 UV5.B10 ; UV5.A1 175.52,154.86 175.61,154.77 v2(175.6,154.77) ; v2(173.58,155.51) 173.49,155.42 UV5.C1 ; UV1.AL26 174.28,112.28 174.34,112.28 v2(174.76,112.7) ; UV9.R1 215.54,119.52 v2(215.54,119.52) ; UV7.M5 211.48,137.52 v2(211.43,137.57) ; v2(195.99,152.79) 195.6,153.19 UV3.A3 ; v2(166.23,151.13) 166.28,151.18 UV5.M5 ; UV7.L5 211.19,136.72 v2(211.16,136.75) ; v2(203.99,119.52) 203.99,119.52 UV9.R14 UV10.C13 ; v2(172.28,148.06) 172.68,147.66 UV5.D10 ; v2(188.4,143.81) 188.4,143.81 UV3.K14 188.33,144.46 188.33,145.13 UV3.K13 ; UV9.P10 v2(208.17,118.32) ; UV5.K13 167.82,145.19 167.82,144.53 UV5.K14 167.88,143.88 v2(167.89,143.87) ; UV9.F10 207.75,112.32 v2(207.36,111.93) ; v2(196.12,154.7) 196.12,154.7 196.03,154.8 UV3.A1 ; UV7.B5 211.96,129.49 v2(211.59,129.11) ; UV3.E3 192.4,153.17 v2(192.01,152.79) ; UV7.F10 207.94,132.72 v2(207.55,132.33) ; UV5.H1 v2(169.08,154.46) ; v2(167.45,148.06) 167.08,147.7 UV5.L10 ; v2(118.71,124.63) 118.61,124.63 118.09,125.15 UC1.D21 ; v2(212.97,117.52) 213.37,117.92 UV9.N3 ; UV5.P10 v2(165.08,148.06) ; v2(212.18,117.51) 211.79,117.12 UV9.M5 ; UC1.G22 118.04,123.8 v2(118.19,123.66) ; UV9.F5 211.74,112.32 v2(211.31,112.75) 211.69,113.12 UV9.G5 ; v2(215.62,109.83) 215.53,109.92 UV9.C1 ; UV5.U3 v2(161.76,153.26) ; UV7.R3 v2(213.16,140.32) 213.16,140.32 212.76,139.92 UV7.R4 v2(212.36,140.32) UV7.T5 v2(211.56,141.12) ; v2(212.96,111.91) 213.35,111.52 UV9.E3 ; UV7.A3 213.56,128.72 v2(213.16,128.32) ; v2(189.59,154.39) 190,154.79 UV3.H1 ; UV7.F5 211.93,132.72 v2(211.5,133.14) 211.88,133.52 UV7.G5 ; UV9.N14 v2(203.97,117.92) ; v2(165.48,143.86) UV5.N14 ; v2(208.36,140.32) 207.96,140.72 UV7.T10 ; v2(206.57,120.72) 206.17,121.12 UV9.U12 ; UV5.C3 v2(173.88,153.66) ; v2(192.79,147.99) 193.19,147.59 UV3.D10 ; UV9.C3 v2(213.77,109.52) ; UV9.U1 215.04,121.19 v2(215.04,121.64) ; 194.79,147.59 v2(194.39,147.19) 194,146.8 UV3.C11 ; 194.79,147.59 UV3.B10 ; 194.79,147.59 v2(194.39,147.99) ; UV7.R1 v2(215.73,139.92) ; UV3.R1 v2(184.39,155.37) ; UV3.A14 195.6,143.96 195.66,143.89 v2(195.66,143.88) ; UV5.E14 v2(171.89,143.83) ; UV3.C4 194,152.4 v2(194.39,152.79) ; v2(204.18,135.91) 204.18,135.92 UV7.K14 UV7.K13 ; UV7.U1 215.23,141.59 v2(215.23,142.04) ; UV7.C1 215.72,130.32 v2(215.81,130.22) ; UV3.U3 v2(182.27,153.19) ; v2(203.94,109.92) UV9.C14 ; UV9.R3 v2(212.97,119.92) 212.97,119.92 UV9.R4 v2(212.17,119.92) UV9.T5 211.77,120.32 v2(211.37,120.72) ; UV5.H14 169.56,144.39 v2(169.56,143.83) ; UV5.G10 v2(170.68,148.06) ; JBTB1.6 v2(231.5,110.03) ; JBTB.1 JBTB1.11 v2(228.56,107.63) ; UV8.J1 215.16,135.12 v2(215.56,135.52) UV7.K1 215.16,135.92 v2(214.76,135.52) UV7.K2 ; UV3.G10 v2(191.19,147.99) ; UV5.U1 162.21,154.93 v2(161.76,154.93) ; UV5.M10 v2(165.88,147.26) ; v2(186.4,152.01) 186.8,151.61 UV3.M5 186.99,151.4 187.4,151.4 UV3.L5 ; UV7.U14 204.24,141.52 v2(204.24,141.54) ; UV10.J1 v2(214.57,115.12) ; UV9.H1 v2(214.57,114.32) ; v2(204.16,138.32) UV7.N14 ; v2(191.98,147.18) 191.6,147.57 UV3.F10 ; v2(206.55,111.92) 206.55,111.91 206.17,111.53 UV9.E12 ; UV9.M10 v2(207.37,117.52) ; v2(186,143.79) UV3.N14 ; UV3.H2 v2(190.39,154.39) ; UV7.U12 v2(206.76,141.12) ; UV3.K1 v2(188.79,155.19) ; UV9.C4 v2(212.97,109.52) ; v2(173.49,143.83) UV5.C14 ; v2(204.13,130.32) UV7.C14 ; UV9.N1 215.54,117.92 v2(215.54,117.92) ; v2(175.11,143.88) 175.09,143.9 UV5.A14 ; UV8.C13 UV7.R14 204.19,139.92 v2(204.18,139.92) ; UV9.K1 v2(215.37,115.12) ; v2(182.27,154.87) 182.72,154.87 UV3.U1 ; UV5.C4 v2(173.88,152.86) ; UV7.H1 v2(214.76,134.72) ; UV5.H2 v2(169.88,154.46) ; UV3.T10 183.6,147.59 v2(183.99,147.99) ; UV3.N12 v2(186.39,146.39) ; v2(194,143.77) UV3.C14 ; UV7.H2 v2(214.76,133.92) ; UV7.E1 215.77,131.92 v2(215.81,131.88) ; UV1.P31 170.06,126.42 v2(169.79,126.69) 170.06,126.97 UV1.N31 ; UV7.C3 v2(213.96,129.92) ; UV5.N12 v2(165.88,146.46) ; UV5.U14 162.28,144.18 v2(162.53,143.94) ; UV5.R1 v2(163.88,155.43)
  BOTTOM w0.356: JDIMM2.25 127.55,74.65 127.79,74.89 128.91,74.89 v2(128.91,74.89) 129.35,74.45 JDIMM2.31 ; JDIMM2.136 163.25,66.44 v2(163.54,66.73) 163.85,66.42 JDIMM2.138 ; JDIMM1.144 v2(87.1,66.57) ; JDIMM2.172 174.05,64.07 174.25,63.87 v2(175.92,63.87) 175.85,63.94 JDIMM2.178 ; JDIMM2.48 134.45,66.65 v2(134.84,67.04) 135.67,67.04 136.25,66.46 JDIMM2.54 ; v2(99.41,75.25) 99.4,75.24 JDIMM1.185 ; v2(99.41,75.25) 100,74.66 JDIMM1.187 ; v2(99.41,75.25) 98.21,75.25 97.6,74.64 JDIMM1.179 ; v2(122.77,74.89) 122.75,74.87 JDIMM2.9 ; v2(122.77,74.89) 123.12,74.89 123.35,74.66 JDIMM2.11 ; v2(122.77,74.89) 121.19,74.89 120.95,74.66 JDIMM2.3 ; JDIMM1.136 84.7,66.44 84.84,66.58 v2(85.5,66.58) 85.3,66.38 JDIMM1.138 ; JDIMM1.28 49.9,66.58 v2(49.88,66.6) 49.53,66.6 49.3,66.37 JDIMM1.26 ; JDIMM1.161 92.2,74.82 91.77,75.25 v2(90.33,75.25) 90.4,75.18 JDIMM1.155 ; JDIMM1.43 54.4,74.59 54.13,74.86 53.18,74.86 53.18,74.85 v2(52.8,74.85) 52.6,74.66 JDIMM1.37 ; JDIMM1.168 94.3,66.26 v2(94.6,66.57) 94.9,66.27 JDIMM1.170 ; JDIMM1.66 61.3,66.29 v2(61.88,66.87) 62.69,66.87 63.1,66.46 JDIMM1.72 ; JDIMM2.20 126.05,66.37 125.82,66.6 125.25,66.6 ; JDIMM2.71 141.35,74.6 141.06,74.89 v2(140.81,74.89) 139.77,74.89 139.55,74.68 JDIMM2.65 ; v2(59.46,74.86) 59.8,74.52 JDIMM1.61 59.8,72.32 59.99,72.12 60.23,72.12 60.42,72.32 60.42,73.39 JDIMM1.63 ; JDIMM1.189 100.6,74.54 v2(101.31,75.25) 101.68,75.25 102.4,74.53 JDIMM1.195 ; JDIMM2.153 168.35,74.45 v2(167.95,74.84) 167.75,74.64 JDIMM2.151 ; v2(127.28,67.04) 127.85,66.48 JDIMM2.26 127.85,64.19 127.98,64.06 128.32,64.06 128.45,64.19 JDIMM2.28 ; JDIMM2.161 170.75,74.57 170.4,74.92 v2(169.45,74.92) 169.19,74.92 168.95,74.68 JDIMM2.155 ; v2(83.21,66.6) 83.85,66.6 84.1,66.35 JDIMM1.134 ; JDIMM2.55 136.55,74.48 136.15,74.88 v2(135.69,74.88) 134.99,74.88 134.75,74.64 JDIMM2.49 ; v2(53.05,63.49) 52.9,63.64 JDIMM1.38 ; JDIMM1.14 v2(45.7,66.85) ; 125.25,66.6 v2(125.25,66.59) ; 125.25,66.6 124.68,66.6 124.25,66.17 JDIMM2.14 ; JDIMM1.162 92.5,66.2 v2(91.98,66.73) 91.15,66.73 90.7,66.28 JDIMM1.156 ; v2(165.65,63.87) 165.65,65.25 JDIMM2.144 ; JDIMM2.139 164.15,74.45 164.56,74.86 v2(165.95,74.86) JDIMM2.145 ; JDIMM2.72 141.65,66.36 141.43,66.57 v2(140.8,66.57) 140.1,66.57 139.85,66.33 JDIMM2.66 ; JDIMM2.38 131.45,66.24 131.03,66.66 129.9,66.66 v2(129.82,66.58) 129.82,66.56 129.65,66.39 JDIMM2.32 ; JDIMM1.32 51.1,66.43 51.46,66.79 v2(51.84,66.79) ; 131.73,74.89 131.47,74.89 131.15,74.57 JDIMM2.37 ; 131.73,74.89 131.73,74.89 132.68,74.89 132.95,74.62 JDIMM2.43 ; 131.73,74.89 v2(132.07,74.89) ; JDIMM1.48 55.9,63.99 v2(55.65,63.74) 55.3,64.1 JDIMM1.46 ; JDIMM1.20 47.5,66.5 47.2,66.8 46.7,66.8 v2(46.7,66.82) ; JDIMM2.187 178.55,75.13 v2(178.65,75.24) ; JDIMM2.162 171.05,64 v2(170.87,63.82) ; v2(177.65,63.87) JDIMM2.184 ; JDIMM1.71 62.8,74.57 62.51,74.86 v2(61.88,74.86) 61.37,74.86 61,74.49 JDIMM1.65 ; JDIMM2.44 133.25,66.72 133.57,67.04 ; v2(102.64,66.72) 102.64,66.54 102.7,66.48 JDIMM1.196 ; 44.2,74.83 42.62,74.83 42.4,74.62 JDIMM1.3 ; 44.2,74.83 v2(44.22,74.85) ; 44.2,74.83 JDIMM1.9 ; v2(44.22,75.51) 44.33,75.51 44.8,75.04 JDIMM1.11 ; 133.57,67.04 133.85,66.76 JDIMM2.46 ; 133.57,67.04 v2(133.57,67.04) ; JDIMM1.139 85.6,74.64 86.21,75.25 v2(86.53,75.25) 86.88,75.25 87.4,74.73 JDIMM1.145 ; JDIMM2.19 125.75,74.45 v2(125.31,74.89) 124.27,74.89 123.95,74.57 JDIMM2.13 ; JDIMM2.185 177.95,74.67 177.7,74.92 v2(176.32,74.92) 176.15,74.75 JDIMM2.179 ; JDIMM1.49 56.2,74.51 56.54,74.85 v2(57.31,74.85) 57.69,74.85 58,74.54 JDIMM1.55 ; JDIMM1.2 42.1,66.32 42.4,66.61 v2(43.27,66.61) 43.51,66.61 43.9,66.23 JDIMM1.8 ; JDIMM2.196 181.25,64 v2(181.38,63.87) ; JDIMM1.25 49,74.61 49.24,74.86 v2(50.26,74.86) 50.38,74.86 50.8,74.44 JDIMM1.31 ; v2(100.58,63.09) 100.9,63.41 JDIMM1.190 ; v2(82.01,66.66) 82.3,66.37 JDIMM1.128 ; JDIMM2.127 160.55,74.72 v2(160.75,74.92) 162.08,74.92 162.35,74.65 JDIMM2.133 ; JDIMM2.167 172.55,74.71 172.81,74.97 v2(173.51,74.97) 173.73,74.97 173.94,74.76 173.95,74.76 174.23,74.47 174.23,74.47 174.35,74.35 JDIMM2.173 ; JDIMM2.2 120.65,66.36 120.87,66.57 v2(121.64,66.57) 122.15,66.57 122.45,66.28 JDIMM2.8 ; JDIMM1.127 82,74.86 v2(82.39,75.25) 83.2,75.25 83.8,74.65 JDIMM1.133 ; JDIMM2.134 162.65,64.25 162.21,63.81 v2(161.6,63.81) 161.09,63.81 160.85,64.05 JDIMM2.128 ; JDIMM1.44 v2(54.7,63.74) ; JDIMM1.54 57.7,66.42 58.15,66.87 v2(58.77,66.87) 59.5,66.13 JDIMM1.60 ; JDIMM2.156 v2(169.25,63.87) ; JDIMM1.173 95.8,74.4 95.42,74.78 v2(95,74.78) 94.38,74.78 94,74.4 JDIMM1.167 ; JDIMM1.13 45.4,74.57 45.69,74.86 46.76,74.86 v2(46.76,74.85) 47.2,74.42 JDIMM1.19 ; JDIMM1.153 89.8,74.92 89.47,75.25 v2(89.07,75.25) 89.2,75.12 JDIMM1.151 ; JDIMM1.172 v2(95.5,66.7) ; JDIMM1.178 97.3,66.27 97.76,66.73 v2(98.45,66.73) 98.83,66.73 99.1,66.46 JDIMM1.184 ; JDIMM2.150 v2(167.45,63.87) ; JDIMM2.189 179.15,74.65 179.43,74.93 v2(180.11,74.93) 180.78,74.93 180.95,74.76 JDIMM2.195 ; JDIMM2.168 172.85,63.97 v2(172.69,63.81) 173.32,63.81 173.45,63.94 JDIMM2.170 ; JDIMM2.63 138.95,72.32 138.82,72.19 138.54,72.19 138.35,72.38 JDIMM2.61 138.35,74.58 v2(138.61,74.84) ; JDIMM2.60 138.05,66.22 v2(137.7,66.57) ; v2(89.15,66.57) 88.9,66.32 JDIMM1.150 ; v2(179.45,63.87) JDIMM2.190
  BOTTOM w0.381: UV1.AG9 188.06,115.3 187.26,116.1 UV1.AF10 187.84,117.08 v2(188.06,117.08) UV1.AD9 ; UV1.R15 183.46,125.68 182.98,125.2 v2(182.96,125.2) ; PC312.2 148.5,157.65 149.27,158.43 PR307.2 ; UV1.AA26 174.46,120.54 v2(174.91,120.09) 175.3,119.7 UV1.AB24 ; UV1.V26 174.3,122.7 v2(173.81,122.22) ; v2(176.96,121.33) 177.11,121.33 177.46,121.68 UV1.Y22 ; v2(179.67,112.73) 179.24,112.3 UV1.AL20 ; UV1.L22 177.46,128.6 v2(177.9,128.17) 177.46,127.73 UV1.M22 ; v2(177.96,118.33) 177.96,118.28 177.46,117.78 UV1.AD22 ; UV1.AF21 178.39,116.7 v2(177.9,116.2) 177.46,115.77 UV1.AG22 ; UV1.Y15 v2(182.96,121.2) UV1.AA16 ; UV1.AB22 177.46,119.81 v2(177.96,120.31) ; v2(175.96,120.07) 176.46,120.57 UV1.AA23 ; v2(181.96,117.35) 181.61,117.7 UV1.AD17 ; v2(174.91,123.27) 175.34,123.7 UV1.U24 ; UV1.AC18 180.39,118.7 v2(180.01,119.09) 179.46,119.63 UV1.AB20 ; v2(173,125.08) 173,125.22 173.46,125.68 UV1.R27 ; v2(179.93,122.12) 179.93,122.15 179.48,121.7 UV1.Y20 UV1.AA21 ; UX2.3 209.73,164.55 v2(209.72,164.53) ; UV1.U27 173.46,123.84 v2(173.83,124.21) 174.33,124.7 UV1.T26 ; UV1.V18 180.46,122.83 v2(180.94,123.32) 181.33,123.7 UV1.U17 ; UV1.AD20 179.46,117.67 v2(179.95,117.18) 180.44,116.7 UV1.AF18 ; UV1.AG17 181.58,115.7 v2(181.94,116.06) 182.46,116.58 UV1.AF16 ; UV1.AC23 176.12,118.36 v2(175.98,118.36) 175.98,118.35 175.46,117.83 UV1.AD24 ; UV1.U20 179.14,123.37 v2(178.96,123.37) ; UV1.V21 v2(177.96,123.2) ; UV1.T13 184.51,124.7 v2(185.01,124.21) 184.5,123.7 UV1.U13 UV1.V13 ; v2(173.96,121.33) 173.83,121.33 173.46,121.69 UV1.Y27 ; v2(178.94,119.29) 178.85,119.29 178.46,118.9 UV1.AC21 ; v2(185.87,124.22) 186.35,124.7 UV1.T11 ; UV1.AC13 UV1.AD15 183.96,117.2 v2(183.99,117.2) ; UV1.AB15 v2(182.96,119.2) UV1.AC16 ; v2(175.96,121.27) 175.53,121.7 UV1.Y24 175.1,122.06 v2(174.98,122.06) ; v2(185.93,122.19) 186.07,122.19 186.46,122.59 UV1.V11 ; UV1.N26 174.84,126.32 174.84,126.31 175.45,125.7 UV1.R24 175.46,125.6 v2(175.97,125.09) 176.36,124.7 UV1.T23 ; v2(173.63,130.45) 173.22,130.45 UV1.J27 ; UV1.T18 180.12,125.05 v2(179.96,125.05) ; UV1.N21 UV1.R22 177.46,125.55 v2(176.95,125.04) ; UV1.AA18 180.29,120.7 v2(179.96,120.37) ; v2(181.96,126.26) 182.4,126.7 UV1.N16 ; UV1.Y17 v2(180.96,121.2) ; UV1.L17 181.46,128.64 v2(181.96,128.14) 181.52,127.7 UV1.M17 ; UV1.AC26 174.31,118.7 v2(173.95,118.35) 173.46,117.86 UV1.AD27 UV1.AC28 ; v2(215.87,41.3) 215.87,40.96 215.7,40.79 UI5.1 ; UV1.AU37 166.06,108.35 v2(166.52,108.81) ; UV1.T31 170.05,124.92 170.05,126.08 UV1.P31 ; UV1.AH21 v2(178.96,115.2) UV1.AG20 ; v2(181.96,125.07) 181.46,125.57 UV1.R17 ; UV1.AB27 173.45,119.7 v2(172.94,120.21) 172.46,120.69 UV1.AA28 ; UV1.AB12 185.36,119.7 v2(184.91,120.15) ; UV1.V16 182.46,122.86 v2(182.89,123.28) 183.31,123.7 UV1.U15 ; UV1.L24 UV1.M24 175.46,127.6 v2(175.89,127.18) 176.03,127.18 176.46,126.75 UV1.N23 ; v2(181.96,119.06) 181.46,119.56 UV1.AB17 ; UV1.T16 v2(182.96,124.2) ; UV1.R20 179.96,126.2 v2(179.96,126.29) 180.05,126.29 UV1.N18 ; UV1.U22 177.4,123.7 v2(176.96,123.26) 176.96,123.2 UV1.V23 ; v2(186.98,118.35) 186.63,118.7 UV1.AC11 ; UV1.T21 v2(177.96,125.2) ; v2(157.64,112.4) UV13.3
  BOTTOM w0.432: QV14.4 189.78,101.76 189.13,102.41 v2(188.75,102.41) 188.48,102.68 QV14.1
  BOTTOM w0.508: CE23.2 v2(47.21,106.99) ; PR204.2 v3(160.55,31.87) ; v2(47.96,86.22) 48.21,85.97 UL2.2 ; CL15.2 34.19,82.74 v2(34.64,82.3) 35.08,82.74 RL31.1 CL20.2 ; v2(183.22,102.6) RV122.2 183.24,103.36 RV95.2 CV81.2 184.1,104.52 v2(183.48,105.14) ; JLVDS.46 231.51,180.05 v2(231.74,179.82) ; PC707.2 v2(169.57,169.66) ; R255.1 82.62,122.99 v2(82.5,123.11) ; C5212.2 v2(84.86,119.81) ; RV146.2 CV220.2 164.59,130.86 v2(164.74,131.01) ; PC1.2 139.79,182.93 v2(140.3,183.44) 140.68,183.06 PC2.2 ; RC89.2 133.24,130.41 v2(132.95,130.41) ; JDIMM1.205 v2(38.51,57.31) ; QC3.3 v2(135.37,133.77) ; CX23.2 14.15,104.59 CX26.2 v2(13.43,104.56) ; v2(115.42,148.89) 115.42,148.89 115.1,149.2 JMINI.50 ; CC2.1 150.08,101.14 150.4,101.46 v2(150.4,102.03) ; PC708.2 166.04,170.38 165.74,170.08 v2(165.74,169.28) ; CC5.2 128.68,97.27 v2(128.81,97.4) ; DI2.1 v2(17.09,60.08) ; CX8.2 v2(223.23,171.87) ; CV111.2 180.37,102.72 v2(180.37,103.49) 180.82,103.49 181,103.31 CV112.2 ; PC803.2 207.1,64.89 v2(206.66,64.44) ; CV118.2 CV119.2 v2(187.54,103.36) 187.54,102.92 187.35,102.72 CV117.2 ; CE22.2 46.89,108.07 v2(46.57,107.75) ; ME1.1 v2(115.88,39.12) ; v2(225.39,179.82) 226.01,180.44 JLVDS.45 ; v2(119.17,131.51) 119.17,132.51 118.7,132.98 C85.2 ; PR819.1 211.1,62.47 v2(210.59,61.96) 210.98,61.58 PR834.1 ; JDIMM2.205 v2(119.2,60.01) ; v2(91.98,132.3) 91.98,131.74 C79.2 ; CV349.2 RV194.2 187.1,140.13 v2(186.72,140.51) ; PD3.1 v2(144.17,187.45) ; v2(163.73,111.83) 163.59,111.69 CV326.1 ; v2(191.96,140.58) 191.51,140.13 RV31.1 ; SW2.5 202.55,39.8 v2(202.54,39.79) ; PC106.2 210.51,21.87 v3(210.37,21.73) ; JBTB.15 v2(230.09,104.21) ; v2(202.34,136.39) 200.88,136.39 200.5,136.01 RV5.2 CV22.2 ; JBTB.18 v2(232.99,115.17) ; v2(18.37,65.06) CI2.2 20.21,65.06 CI40.2 ; v3(183.35,181.23) 183.73,181.61 PR1204.2 ; v2(33.29,92.89) CL26.2 CL22.2 ; CV95.2 v2(173,103.17) 173.13,103.3 PC849.2 ; JMINI.26 v2(105.5,151.55) ; v2(200.94,130.99) 200.5,131.43 RV163.1 ; v2(224.46,123.9) 224.46,123.9 CS16.2 ; PR602.2 221.26,93.78 221.45,93.97 v2(221.45,94.35) ; JREAD.2 v2(190.71,26.99) ; CC17.2 v2(60.94,105.34) ; JMINI.34 108.7,149.2 v2(109.07,148.82) ; R2338.2 133,100.88 RE2.1 132.13,100.64 131.67,100.17 v2(131.22,100.17) ; C63.2 v2(125.95,133.54) ; v2(199.16,39.96) 199.01,39.8 SW2.6 ; CV113.2 v2(180.37,104.2) ; CV355.2 RV41.2 v2(203.03,157.99) ; RX171.2 v2(199.86,175.67) ; JDIMM2.206 183.24,57.35 v2(182.69,57.9) ; v2(169.62,103.93) CV94.2 ; v2(15.83,101.89) CX24.2 ; CL41.1 32.99,87.89 v2(32.54,88.33) ; CV110.2 162.91,104.95 v2(163.03,104.83) ; CX33.2 CX31.2 197.79,172.67 v2(197.5,172.38) ; PC7.2 PC8.2 v2(158.98,184.89) ; RC84.1 131.04,135.17 131.16,135.05 v2(131.16,135.03) ; C2314.2 142.78,27.24 v2(142.78,26.61) ; RX34.2 v2(13.5,116.14) ; v2(202.09,38.48) 202.09,38.44 SW2.2 ; RC25.2 95.29,94.89 RC22.2 95.28,94.48 95.69,94.06 v2(95.69,93.17) ; CL35.2 35.08,93.08 v2(35.53,93.52) 35.97,93.08 CL34.2 ; UE3.5 50.07,99.37 v2(49.37,98.67) 48.8,99.24 UE3.6 ; v2(200.75,111.86) 200.31,112.31 RV169.1 ; v3(207.63,20.64) 207.89,20.91 PC105.2 ; CS17.2 223.5,110.25 221.44,108.19 v2(220.41,108.19) ; CX2.2 218.23,169.79 v2(217.64,170.37) ; JREAD.17 176.27,24.22 v2(176.37,24.12) ; v2(37.24,84.68) 37.1,84.55 CL36.1 ; PC300.2 PR301.2 v3(149.77,151.24) ; v2(210.98,102.6) 210.98,102.8 211.36,103.18 CV29.2 RV13.2 ; CC13.2 70.78,111.27 v2(71.21,111.7) ; RX170.2 199.86,179.33 199.42,179.77 198.21,179.77 v2(197.45,179.01) ; CE25.2 v2(44.73,102.17) ; v2(20.09,108.17) 20.4,107.86 QX3.3 ; v3(147.74,157.65) PC312.2 ; CI25.2 211.55,37.53 v2(211.17,37.91) 210.8,37.91 CI32.2 ; v2(51.19,111.86) JFAN.3 ; v2(133.24,186.93) PQ5.3 ; v2(20.86,117.27) RX14.2 ; CC35.2 123.1,96.49 v2(123.46,96.14) 124.28,96.96 RC101.2 RC134.2 ; v2(160.3,110.16) 160.63,109.84 RV127.2 ; CV31.2 205.26,102.73 v2(205.71,102.29) 206.15,102.73 RV15.2 ; CV215.2 v2(193.89,97.84) ; v2(174.91,102.47) RV236.2 ; v2(172.81,140.64) 172.37,140.2 RV25.1 ; v2(204.83,166.22) 205.29,165.76 206.26,165.76 206.65,166.14 RX36.2 ; JMINI.40 111.1,149.2 v2(110.79,148.89) ; PC503.2 82.83,138.8 v2(82.07,138.04) ; PC505.2 90.95,133.67 v2(90.83,133.78) ; RC21.2 93.5,95.74 RC24.2 93.24,95.75 92.68,96.32 92.68,97.96 v2(93.15,98.43) ; SW2.1 202.92,41.16 v2(202.92,41.15) ; JREAD.9 v2(183.87,26.99) ; JBTB.13 v2(227.19,104.21) ; JREAD.21 170.95,27.15 v2(170.78,27.32) ; CI19.2 14.62,35.43 CI44.2 v2(14.32,36.5) ; v2(198.59,66.47) 198.33,66.21 PR1304.2 PC1307.2 ; v2(214.23,162.42) 214.48,162.68 CX10.2 ; CX21.2 CX25.2 v2(13.43,107.25) ; CV85.1 179.86,97.45 v2(179.99,97.58) ; v2(173.48,101.92) YV1.4 ; PC210.2 v3(159.67,31.88) ; RC135.2 83.34,110.92 v2(83.02,111.24) ; CC30.2 62.2,105.67 v2(62.51,105.35) 62.7,105.16 CC14.2 ; PC313.2 v3(145.89,160.39) ; CX11.2 225.53,172.58 225.71,172.41 v2(226.28,172.41) ; v2(160.53,117.43) 160.1,117.43 159.73,117.8 CV134.2 160.04,118.34 160.35,118.34 160.88,118.87 CV132.2 CV133.2 ; v2(140.97,116.96) 140.99,116.98 C2326.2 ; v2(180.94,97.9) CV102.2 ; JRTC.2 v2(141,18.23) ; v2(88.28,131.55) RC66.2 88.28,130.86 CC27.2 ; JLVDS.43 213.01,181.05 211.8,179.83 210.12,179.83 JLVDS.41 v2(207,181.56) ; JFAN.4 v2(46.14,111.51) ; v2(210.54,60) PR836.1 PR838.1 ; RC123.2 RC88.2 RC116.2 134.41,119.76 v2(134.45,119.71) ; CI43.2 17.73,56.14 CI9.2 v2(19.16,56.14) ; JLVDS.42 236.14,179.53 v2(235.74,179.14) ; CMOS1.1 v2(112.63,42.23) ; JFAN.5 v2(53.74,111.57) ; v2(197.36,175.08) 197.36,174.77 197.68,174.45 RX35.2 ; v2(204.18,165.71) 203.99,165.9 RX26.2 ; JMINI.18 102.3,148.94 v2(102.47,148.77) ; v2(66.89,107.32) 66.89,107.51 66.69,107.71 CC29.2 ; CV202.2 v2(192.69,98.93) CV216.2 ; v2(216.75,116.57) 216.82,116.57 218.58,118.34 CS13.2 ; U2302.4 164.24,85.6 v2(164.24,85.6) ; v2(13.35,96.62) CX30.2 ; RV149.2 CV224.2 195.86,107.05 v2(195.42,106.61) 195.83,106.2 CV223.2 RV148.2 ; DI5.1 v2(15.46,46.28) ; YL2.4 v2(36.77,79.12) ; JDIMM1.206 v2(104.12,57.31) ; v2(12.42,99.29) CX28.2 13.14,99.32 CX29.2 ; JBTB.16 v2(230.09,115.06) ; v2(13.86,101.98) CX27.2 ; RC138.2 81.69,116.03 v2(81.98,116.32) ; PC508.1 v2(89.69,144.01) ; v2(220.63,168.09) 220.44,168.28 CX3.2 ; PD1.2 143.37,186.11 143.54,186.27 v2(143.54,186.45) ; RX13.2 v2(22.95,108.83) ; JMINI.4 93.5,149.3 93.83,148.97 v2(93.83,148.89) ; CV172.2 172.18,97.13 v2(172.6,96.7) 173.06,97.16 CV171.2 ; RL35.1 v2(43.72,88.32) ; v2(182.21,97.84) CV101.2 ; PR840.1 v2(211.22,56.71) ; v2(196.74,168.89) 196.93,169.08 CX35.2 ; RC133.1 122.25,133.47 C58.2 v2(121.39,132.83) ; v2(50.97,108.97) CE24.2 ; CC28.2 78.34,125.43 77.98,125.07 v2(77.98,124.26) ; CV217.2 v2(192.71,99.82) CV201.2 ; v2(191.8,104.9) RV70.1 ; DI7.1 v2(15.18,29.43) ; PD2.1 v2(140.81,190.12) ; CV316.2 CV304.2 219.24,106.47 v2(219.74,105.97) ; v2(39.53,82.93) 39.53,82.67 38.97,82.11 YL2.2 ; C86.2 115.54,136.53 115.54,134.42 v2(115.47,134.35) ; QV24.3 v2(176.91,92.18) ; CV33.2 RV17.2 200.31,113.64 v2(200.69,113.26) ; YV1.2 169.92,100.22 169.51,100.63 v2(169.06,100.63) ; PR106.2 v3(202.47,22.33) ; CV170.2 171.03,97.15 171.35,96.83 v2(171.35,96.64) ; v2(162.51,108.65) 162.4,108.76 CV82.2 ; CV399.2 RV184.2 167.87,140.18 v2(167.48,140.58) ; v2(15.21,106.92) CX22.2 ; v2(39.21,83.55) 38.75,83.1 CL37.1 ; PC202.2 v2(163.67,26.34) ; CV137.2 204.23,148.2 v2(204.5,148.46) ; RV66.2 160.61,114.74 160.13,114.74 v2(160.11,114.73) 159.61,114.73 RV84.2 ; v2(149.76,153.75) 149.6,153.9 PR306.2 ; v2(195.1,103.93) 194.77,104.26 RV68.1 ; QV25.3 173.19,93.02 v2(173.38,92.83) ; UE3.8 46.26,99.3 v2(46.96,98.6) 47.53,99.18 UE3.7 ; v2(164.62,134.54) 164.62,135.11 164.11,135.62 163.09,135.62 162.84,135.36 CV221.2 RV147.2 ; JBTB.14 v2(227.19,115.02) ; JLVDS.44 v2(218.51,179.9) ; PC203.2 v2(163.67,28.12) ; v2(28.79,13.78) RA30.2 27.27,13.78 24.73,11.24 v2(19.59,11.24) 19.46,11.24 19.14,11.56 RA29.2 ; v2(196.24,53.72) PC720.1 ; v2(47.91,90.16) 48.72,89.35 CL38.2 ; CC1.1 146,101.54 145.89,101.65 v2(145.89,102.22) ; JREAD.16 177.03,27.64 v2(177.51,28.12) ; v2(39.59,114.75) 40,115.16 QE5.4 ; C2327.2 167.15,93.3 v2(166.84,93.6) ; CV200.2 v2(191.48,97.84) ; v2(84.61,142.55) 84.55,142.48 PC522.2 ; RC122.2 v2(133.49,126.98) ; CX20.2 v2(13.44,113.48) ; PR811.1 v2(209.91,64.11) ; JBTB.17 v2(232.99,104.27) ; CC16.2 61.19,89.78 v2(60.87,89.45) ; v2(188.18,94.66) CV103.2
  vias: v2(0.5,121.9) v2(0.5,113.9) v2(0.5,76.16) v2(0.5,72.85) v2(0.5,58.35) v2(0.5,55.25) v2(0.5,40.75) v2(0.5,37.71) v2(0.5,23.1) v2(0.5,21.9) v2(4.73,119.81) v2(4.73,117.27) v2(5.49,95.3) v2(5.81,74.54) v2(5.88,113.9) v2(5.88,97.4) v2(5.93,56.82) v2(6,39.1) v2(6.51,121.9) v2(6.5,93.44) v2(6.5,76.16) v2(7.12,37.71) v2(7.12,23.1) v2(7.27,119.81) v2(7.27,117.27) v2(8.03,95.3) v2(8.35,74.54) v2(8.47,56.82) v2(8.54,39.1) v2(11.86,121.89) v2(12.52,121.9) v2(12.5,93.44) v2(12.5,76.16) v2(16.6,119.38) v2(17.17,101.46) v2(17.17,99.68) v2(18,97.02) v2(18.13,106.8) v2(18.13,105.02) v2(18.06,98.79) v2(18.19,33.96) v2(18.41,102.1) v2(18.54,121.9) v2(18.8,10.15) v2(19.02,104.13) v2(19.02,102.35) v2(19.94,109.59) v2(20.67,119.45) v2(21.05,105.08) v2(21.62,106.54) v2(22.19,101.97) v2(22.38,62.74) v2(22.83,116.46) v2(22.83,60.89) v2(23.46,99.94) v2(24.06,10.15) v2(24.16,49.14) v2(24.16,47.99) v2(24.22,41.84) v2(24.22,41.2) v2(24.22,40.5) v2(24.54,33.02) v2(24.54,32.44) v2(24.58,102.99) v2(24.65,60.85) v2(24.86,41.9) v2(24.86,41.26) v2(24.86,40.63) v2(25.24,51.23) v2(25.24,49.46) v2(25.17,32.71) v2(27.55,58.4) v2(27.55,57.79) v2(27.8,73) v2(27.8,72.39) v2(28.15,68.56) v2(28.15,67.95) v2(28.15,52.87) v2(28.15,52.26) v2(28.16,58.4) v2(28.16,57.79) v2(28.41,73) v2(28.41,72.39) v2(28.76,68.56) v2(28.76,67.95) v2(28.76,52.87) v2(28.76,52.26) v2(29.32,10.16) v2(31.52,64.77) v2(31.52,63.5) v2(31.52,62.87) v2(31.46,61.85) v2(31.46,61.22) v2(31.46,60.07) v2(31.46,59.44) v2(34.58,10.16) v2(36.8,88.83) v2(36.8,87.94) v2(36.8,86.98) v2(37,120.4) v2(37.75,88.83) v2(37.75,87.94) v2(37.75,87.05) v2(37.94,104.51) v2(38.26,23.99) v2(38.38,25.77) v2(38.5,121.9) v2(38.64,88.83) v2(38.64,87.94) v2(38.64,86.98) v2(39.34,24.82) v2(39.84,10.16) v2(40.68,85.66) v2(40.68,85.08) v2(40.92,26.4) v2(41.11,23.17) v2(41.35,93.71) v2(41.49,119.69) v2(42.19,70.69) v2(42.19,69.17) v2(43.27,107.55) v2(43.27,62.71) v2(43.27,61.18) v2(44.22,70.69) v2(44.22,69.17) v2(44.86,63.09) v2(44.86,60.8) v2(45.1,10.16) v2(46.63,70.69) v2(46.63,69.17) v2(46.57,62.71) v2(46.57,61.18) v2(48,121.9) v2(48.43,68.68) v2(49.04,71.07) v2(49.04,68.79) v2(49.11,62.71) v2(49.11,61.18) v2(50.31,70.86) v2(50.31,69.33) v2(50.37,10.16) v2(51.53,62.71) v2(51.53,61.18) v2(52.9,70.66) v2(52.9,69.14) v2(52.9,67.61) v2(53.67,122.33) v2(54.7,71.07) v2(54.7,68.79) v2(55.63,10.16) v2(56.87,70.69) v2(56.87,69.17) v2(56.86,67.55) v2(58.77,62.71) v2(58.77,61.18) v2(59.21,123.61) v2(59.46,70.69) v2(59.46,69.17) v2(60.15,63.09) v2(60.15,60.8) v2(60.89,10.16) v2(61.88,70.69) v2(61.88,69.17) v2(61.88,62.71) v2(61.88,61.18) v2(62.4,14.99) v2(62.51,122.04) v2(63.52,45.46) v2(64.04,75.87) v2(64.04,75.05) v2(64.42,122.04) v2(64.42,76.32) v2(64.49,125.72) v2(64.86,76.76) v2(65.31,77.2) v2(69.4,128.6) v2(71.09,14.99) v2(75.47,39.37) v2(75.53,33.72) v2(75.47,29.47) v2(75.47,24.89) v2(77.11,14.99) v2(79.86,137.24) v2(82.79,70.71) v2(82.79,69.19) v2(82.76,14.99) v2(83.02,145.94) v2(83.44,62.71) v2(83.44,61.18) v2(83.49,143.69) v2(84.74,71.09) v2(84.74,68.8) v2(84.79,152.05) v2(85.3,62.71) v2(85.3,61.18) v2(85.5,159.4) v2(85.5,158.37) v2(86.53,70.71) v2(86.53,69.19) v2(87.64,62.71) v2(87.64,61.18) v2(88.02,108.25) v2(87.97,104.69) v2(88.19,109.67) v2(88.42,161.3) v2(88.42,155.52) v2(88.4,14.99) v2(88.55,140.2) v2(88.55,138.99) v2(88.79,117.82) v2(88.76,105.58) v2(88.96,122.24) v2(88.97,116.38) v2(89.03,107.93) v2(89.07,70.71) v2(89.07,69.19) v2(89.25,139.56) v2(89.15,63.09) v2(89.15,60.8) v2(89.26,123.76) v2(89.94,140.2) v2(89.94,138.99) v2(89.9,10.98) v2(90.59,70.71) v2(90.59,69.19) v2(91.26,62.71) v2(91.26,61.18) v2(91.46,101.45) v2(92.42,70.71) v2(92.42,69.19) v2(92.76,102.88) v2(93.25,101.36) v2(93.93,132.74) v2(93.93,130.85) v2(94.25,62.71) v2(94.25,61.18) v2(94.53,99.81) v2(94.57,102.65) v2(94.87,71.09) v2(94.87,68.8) v2(95.22,10.98) v2(95.76,132.8) v2(95.76,130.85) v2(95.91,101.19) v2(96.25,62.71) v2(96.25,61.18) v2(96.36,126.09) v2(96.51,70.71) v2(96.51,69.19) v2(97.29,102.57) v2(98.52,138.42) v2(98.52,134.86) v2(99.03,62.71) v2(99.03,61.18) v2(99.34,132.8) v2(99.34,130.85) v2(99.41,70.71) v2(99.41,69.19) v2(99.53,138.42) v2(99.6,134.86) v2(99.72,96.8) v2(100.23,97.07) v2(100.55,10.98) v2(100.58,60.8) v2(100.86,132.74) v2(100.86,130.83) v2(101.31,70.71) v2(101.31,69.19) v2(101.82,140.64) v2(101.82,138.42) v2(101.88,134.86) v2(101.98,62.71) v2(101.98,61.18) v2(102.71,130.84) v2(102.9,140.64) v2(102.9,138.42) v2(102.9,38.55) v2(102.96,134.86) v2(103.15,97.05) v2(103.15,96.45) v2(103.22,67.49) v2(103.22,66.85) v2(103.55,104.62) v2(103.98,76.19) v2(104.74,97.02) v2(104.74,96.41) v2(105.12,140.64) v2(105.12,138.42) v2(105.11,104.61) v2(105.18,134.86) v2(105.44,129.4) v2(105.95,35.31) v2(105.87,10.98) v2(106.2,138.42) v2(106.26,134.86) v2(106.26,17.19) v2(106.25,16.53) v2(106.79,102.5) v2(108,17.44) v2(108.49,138.42) v2(108.46,103.43) v2(109.12,38.42) v2(109.57,140.58) v2(109.57,138.42) v2(109.57,134.88) v2(109.86,100.95) v2(111.19,10.98) v2(111.41,129.6) v2(111.43,127.7) v2(111.85,140.58) v2(111.85,138.42) v2(111.98,134.86) v2(111.96,101.68) v2(111.96,100.38) v2(111.96,97.76) v2(112.55,130.42) v2(112.55,128.6) v2(112.93,140.58) v2(112.93,138.42) v2(113.58,101.03) v2(113.58,98.43) v2(115.67,101.68) v2(115.67,99.73) v2(116.09,97.32) v2(116.28,131.53) v2(116.26,129.55) v2(116.46,126.09) v2(116.51,10.98) v2(117.57,102) v2(117.57,100.32) v2(119.17,101.03) v2(119.73,25.34) v2(119.79,33.72) v2(120.04,17.85) v2(120.74,70.73) v2(120.74,69.21) v2(121.05,101.1) v2(121.05,99.05) v2(121.75,130.83) v2(121.82,62.75) v2(121.82,61.22) v2(121.83,10.98) v2(122.77,70.73) v2(122.77,69.21) v2(123.41,63.13) v2(123.41,60.84) v2(123.54,136.78) v2(123.54,136.2) v2(123.47,134.86) v2(124.04,134.86) v2(125,191.6) v2(125,185.84) v2(125,180.08) v2(125,174.32) v2(125.01,168.56) v2(125.01,162.8) v2(124.99,102.8) v2(125.12,62.75) v2(125.12,61.22) v2(125.31,70.73) v2(125.31,69.21) v2(126.95,131.36) v2(127.24,136.89) v2(127.22,136.26) v2(127.15,10.98) v2(127.66,62.75) v2(127.66,61.22) v2(127.98,71.11) v2(127.98,68.83) v2(128.62,33.72) v2(129.1,103.19) v2(129.06,25.21) v2(129.38,70.73) v2(129.38,69.21) v2(129.57,18.04) v2(130.06,177.92) v2(130.2,62.75) v2(130.2,61.22) v2(130.83,191.6) v2(132.07,70.81) v2(132.07,69.29) v2(132.47,10.98) v2(132.74,62.75) v2(132.74,61.22) v2(133.6,71.19) v2(133.6,68.91) v2(134.57,96.99) v2(135.03,62.75) v2(135.03,61.22) v2(135.1,111.47) v2(135.73,70.81) v2(135.73,69.29) v2(136.66,191.6) v2(136.79,116.98) v2(137.14,96.96) v2(137.32,62.75) v2(137.32,61.22) v2(137.79,10.98) v2(138.3,70.73) v2(138.3,69.21) v2(138.7,63.13) v2(138.7,60.84) v2(140.81,70.73) v2(140.81,69.21) v2(140.81,62.75) v2(140.81,61.22) v2(141.06,26.67) v2(141.95,26.66) v2(142.49,191.6) v2(143.12,10.98) v2(143.35,32.5) v2(143.35,31.87) v2(144.49,166.49) v2(144.55,167.5) v2(148.32,191.6) v2(148.44,10.98) v2(149.74,192.6) v2(153.31,122.04) v2(153.76,10.98) v2(154.78,134.29) v2(154.78,133.66) v2(155.01,121.78) v2(155.41,134.29) v2(155.41,133.66) v2(155.9,192.6) v2(155.86,159.31) v2(155.86,158.68) v2(156.3,109.77) v2(156.42,120.22) v2(156.49,159.95) v2(156.49,159.31) v2(156.76,121.78) v2(158.17,192.59) v2(158.18,120.22) v2(158.7,81.89) v2(159.08,10.98) v2(159.17,81.41) v2(159.59,81) v2(160.03,80.55) v2(161.24,71) v2(161.24,69.48) v2(161.24,67.95) v2(162.07,192.6) v2(163.03,71.38) v2(163.03,69.1) v2(163.57,192.59) v2(164.4,10.98) v2(165.47,71) v2(165.47,69.48) v2(165.47,67.95) v2(165.65,160.26) v2(165.9,0.5) v2(166.25,160.25) v2(166.84,160.31) v2(167.1,174.55) v2(167.41,174.04) v2(167.35,172.01) v2(167.35,170.87) v2(167.76,71) v2(167.76,69.48) v2(167.76,67.95) v2(167.92,171.44) v2(168.24,192.6) v2(168.32,160.25) v2(168.56,172.01) v2(168.56,170.93) v2(168.98,192.59) v2(168.95,160.25) v2(169.07,69.86) v2(169.07,67.57) v2(169.59,160.25) v2(170.08,28.2) v2(170.34,71) v2(170.34,69.48) v2(170.34,67.95) v2(171.24,0.5) v2(172.63,71) v2(172.63,69.48) v2(172.63,67.95) v2(173.9,71.38) v2(173.9,69.1) v2(174.4,192.6) v2(175.35,11.88) v2(175.99,39.74) v2(176.34,71) v2(176.34,69.48) v2(176.34,67.95) v2(176.57,0.5) v2(177,38.42) v2(177.07,2.35) v2(177.64,8.07) v2(177.66,191.59) v2(177.7,25.53) v2(177.7,24.83) v2(177.7,24.12) v2(178.62,71) v2(178.62,69.48) v2(178.62,67.95) v2(178.84,11.88) v2(179.93,69.86) v2(179.93,67.57) v2(180.11,76.14) v2(180.11,75.55) v2(180.89,160.25) v2(181.2,71) v2(181.2,69.48) v2(181.2,67.95) v2(181.52,160.25) v2(181.9,0.5) v2(182.16,160.25) v2(182.91,11.69) v2(183.42,7.94) v2(183.73,35.93) v2(184.33,160.25) v2(184.5,2.48) v2(184.97,160.25) v2(185.07,78.92) v2(185.39,45.84) v2(185.6,160.25) v2(185.77,43.8) v2(186.34,62.64) v2(186.4,174.99) v2(186.4,174.3) v2(186.4,173.6) v2(186.86,191.6) v2(187.04,45.07) v2(187.16,42.66) v2(187.23,0.5) v2(187.29,19.45) v2(187.29,18.86) v2(189.7,21.03) v2(189.7,20.45) v2(190.27,18.68) v2(190.27,18.1) v2(191.15,191.59) v2(191.54,159.88) v2(192.18,159.88) v2(192.38,191.6) v2(192.5,63.11) v2(192.5,62.41) v2(192.57,0.5) v2(192.81,159.88) v2(193.25,72.89) v2(193.51,20.64) v2(193.51,19.12) v2(193.83,72.89) v2(194.08,82.16) v2(194.12,66.41) v2(194.28,93.82) v2(194.47,81.46) v2(194.66,66.03) v2(194.86,93.82) v2(194.91,82.16) v2(195.22,72.89) v2(195.29,81.46) v2(195.35,66.41) v2(195.35,65.52) v2(195.74,82.16) v2(195.8,72.89) v2(196.12,81.46) v2(196.31,93.82) v2(196.56,82.16) v2(196.89,93.82) v2(196.94,81.46) v2(196.99,72.89) v2(197.39,82.16) v2(197.58,72.89) v2(197.77,81.46) v2(197.9,191.6) v2(197.9,184.1) v2(197.91,93.82) v2(198.21,82.16) v2(198.59,81.46) v2(198.59,72.89) v2(199.99,83.31) v2(201.51,83.31) v2(201.51,18.3) v2(201.51,17.72) v2(201.58,22.43) v2(201.58,21.85) v2(202.28,81.28) v2(202.28,80.39) v2(202.72,57.53) v2(202.84,171.01) v2(203.04,83.31) v2(203.1,82.36) v2(203.23,0.5) v2(203.93,82.36) v2(204.31,172.53) v2(204.56,83.31) v2(204.75,82.36) v2(204.88,60.06) v2(204.88,58.73) v2(205.39,59.42) v2(205.6,171.1) v2(205.58,82.36) v2(205.67,173.13) v2(205.96,60.06) v2(205.96,58.73) v2(206.09,83.31) v2(207.1,82.17) v2(207.1,81.28) v2(207.8,82.3) v2(208.63,82.3) v2(208.57,0.5) v2(209.45,82.3) v2(209.58,95.68) v2(210.28,82.3) v2(212.89,39.82) v2(213.9,0.5) v2(216.06,93.91) v2(216.06,93.32) v2(216.69,178.04) v2(218.15,92.76) v2(218.85,103.63) v2(219.23,0.5) v2(219.29,104.08) v2(219.29,93.27) v2(219.29,41.09) v2(219.93,41.09) v2(220.35,112.13) v2(220.35,111.49) v2(220.37,110.48) v2(220.37,109.84) v2(220.37,109.08) v2(220.44,105.29) v2(220.44,98.55) v2(220.44,97.97) v2(220.5,100.76) v2(220.63,143.18) v2(220.63,142.48) v2(220.63,141.85) v2(220.72,130.67) v2(220.72,130.04) v2(220.72,129.45) v2(220.72,128.87) v2(220.74,128.02) v2(220.73,126.51) v2(220.72,124.91) v2(220.87,133.52) v2(220.86,132.87) v2(221.45,132.87) v2(221.45,133.52) v2(221.52,43.99) v2(223.8,3.3) v2(224.56,0.5) v2(227.55,74.74) v2(227.49,73.03) v2(227.74,3.24) v2(229.9,90.45) v2(229.9,64.77) v2(229.89,25.79) v2(229.9,0.5) v2(233.2,181.1) v2(234.39,167.68) v2(234.4,164.27) v2(234.39,162.51) v2(234.4,159.11) v2(234.39,157.34) v2(234.4,153.94) v2(234.39,152.17) v2(234.4,148.77) v2(234.39,147.01) v2(234.4,143.61) v2(234.39,141.84) v2(234.4,138.44) v2(234.39,136.67) v2(234.4,133.28) v2(234.39,131.5) v2(234.4,128.11) v2(234.39,126.33) v2(234.39,119.1) v2(234.4,117.78) v2(234.4,112.62) v2(234.4,107.45) v2(234.39,106.61) v2(234.4,102.28) v2(234.39,100.36) v2(234.4,91.95) v2(236.9,174.6) v3(110.26,25.97) v3(110.93,25.96) v3(112.93,146.55) v3(112.93,145.78) v3(112.87,28.67) v3(112.87,27.99) v3(112.97,144.72) v3(112.97,143.96) v3(112.97,143.19) v3(112.97,142.43) v3(112.97,141.67) v3(113.58,146.56) v3(113.58,145.81) v3(113.67,144.72) v3(113.67,143.96) v3(113.67,143.19) v3(113.67,142.43) v3(113.67,141.67) v3(114.37,144.72) v3(114.37,143.96) v3(114.37,143.19) v3(114.37,142.43) v3(114.37,141.67) v3(116.79,146.1) v3(117.43,146.1) v3(118.06,146.1) v3(118.7,146.1) v3(128.24,166.93) v3(128.24,166.3) v3(128.87,166.93) v3(128.87,166.3) v3(129.51,166.93) v3(129.51,166.3) v3(130.14,166.93) v3(130.14,166.3) v3(130.78,166.93) v3(130.78,166.3) v3(130.97,141.02) v3(130.97,140.39) v3(130.97,139.75) v3(131.6,141.02) v3(131.6,140.39) v3(131.6,139.75) v3(134.84,141.02) v3(134.84,140.39) v3(134.84,139.75) v3(135.47,141.02) v3(135.47,140.39) v3(135.47,139.75) v3(139.04,154.6) v3(139.29,156.25) v3(139.67,154.6) v3(139.93,156.25) v3(140.31,154.6) v3(140.31,153.97) v3(140.31,153.33) v3(140.56,156.25) v3(140.62,146.93) v3(140.94,154.6) v3(140.94,153.97) v3(140.94,153.33) v3(141.2,156.25) v3(141.25,147.56) v3(141.25,146.93) v3(141.58,154.6) v3(141.58,153.97) v3(141.83,156.25) v3(141.89,147.56) v3(141.89,146.93) v3(142.21,154.6) v3(142.53,160.89) v3(143.42,160.89) v3(146.59,147.58) v3(146.59,146.94) v3(147.22,147.58) v3(147.22,146.94) v3(148.49,176.71) v3(148.49,176.07) v3(149.13,185.22) v3(149.13,184.58) v3(149.13,183.69) v3(149.13,183.06) v3(149.13,182.04) v3(149.13,181.41) v3(149.19,176.71) v3(149.19,176.07) v3(150.53,23.24) v3(150.53,22.61) v3(150.53,21.97) v3(151.17,23.24) v3(151.17,22.61) v3(151.17,21.97) v3(151.8,23.24) v3(151.8,22.61) v3(154.47,28.26) v3(155.1,28.26) v3(155.29,191.25) v3(155.29,190.62) v3(155.29,189.98) v3(155.29,189.35) v3(155.92,191.25) v3(155.92,190.62) v3(155.92,189.98) v3(155.92,189.35) v3(156.75,189.54) v3(157.38,189.54) v3(157.77,30.93) v3(157.77,30.29) v3(158.08,189.47) v3(158.09,27.31) v3(158.09,26.54) v3(158.09,24.45) v3(158.09,23.81) v3(158.72,189.47) v3(158.79,15.62) v3(158.79,14.99) v3(158.79,14.35) v3(158.91,27.31) v3(158.91,26.48) v3(159.42,15.62) v3(159.42,14.99) v3(159.42,14.35) v3(160.05,169.28) v3(160.05,168.39) v3(160.05,167.5) v3(160.06,15.62) v3(160.06,14.99) v3(160.06,14.35) v3(160.18,21.21) v3(160.75,176.26) v3(160.75,175.12) v3(160.75,174.11) v3(160.75,173.09) v3(160.68,169.28) v3(160.68,168.39) v3(160.68,167.5) v3(160.69,15.62) v3(160.69,14.99) v3(160.69,14.35) v3(160.88,21.21) v3(161,178.42) v3(161,164.71) v3(161,164.07) v3(161.32,169.28) v3(161.32,168.39) v3(161.32,167.5) v3(161.33,15.62) v3(161.33,14.99) v3(161.33,14.35) v3(161.38,176.26) v3(161.38,175.12) v3(161.38,174.11) v3(161.38,173.09) v3(161.64,178.42) v3(161.64,164.71) v3(161.64,164.07) v3(162.02,176.26) v3(162.02,175.12) v3(162.02,174.11) v3(161.95,168.14) v3(161.95,167.25) v3(161.96,15.62) v3(161.96,14.99) v3(161.96,14.35) v3(162.27,164.71) v3(162.27,164.07) v3(162.72,168.14) v3(162.72,167.25) v3(162.65,15.29) v3(162.65,14.59) v3(176.18,185.55) v3(176.18,184.91) v3(181.45,176.52) v3(181.45,175.88) v3(181.45,175.25) v3(181.45,174.61) v3(181.45,173.98) v3(182.08,176.52) v3(182.08,175.88) v3(182.08,175.25) v3(182.08,174.61) v3(182.08,173.98) v3(182.72,176.52) v3(182.72,175.88) v3(182.72,175.25) v3(182.72,174.61) v3(186.72,176.85) v3(187.29,170.99) v3(187.29,170.36) v3(187.35,176.85) v3(187.86,177.55) v3(187.93,170.99) v3(187.93,170.36) v3(187.99,176.85) v3(188.56,170.99) v3(188.56,170.36) v3(188.88,176.85) v3(189.2,170.99) v3(189.2,170.36) v3(189.96,183.28) v3(189.96,182.64) v3(191.04,184.72) v3(191.04,184.09) v3(191.67,184.72) v3(191.67,184.09) v3(192.12,189.61) v3(192.12,188.6) v3(192.12,187.58) v3(192.12,186.57) v3(192.12,185.55) v3(192.18,183.28) v3(192.18,182.64) v3(194.28,190.12) v3(194.91,190.12) v3(206.79,20.64) v3(206.79,19.8) v3(207.55,14.61) v3(207.55,13.97) v3(207.55,13.34) v3(207.55,12.7) v3(207.63,19.8) v3(208.25,28.01) v3(208.25,27.37) v3(208.25,26.74) v3(208.25,26.1) v3(208.18,14.61) v3(208.18,13.97) v3(208.18,13.34) v3(208.18,12.7) v3(208.88,28.01) v3(208.88,27.37) v3(208.88,26.74) v3(212.37,22.23) v3(212.37,21.59) v3(212.37,20.96) v3(212.37,20.32) v3(212.37,19.69) v3(212.63,22.86) v3(212.63,19.05) v3(212.63,18.42) v3(213.01,22.23) v3(213.01,21.59) v3(213.01,20.96) v3(213.01,20.32) v3(213.01,19.69) v3(213.26,22.86) v3(213.26,19.05) v3(213.26,18.42) v3(213.64,22.23) v3(213.64,21.59) v3(213.64,20.96) v3(213.64,20.32) v3(213.64,19.69) v3(213.9,22.86) v3(213.9,18.42) v3(215.23,64.57) v3(215.23,63.93) v3(215.23,63.3) v3(215.29,70.85) v3(215.29,70.03) v3(215.29,69.27) v3(215.29,68.51) v3(215.29,67.74) v3(215.29,66.98) v3(215.36,75.82) v3(215.36,75.11) v3(215.36,74.35) v3(215.36,73.59) v3(215.36,72.82) v3(215.99,64.57) v3(215.99,63.93) v3(215.99,63.3) v3(216.12,75.11) v3(216.12,74.35) v3(216.12,73.59) v3(216.12,72.82) v3(216.1,72.14) v3(216.1,71.49) v3(216.06,70.79) v3(216.06,70.03) v3(216.06,69.27) v3(216.06,68.51) v3(216.06,67.74) v3(216.06,66.98) v3(216.06,66.22) v3(216.06,65.46) v3(216.82,70.79) v3(216.82,70.03) v3(216.82,69.27) v3(216.82,68.51) v3(216.82,67.74) v3(216.82,66.98) v3(216.82,66.22) v3(216.82,65.46) v3(216.88,75.11) v3(216.88,74.35) v3(216.88,73.59) v3(216.88,72.82) v3(216.86,72.14) v3(216.86,71.49) v3(217.53,74.35) v3(217.53,73.59) v3(217.53,72.82) v3(217.52,72.14) v3(217.52,71.49) v3(217.53,70.79) v3(217.53,70.03) v3(217.53,69.27) v3(217.53,68.51) v3(217.53,67.74) v3(217.53,66.98) v3(217.53,66.22) v3(217.53,65.46) v4(25.81,33.45) v4(37.71,26.44) v4(101.12,95.66) v4(107.01,95.74) v4(114.21,96.97) v4(115.61,142.57) v4(135.4,96.92) v4(140.16,158.99) v4(144.78,152.11) v4(156.51,108.09) v4(156.99,136.04) v4(159.88,174.54) v4(160.85,170.96) v4(161.76,177.4) v4(162.03,165.92) v4(163.45,161.32) v4(164.25,14.76) v4(172.61,161.38) v4(179.98,160.23) v4(180.04,76.88) v4(180.79,175.58) v4(181.18,65.64) v4(183.37,160.89) v4(186.53,160.52) v4(186.5,160.39) v4(189.37,160.39) v4(190.64,182.44) v4(195.52,93.83) v4(195.96,83.12) v4(200.13,80.69) v4(217.54,75.1) v4(217.57,75.12) v4(219.97,40.34) v4(221.26,137.02) v4(221.56,130.01) v4(221.57,110.33)
