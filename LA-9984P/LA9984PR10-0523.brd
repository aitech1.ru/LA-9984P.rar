# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDCA0_3: length 15.3
  BOTTOM w0.102: UV1.E20 178.97,133.5 178.84,133.63 178.84,133.84 178.97,133.97 179.24,133.97 179.37,134.09 179.37,134.46 179.22,134.61 179.07,134.61 178.76,134.92 178.76,135.23 178.98,135.45 178.98,136.38 178.17,137.2
  BOTTOM w0.127: 178.17,137.2 178.13,137.23 v1(178.13,138.22) 178.13,139.07 174.72,142.49 174.72,144.64 174.51,144.85 174.13,144.85 173.72,145.26 UV4.R13
EDCA1_0: length 13.4
  TOP w0.102: 183.88,137.4 183.88,137.01 182.05,135.17 181.82,135.17 181.45,134.8 181.45,134.42 v2(181.96,133.91)
  TOP w0.127: UV3.R13 183.99,144.79 v1(183.99,141.3) 183.99,139.83 183.88,139.72 183.88,137.4
  BOTTOM w0.102: UV1.E16 182.26,133.6 v2(181.96,133.91)
EDCA1_1: length 29.8
  BOTTOM w0.102: 185.71,137.4 185.71,135.67 185.97,135.41 185.97,134.86 185.96,134.85 185.96,134.54 186.01,134.49 186.01,134.07 185.46,133.52 UV1.E12
  BOTTOM w0.127: 185.71,137.4 185.71,137.55 v1(183.84,139.42) 183.84,139.6 184,139.76 184,139.94 183.82,140.11 183.64,140.11 183.48,139.96 183.3,139.96 183.12,140.14 183.12,140.32 183.28,140.47 183.28,140.65 183.1,140.83 182.92,140.83 182.76,140.68 182.58,140.68 182.4,140.86 182.4,141.04 182.56,141.19 182.56,141.37 182.38,141.55 182.2,141.55 182.04,141.4 181.86,141.4 181.69,141.58 181.69,141.76 181.87,141.94 181.87,142.06 181.63,142.3 181.51,142.3 181.31,142.1 181.16,142.1 180.95,142.31 180.95,142.46 181.12,142.63 181.12,142.81 180.13,143.8 180.13,152.77 181.72,154.36 183.75,154.36 184.12,154 UV6.C2
EDCA1_2: length 39
  TOP w0.102: v2(186.88,130.7) 186.88,131.19 188.5,132.8 188.5,132.89
  TOP w0.127: UV3.C2 194.32,154 194.71,154.39 195.84,154.39 196.04,154.19 196.5,154.19 196.62,154.32 196.62,154.61 196.75,154.74 197.01,154.74 197.13,154.61 197.13,154.32 197.26,154.19 197.51,154.19 197.64,154.06 197.64,152.07 197.77,151.94 198.15,151.94 198.28,152.07 198.28,152.91 198.4,153.04 198.8,153.04 198.93,152.91 v1(198.93,148.88) 198.93,143.05 193,137.13 189.24,137.13 188.5,136.39 188.5,132.89
  BOTTOM w0.102: UV1.J10 187.26,130.32 v2(186.88,130.7)
EDCA1_3: length 16
  BOTTOM w0.102: UV1.D7 189.48,133.9 189.97,134.39 189.97,134.89 189.96,134.9 189.96,135.23 190.14,135.41 190.14,135.74 190.15,135.75 190.15,135.78
  BOTTOM w0.127: UV6.R13 194.23,145.19 194.64,144.79 195.02,144.79 195.23,144.58 195.23,142.46 195.1,142.34 194.97,142.34 194.85,142.21 194.85,141.96 194.97,141.83 195.1,141.83 195.23,141.7 195.23,141.45 195.1,141.32 194.97,141.32 194.85,141.19 194.85,140.94 194.97,140.81 195.1,140.81 195.23,140.69 195.23,140.09 v1(193.39,138.25) 192.54,137.4 191.73,137.4 190.15,135.82 190.15,135.78
EDCB0_0: length 21.4
  TOP w0.102: 194.39,132.5 194.21,132.5 194.21,132.51 193.96,132.77 193.4,132.77 192.78,133.39 192.22,133.39 192.18,133.35 192.18,133.35 191.74,132.92 v2(191.01,132.92)
  TOP w0.127: UV7.R13 205.56,140.15 205.39,140.32 203.99,140.32 203.8,140.13 203.69,140.13 203.58,140.25 203.43,140.25 203.1,139.92 203.1,139.74 203.37,139.48 203.37,139.3 203.19,139.12 203.01,139.12 202.74,139.38 202.56,139.38 202.38,139.2 202.38,139.02 202.69,138.71 202.69,138.53 202.51,138.36 202.33,138.36 202.02,138.66 201.84,138.66 v1(200.83,137.65) 195.68,132.5 194.39,132.5
  BOTTOM w0.102: v2(191.01,132.92) 190.81,132.92 190.59,132.7 UV1.F6
EDCB0_1: length 38.4
  BOTTOM w0.102: 194.39,130.11 194.2,130.11 193.7,129.61 192.74,129.61 192.43,129.3 UV1.K3
  BOTTOM w0.127: 194.39,130.11 194.67,130.11 196.94,132.39 196.94,133.85 197.07,133.98 197.35,133.98 197.48,134.11 197.48,134.36 197.35,134.49 197.11,134.49 196.98,134.62 196.98,134.87 197.11,135 197.35,135 197.48,135.12 197.48,135.38 197.35,135.51 197.11,135.51 196.98,135.63 196.98,135.89 197.11,136.01 197.35,136.01 197.48,136.14 197.48,136.96 199.51,139 199.51,140.1 v1(199.88,140.47) 203.35,143.94 207.7,143.94 208.04,143.61 214.25,143.61 214.67,143.18 214.68,143.18 215.94,141.92 215.94,140.78 215.48,140.32 214.98,140.32 214.57,139.92 UV8.C2
EDCB0_2: length 15.9
  BOTTOM w0.102: 194.39,125.92 193.14,125.92 193.01,125.8 192.74,125.8 192.53,126 192.16,126 UV1.P3
  BOTTOM w0.127: UV8.R13 205.56,130.08 205.15,129.67 205.15,129.29 204.94,129.08 202.56,129.08 201.99,128.51 v1(200.38,128.51) 199.57,128.51 196.98,125.92 194.39,125.92
EDCB0_3: length 31
  TOP w0.127: v2(193.39,122.99) 193.76,123.36 194.46,123.36 v1(195.69,124.59) 196.86,125.77 211.16,125.77 211.29,125.89 211.29,126.54 211.42,126.67 211.69,126.67 211.82,126.54 211.82,125.89 211.94,125.77 212.2,125.77 212.32,125.89 212.32,126.54 212.45,126.67 212.71,126.67 212.83,126.54 212.83,126.42 212.96,126.29 213.21,126.29 213.34,126.42 213.34,126.54 213.47,126.67 213.69,126.67 214.55,127.54 214.55,128.27 214.75,128.47 214.75,129.6 214.36,129.99 UV7.C2
  BOTTOM w0.102: v2(193.39,122.99) 192.96,122.56 192.74,122.56 192.62,122.69 192.3,122.69 192.15,122.53 191.63,122.53 UV1.V5
EDCB1_0: length 31.8
  BOTTOM w0.102: 194.39,120.26 194,120.26 193.12,119.38 192.74,119.38 192.68,119.45 192.25,119.45 192.01,119.2 191.72,119.2 191.54,119.38 191.54,119.52 191.73,119.71 191.73,119.85 191.61,119.98 191.29,119.98 191.23,119.92 191.23,119.74 UV1.AB5
  BOTTOM w0.127: 194.39,120.26 197.48,120.26 198.26,121.04 198.26,121.04 201.2,123.97 v1(211.14,123.97) 213.3,123.97 214.48,122.79 214.49,122.79 215.75,121.52 215.75,120.38 215.29,119.93 214.79,119.93 214.38,119.52 UV10.C2
EDCB1_1: length 15.1
  TOP w0.127: UV9.R13 204.97,119.92 203.36,119.92 203.05,120.22 v1(200.26,120.22) 199.52,120.22 195.47,116.17 v2(195.47,115.94)
  BOTTOM w0.102: 194.39,115.06 194.12,115.06 194.07,115.01 192.98,115.01 UV1.AH1
  BOTTOM w0.127: 194.39,115.06 194.59,115.06 v2(195.47,115.94)
EDCB1_2: length 39.9
  TOP w0.102: v2(187.65,113.51) 188.26,114.12 191.08,114.12 191.74,113.46
  TOP w0.127: UV9.C2 214.24,109.85 214.24,109.59 214.56,109.27 214.56,108.07 214.36,107.87 214.36,107.48 214.49,107.35 215.16,107.35 215.29,107.22 215.29,106.97 215.16,106.84 214.21,106.84 214.09,106.72 214.09,105.77 213.96,105.64 213.71,105.64 213.58,105.77 213.58,105.84 213.45,105.97 213.19,105.97 213.07,105.84 213.07,105.12 212.94,104.99 v1(204.68,104.99) 202.32,104.99 197.4,109.91 192.97,109.91 191.74,111.14 191.74,113.46
  BOTTOM w0.102: UV1.AJ9 187.65,113.69 v2(187.65,113.51)
EDCB1_3: length 16.2
  BOTTOM w0.102: 194.39,110.77 193.84,110.77 193.42,111.19 192.6,111.19 192.43,111.37 191.59,111.37 UV1.AM5
  BOTTOM w0.127: 194.39,110.77 198.32,110.77 v1(199.87,109.22) 202.81,109.22 203.33,108.7 204.77,108.7 205.01,108.94 205.01,109.39 205.37,109.75 UV10.R13
EDID_CLK: length 36.5
  TOP w0.102: RP56.3 200.54,178.48 200.67,178.62 201.07,178.62 v2(201.26,178.44) 201.25,178.44 201.42,178.61 201.97,178.61 202.15,178.43 v3(202.15,177.95) 202.15,177.42 203.02,176.55 203.02,176.02 202.92,175.93 UX4.46
  BOTTOM w0.102: v2(201.26,178.44) 201.45,178.63 202.79,178.63 203.06,178.89 223.9,178.89 224.31,178.49 228.57,178.49 229.15,177.9 229.15,176.65 229.01,176.51 JLVDS.34
EDID_DATA: length 37.3
  TOP w0.102: UX4.45 203.32,175.95 203.24,176.03 203.24,176.64 202.38,177.51 202.38,178.53 202.06,178.84 201.42,178.84 201.25,179.02 v2(201.26,179.02) 201.08,178.85 200.67,178.85 200.54,178.98 RP56.4
  BOTTOM w0.102: JLVDS.35 229.51,176.51 229.38,176.65 229.38,178 228.66,178.72 224.41,178.72 224,179.12 202.96,179.12 202.7,178.86 201.42,178.86 v2(201.26,179.02)
EDP_AUX: length 5.3
  BOTTOM w0.102: RX39.2 202.42,173.81 v3(203.51,173.81) 205.94,173.81 206.25,173.5 206.66,173.5 RX40.1
EDP_AUX#: length 5.3
  BOTTOM w0.102: RX37.2 202.38,174.08 v3(205.32,174.08) 206.05,174.08 206.36,173.77 206.66,173.77 RX38.1
EDP_BIA_PWM: length 145.1
  TOP w0.102: UX4.21 205.32,168.53 v2(205.38,168.47)
  IN1 w0.127: v2(101.69,132.64) 102.4,133.35 102.9,133.35 105.23,135.69 108.47,135.69 109.62,136.83 112.78,136.83 114.75,138.8 118.19,138.8 119.45,140.06 128.33,140.06 129.33,139.06 133.24,139.06 v2(134.59,137.71)
  IN3 w0.127: v2(205.38,168.47) 205.21,168.3 205.21,167.43 205.43,167.21 205.43,165.13 203.25,162.95 191.33,162.95 188.1,159.72 164.69,159.72 159.05,154.07 159.05,144.88 152.85,138.69 152.85,135.42 151.43,134.01 150.36,134.01 147.51,136.86 135.44,136.86 v2(134.59,137.71)
  BOTTOM w0.102: RC72.2 103.08,131.65 v1(102.28,132.45) 102.09,132.64 v2(101.69,132.64) ; RX36.1 RX49.1 205.49,167.31 205.13,167.67 205.13,168.22 v2(205.38,168.47) ; RC81.2 129.63,136.84 129.66,136.82 RC75.2 130.13,137.71 130.58,138.16 134.13,138.16 v2(134.59,137.71)
EDP_BKLCTL: length 10.6
  BOTTOM w0.076: UC1.B8 125.45,126.99 125.45,127.81 126.75,129.12 126.75,130.6 127.38,131.23 v1(127.38,133.02) 127.38,133.33 127.87,133.82
  BOTTOM w0.089: 129.21,135.15 127.87,133.82
  BOTTOM w0.102: RC81.1 129.25,135.2 129.21,135.15
EDP_COMP: length 1.9
  TOP w0.508: RC71.2 118.71,126.1 119.04,125.77 119.04,125.77 v2(119.57,125.25)
  BOTTOM w0.254: v2(119.57,125.25) 119.27,125.54 UC1.D20
EDP_CPU_AUX: length 137.6
  TOP w0.102: CX43.1 198.19,173.61 198.11,173.61 RX25.1 197.15,173.61 196.34,173.61 191.29,168.57 191.29,163.44 190.47,162.61 190.47,161.01 v2(190.64,160.83)
  IN1 w0.127: v2(190.64,160.83) 190.47,160.66 190.47,160.26 189.74,159.54 165.53,159.54 164.92,158.93 157.19,158.93 154.93,156.67 154.93,154.67 158.34,151.26 158.34,142.26 153.36,137.28 149.52,137.28 148.63,136.39 138.67,136.39 137.47,135.19 132.2,135.19 131.96,135.43 129.3,135.43 127.39,137.34 120.73,137.34 119.68,136.29 116.65,136.29 113.52,133.17 110.14,133.17 108.8,131.83 105.58,131.83 103.48,129.73 102.92,129.73 102.77,129.58 102.77,129.58 v2(102.76,129.58)
  BOTTOM w0.076: UC1.B45 103.03,127.16 102.73,127.45 102.73,128.38 103.15,128.8 103.15,129.64 103.07,129.72 102.91,129.72 v2(102.76,129.58)
EDP_CPU_AUX#: length 137.5
  TOP w0.102: v2(190.05,160.83) 190.25,161.03 190.25,162.7 191.08,163.53 191.08,168.66 196.25,173.83 197.08,173.83 RX30.2 198.07,173.88 198.2,173.88 CX44.1
  IN1 w0.127: v2(102.77,130.2) 102.96,130.01 103.37,130.01 105.47,132.1 108.68,132.1 110.02,133.44 113.41,133.44 116.54,136.56 119.57,136.56 120.62,137.61 127.51,137.61 129.41,135.71 132.07,135.71 132.31,135.46 137.36,135.46 138.55,136.66 148.52,136.66 149.41,137.55 153.24,137.55 158.07,142.37 158.07,151.15 154.66,154.56 154.66,156.78 157.08,159.2 164.81,159.2 165.42,159.81 189.63,159.81 190.19,160.38 190.19,160.69 v2(190.05,160.83)
  BOTTOM w0.076: UC1.A45 103.18,127.57 103.27,127.66 103.27,127.79 102.92,128.13 102.92,128.3 103.34,128.72 103.34,129.72 103.15,129.91 102.92,129.91 102.77,130.06 v2(102.77,130.2)
EDP_CPU_HPD: length 101.7
  TOP w0.102: UX4.1 200.78,174.59 200.24,175.12 v2(199.3,175.12) ; v1(133.18,137.87) 133.33,137.72 v2(133.76,137.72)
  IN3 w0.127: v2(199.3,175.12) 199.3,175.47 198.76,176.01 196.26,176.01 195.35,175.1 195.35,167.87 191.44,163.96 191.26,163.96 188.69,161.38 165.27,161.38 157.76,153.87 157.76,145.01 151.31,138.56 148.94,138.56 147.95,137.57 137.16,137.57 136.57,138.17 134.21,138.17 v2(133.76,137.72)
  BOTTOM w0.102: RX52.1 RX35.1 v2(199.3,175.12) ; RC105.1 132.86,133.82 133.44,134.41 QC3.2 133.44,137.4 v2(133.76,137.72)
EDP_CPU_LANE_N0: length 141.4
  TOP w0.102: v2(191.7,162.14) 191.67,162.17 191.67,162.76 191.99,163.08 191.99,168.2 195.48,171.69 198.33,171.69 CX46.1
  IN1 w0.084: 101.49,131.93 101.03,131.93
  IN1 w0.127: v2(191.7,162.14) 191.6,162.24 191.6,162.56 191.26,162.9 189.1,162.9 188.02,161.82 155.98,161.82 153,158.85 153,152.77 156.42,149.35 156.42,143.28 152.35,139.22 148.69,139.22 147.76,138.28 137.78,138.28 136.79,137.29 133.57,137.29 132.31,138.55 129.12,138.55 128.12,139.55 119.66,139.55 118.4,138.29 115.68,138.29 113.2,135.82 109.36,135.82 108.68,135.13 108.68,134.94 107.43,133.69 104.49,133.69 103.13,132.33 102.1,132.33 101.71,131.93 101.49,131.93 ; 101.03,131.93 v2(100.86,132.1)
  BOTTOM w0.076: 102.06,130.6 102.06,128.99 102.57,128.48 102.57,126.96 102.76,126.78 102.76,126.54 UC1.C45
  BOTTOM w0.102: 102.06,130.6 102.07,130.62 102.07,131.24 101.44,131.88 101.09,131.88 v2(100.86,132.1)
EDP_CPU_LANE_N1: length 139.2
  TOP w0.102: CX39.1 196.19,170.78 195.56,170.78 192.75,167.97 192.75,162.05 192.35,161.65 192.35,161.14 v2(192.72,160.77)
  IN1 w0.127: v2(192.72,160.77) 192.58,160.91 192.58,161.3 192.27,161.61 189.08,161.61 188.51,161.04 156.41,161.04 153.88,158.51 153.88,154.18 157.24,150.82 157.24,142.94 152.68,138.38 149.12,138.38 148.2,137.46 138.16,137.46 137.01,136.32 132.93,136.32 132.73,136.52 129.82,136.52 127.58,138.75 120.41,138.75 119.09,137.43 115.96,137.43 112.86,134.32 109.51,134.32 108.08,132.89 104.88,132.89 103.53,131.55 102.44,131.55 101.93,131.04 101.93,130.59 101.37,130.03 101.03,130.03 v2(100.86,130.2)
  BOTTOM w0.076: v2(100.86,130.2) 100.68,130.02 100.52,130.02 100.23,129.73 100.23,128.58 100.61,128.2 101.89,128.2 102,128.08 102,127.97 101.93,127.9 101.8,127.9 101.74,127.84 101.74,127.73 UC1.A47
EDP_CPU_LANE_P0: length 141.3
  TOP w0.102: v2(191.12,162.14) 191.46,162.48 191.46,162.85 191.77,163.17 191.77,168.29 195.39,171.91 198.03,171.91 CX42.1
  IN1 w0.127: v2(191.12,162.14) 191.33,162.35 191.33,162.44 191.15,162.62 189.21,162.62 188.14,161.55 156.09,161.55 153.27,158.74 153.27,152.88 156.69,149.46 156.69,143.17 152.47,138.95 148.81,138.95 147.87,138.01 137.89,138.01 136.9,137.02 133.46,137.02 132.2,138.28 129.01,138.28 128,139.28 119.78,139.28 118.51,138.02 115.79,138.02 113.31,135.54 109.47,135.54 108.95,135.02 108.95,134.83 107.54,133.42 104.6,133.42 103.24,132.06 102.21,132.06 101.82,131.66 101.06,131.66 v2(100.86,131.47)
  BOTTOM w0.076: 101.86,130.69 101.86,130.52 101.87,130.51 101.87,128.91 102.38,128.4 102.38,126.99 102.12,126.73 102.12,126.53 102.19,126.47 102.34,126.47 UC1.B46
  BOTTOM w0.102: 101.86,130.69 101.86,131.15 101.35,131.66 101.06,131.66 v2(100.86,131.47)
EDP_CPU_LANE_P1: length 139.3
  TOP w0.102: CX38.1 196.46,171 195.47,171 192.54,168.06 192.54,162.14 192.14,161.74 v2(192.14,160.77)
  IN1 w0.127: v2(192.14,160.77) 192.31,160.94 192.31,161.19 192.16,161.34 189.2,161.34 188.62,160.77 156.52,160.77 154.15,158.4 154.15,154.29 157.51,150.93 157.51,142.83 152.79,138.11 149.24,138.11 148.32,137.19 138.27,137.19 137.13,136.04 132.82,136.04 132.62,136.25 129.71,136.25 127.47,138.48 120.53,138.48 119.2,137.16 116.08,137.16 112.97,134.05 109.62,134.05 108.19,132.62 104.99,132.62 103.64,131.27 102.55,131.27 102.2,130.93 102.2,130.48 101.48,129.76 101.06,129.76 v2(100.86,129.56)
  BOTTOM w0.076: v2(100.86,129.56) 100.86,129.76 100.8,129.83 100.6,129.83 100.42,129.66 100.42,128.66 100.69,128.39 101.97,128.39 102.19,128.16 102.19,127.45 101.9,127.16 UC1.B47
EDP_DISP_UTIL: length 3.6
  BOTTOM w0.102: RC72.1 103.66,130.42 v1(103.66,129.8) 103.66,128.32 UC1.A43
EDP_HPD_PANEL: length 28.5
  TOP w0.102: v2(204.75,180.85) 205.46,180.85 207.31,179.01 v1(208.96,179.01) RX53.1
  BOTTOM w0.102: RX52.2 196.78,173.56 196.33,174.01 196.33,178.87 198.31,180.85 v2(204.75,180.85)
EDP_N0: length 5.3
  BOTTOM w0.102: RX44.1 206.66,171.73 203.91,171.73 203.6,172.04 v3(203.28,172.04) 202.4,172.04 RX43.2
EDP_N1: length 5.3
  BOTTOM w0.102: RX48.1 206.66,169.95 v3(203.64,169.95) 203.38,169.95 203.03,170.3 202.44,170.3 RX47.2
EDP_P0: length 5.3
  BOTTOM w0.102: RX42.1 206.66,171.99 v3(205.35,171.99) 204.02,171.99 203.71,172.3 202.39,172.3 RX41.2
EDP_P1: length 5.3
  BOTTOM w0.102: RX46.1 206.66,170.21 v3(205.5,170.21) 203.49,170.21 203.14,170.56 202.35,170.56 RX45.2
EN_0.675VSP: length 4.6
  BOTTOM w0.102: PR202.2 162,29.76 v1(162.46,30.22)
  BOTTOM w0.203: PC203.1 161.38,28.12 160.49,27.24 PU200.7
  BOTTOM w0.254: PC203.1 PR202.2
EN_1.35V: length 3
  BOTTOM w0.203: PR201.2 161.75,27.23 161.36,26.84 v1(161.09,26.84) PU200.8
  BOTTOM w0.254: PR201.2 PC202.1
EN_+1.2VSP: length 4
  TOP w0.102: PR1103.2 v1(191.2,174.28)
  TOP w0.254: PU1100.3 v2(189.13,174.3) 189.14,174.28 PR1103.2
  BOTTOM w0.254: v2(189.13,174.3) 189.03,174.19 188.93,174.19 188.78,174.04 PC1104.1
EN_DFAN1: length 192
  TOP w0.102: v2(193.38,52.15) 193.42,52.15 193.59,52.31 UE1.70
  IN3 w0.127: v2(54.77,104.32) 54.77,100.64 56.1,99.3 56.1,97.69 59.3,94.5 59.3,76.75 61.44,74.61 61.44,59.11 69.44,51.11 181.91,51.11 183.34,52.54 188.01,52.54 189.63,50.92 192.15,50.92 v2(193.38,52.15)
  BOTTOM w0.102: UE3.4 50.07,104.45 50.19,104.32 v1(53.05,104.32) v2(54.77,104.32)
EN_INVPWR: length 160.4
  TOP w0.102: v2(224.24,176.83) 224.5,177.09 224.5,178.48 223.43,179.54 QX1.2 ; UE1.68 194.39,51.86 v2(194.78,51.46)
  IN2 w0.127: v2(217.1,53.76) 217.86,54.53 217.86,56.39 222.91,61.44 222.91,80.03 221.34,81.6 221.34,89.18 224.69,92.53 224.69,122.45 225.85,123.61 225.85,148.26 222.53,151.58 222.53,164.18 222.02,164.68 222.02,172.77 222.53,173.27 222.53,175.12 v2(224.24,176.83)
  BOTTOM w0.102: v2(217.1,53.76) 216.71,54.15 216.14,54.15 215.61,53.62 215.61,53.27 v1(215.41,53.07) 212.86,50.52 204,50.52 203.83,50.69 195.56,50.69 v2(194.78,51.46)
EN_PCIE: length 1
  BOTTOM w0.102: PR1304.1 198.68,67.12 v1(198.82,67.26)
ENVDD_PCH: length 232.7
  TOP w0.089: v2(127.01,126.46) 126.85,126.62 RC87.2
  TOP w0.102: UE1.19 190.39,38.96 v2(190.33,39.02)
  IN1 w0.127: v2(167.66,88.83) 167.88,88.61 174.33,88.61 178.68,84.27 182.7,84.27 189.3,77.67 189.3,67.63 190.37,66.56 190.37,59.52 191.86,58.03 191.86,57 192.56,56.3 192.56,52.71 192.41,52.57 192.41,49.55 192.08,49.22 192.08,46.72 192.42,46.38 192.42,41.34 190.85,39.76 190.85,39.41 190.46,39.02 v2(190.33,39.02) ; v2(128.49,129.91) 128.49,130.24 129.18,130.93 136.35,130.93 139.67,134.25 143.95,134.25 145.2,133 151.4,133 v2(151.9,132.5) 151.18,131.79 151.18,127.01 152.61,125.58 152.61,121.64 157.2,117.04 157.2,115.29 161.15,111.34 161.15,106.08 164.18,103.06 164.18,102.5 v2(169.4,97.27)
  IN3 w0.127: v2(151.9,132.5) 153.27,133.87 153.27,138.55 159.46,144.74 159.46,154.13 164.79,159.46 189.96,159.46 192.56,162.07 204.64,162.07 208.18,165.61 v2(208.19,165.61)
  BOTTOM w0.089: v2(127.01,126.46) 126.92,126.37 UC1.C6 126.5,126.78 126.91,127.19 127.03,127.31 127.03,127.98 128.49,129.44 v2(128.49,129.91)
  BOTTOM w0.102: v2(208.19,165.61) 207.53,166.27 RX51.1 ; v2(167.66,88.83) 168.37,88.83 169.4,89.86 v1(169.4,94.76) v2(169.4,97.27)
ENVDD_R: length 3.4
  TOP w0.102: UX1.3 v1(217.24,170.88) 217.15,170.88 RX7.1 RX8.1
ERP_LOT6: length 161.9
  TOP w0.102: UE1.73 192.39,54.18 192.55,54.34 192.55,54.85 193.49,55.79 193.49,57.41 v2(193.31,57.58)
  IN1 w0.127: v2(123.4,149.8) 123.57,149.98 123.57,159.15 127.49,163.06 127.49,166.87 129.28,168.66 129.28,172.29 130,173.01 v2(130.18,173.01)
  IN2 w0.089: 137.81,129.22 137.92,129.11
  IN2 w0.127: v2(123.4,149.8) 127.33,149.8 136.87,140.26 136.87,130.16 137.81,129.22 ; v2(186.26,60.01) 185.75,60.52 185.75,67.67 186.52,68.44 186.52,75.95 184.12,78.36 184.12,79.38 182.66,80.83 182.46,80.83 160.59,102.7 158.03,102.7 152.91,107.82 152.91,110.17 151.87,111.21 151.87,112.92 151.07,113.72 151.07,116.7 148.53,119.24 144.47,119.24 143.51,120.2 143.51,123.52 137.92,129.11
  IN3 w0.102: v2(186.26,60.01) 186.49,60.24 190.66,60.24 v2(193.31,57.58)
  vias: v1(130.55,173.37)
F-IMAX: length 4.3
  TOP w0.102: v1(86.92,143.31) 86.83,143.22 v2(86.83,142.61)
  TOP w0.254: v2(86.83,142.61) 86.71,142.48 PR505.2
  BOTTOM w0.203: v2(86.83,142.61) 87.29,142.15 87.95,142.15 88.22,141.89 PU501.10
  BOTTOM w0.254: v2(86.83,142.61) PR504.1
FAN_SPEED1: length 212.3
  TOP w0.102: v2(168.88,49.84) 169.19,49.52 169.19,37.44 169.92,36.72 177.62,36.72 181.19,33.15 193.72,33.15 v4(193.93,33.36) 194.59,34.02 194.59,35.12 CE29.1 193.96,36.35 193.99,36.37 UE1.28
  IN3 w0.127: v2(51.38,105.67) 51.38,101.3 58.51,94.17 58.51,76.43 60.64,74.3 60.64,58.67 68.95,50.35 168.36,50.35 v2(168.88,49.84)
  BOTTOM w0.102: v2(51.38,105.67) 50.05,107 RE50.2 CE24.1 49.94,108.24 JFAN.2
FB_1.5VSP: length 4.5
  TOP w0.102: v2(109.27,17.12) v1(109.27,16.37)
  TOP w0.254: v2(109.27,17.12) 109.27,17.83 PC404.2 PR403.2 PR402.1
  BOTTOM w0.254: v2(109.27,17.12) 108.75,16.6 PU400.1
FB_1.8VSP: length 4.7
  BOTTOM w0.102: v1(220.21,89.61) 220.63,90.03 PC604.2
  BOTTOM w0.254: PU600.1 220.04,91.82 220.25,91.62 220.5,91.62 220.68,91.8 PR602.1 221.25,91.78 PR603.2 PC604.2
FB_1.35V: length 4.3
  BOTTOM w0.203: PU200.6 160.39,27.64 160.55,27.8 160.55,28.48 v1(161.09,29.02) 161.47,29.4 PR207.1
  BOTTOM w0.254: PR207.1 PR204.1
FB_3V: length 4.6
  TOP w0.102: PR107.2 v1(204.99,17.34)
  TOP w0.203: 204.76,19.51 205.06,19.82 PU100.4
  TOP w0.254: PR107.2 PC102.2 PR109.2 204.36,19.12 204.76,19.51
FB_5V: length 4.9
  TOP w0.203: PU100.2 205.09,20.62 204.71,21 v3(204.71,21.31)
  TOP w0.254: v3(204.71,21.31) 204.68,21.34 PR104.1
  BOTTOM w0.102: PR106.1 v1(204.07,23.58)
  BOTTOM w0.254: PR106.1 PC108.1 204.63,21.38 204.69,21.31 v3(204.71,21.31)
FB_+1.2VSP: length 5.1
  TOP w0.254: v2(189.13,174.88) 189.05,174.8 PU1100.4
  BOTTOM w0.102: v1(191.08,173.26) 191.08,174.37 190.57,174.88 PR1107.1
  BOTTOM w0.254: PR1107.1 v2(189.13,174.88) 189.08,174.93 PR1108.1
FB_PCIE: length 4.6
  TOP w0.102: v1(199.01,64.62) PC1306.2
  TOP w0.254: PC1306.2 PR1302.2 196.88,64.58 v2(196.29,64) 195.99,64.3 PR1301.1
  BOTTOM w0.254: PU1300.6 195.66,64.41 196.07,64 v2(196.29,64)
GCLK_VRTC: length 4.4
  TOP w0.102: RG1.2 CG5.1 65.84,48.59 65.24,47.99 64.84,47.99 64.57,47.72 v1(64.57,47.61) 64.57,47.32 64.32,47.07 UG1.10
GENLK_CLK: length 1.6
  TOP w0.102: T80.1 170.71,118.76 v2(171.24,118.24)
  BOTTOM w0.102: v2(171.24,118.24) 171.66,117.82 UV1.AD29
GENLK_VSYNC: length 1.6
  TOP w0.102: v2(171.51,119.49) 171.51,119.67 T81.1
  BOTTOM w0.102: v2(171.51,119.49) 171.66,119.34 171.66,118.9 UV1.AC29
GFX_FB-1: length 0.9
  BOTTOM w0.254: PR821.2 204.23,54.83 PC806.1
GFX_FB-2: length 2.2
  BOTTOM w0.102: v1(200.5,53.65) 201.08,53.06 PC817.1
  BOTTOM w0.254: PC817.1 202.44,53.06 PR818.2
GPIO21_BBEN: length 1.6
  TOP w0.102: v2(183.24,113.46) 183.47,113.69 T78.1
  BOTTOM w0.102: UV1.AJ14 183.42,113.46 v2(183.24,113.46)
GPIO24_TRSTB: length 2.9
  TOP w0.102: RP47.8 175.62,110.43 v2(176.08,110.89)
  BOTTOM w0.102: v2(176.08,110.89) 176.66,111.47 UV1.AM23
GPIO25_TDI: length 7.1
  TOP w0.102: RP47.7 176.12,110.19 v2(176.04,110.27)
  BOTTOM w0.102: v4(176.23,105.37) 176.23,109.18 176.14,109.27 176.14,109.31 175.97,109.48 175.97,109.89 176.04,109.96 v2(176.04,110.27) 176.47,110.7 UV1.AN23
GPIO26_TCK: length 5.5
  TOP w0.102: RP47.5 177.12,109.61 176.7,110.03 176.7,111.2 176.82,111.33 v4(176.82,112.66) 176.82,112.83 176.61,113.04 v2(176.04,113.04)
  BOTTOM w0.102: UV1.AK23 176.1,113.1 v2(176.04,113.04)
GPIO27_TMS: length 6.4
  TOP w0.102: v4(174.29,113.54) 174.43,113.4 174.91,113.4 176.05,112.26 v2(176.05,112.11) 176.5,111.67 176.5,109.84 176.62,109.72 RP47.6
  BOTTOM w0.102: v2(176.05,112.11) 175.65,112.11 UV1.AL24
GPIO28_TDO: length 1.9
  TOP w0.102: T79.1 175.41,112.14 v2(176.08,111.47)
  BOTTOM w0.102: v2(176.08,111.47) 176.05,111.5 UV1.AM24
GPU_B+: length 13
  TOP w0.508: 208.18,64.2 207.48,63.5 206.34,63.5 205.81,64.03 199.84,64.03 199.1,63.3 199.1,61.58 199.99,60.69 PR823.2
  vias: v1(213.2,65.95)
GPU_GPIO0: length 17.2
  IN3 w0.102: v2(179.7,114.15) 179.74,114.15 180.11,113.77 180.11,112.28 179.93,112.1 179.93,107.03 180.46,106.51
  IN3 w0.127: 180.46,106.51 180.81,106.15 180.81,103.38 181.57,102.62 v2(181.57,100.25)
  BOTTOM w0.102: v2(181.57,100.25) 181.7,100.12 RV75.2 v1(180.72,99.56) ; v2(179.7,114.15) 179.46,114.38 UV1.AH20
GPU_GPIO1: length 17.4
  TOP w0.102: v1(182.36,100.76) 182.59,100.54 v2(182.59,100.2)
  IN3 w0.102: 181.19,105.7 181.19,106.48 180.18,107.49 180.18,111.81 180.43,112.07 180.43,113.84 v2(180.96,114.37)
  IN3 w0.127: 181.19,105.7 181.19,103.68 182.15,102.73 182.15,100.64 v2(182.59,100.2)
  BOTTOM w0.102: v2(180.96,114.37) 180.63,114.7 UV1.AH18 ; v2(182.59,100.2) RV76.2
GPU_GPIO2: length 3.2
  TOP w0.102: v2(183.24,111.18) 183.52,110.9 v1(183.52,110.63) 183.52,110.19 184,109.7 RP60.8
  BOTTOM w0.102: UV1.AN16 182.76,110.7 v2(183.24,111.18)
GPU_GPIO6: length 106
  IN1 w0.102: 164.11,123.31 166.61,123.31 167.67,122.25 167.67,121.4 168.59,120.47 168.59,119.46 169.44,118.61 169.44,118.09 169.26,117.9 169.26,116 169.83,115.43 171.27,115.43 173.62,113.08 175.1,113.08 175.54,112.64 177.7,112.64 178.52,113.46 v2(180.87,113.46)
  IN1 w0.127: v2(158.83,156.16) 160.54,154.45 160.54,138.45 157.17,135.08 157.17,130.46 155.73,129.03 155.73,127.52 156.26,126.99 158.64,126.99 162.33,123.31 164.11,123.31
  IN2 w0.127: v2(158.83,156.16) 158.83,157.79 162.51,161.47 168.56,161.47 171.22,164.14 171.22,175.45 v2(173.45,177.68)
  BOTTOM w0.102: UV1.AJ17 181.32,113.9 v2(180.87,113.46)
  BOTTOM w0.254: PR1213.2 PR1214.1 173.71,183.47 173.19,182.95 v1(173.19,182.17) 173.19,180.77 PR1212.1 174.32,178.55 v2(173.45,177.68)
GPU_GPIO8: length 5.6
  TOP w0.102: RP60.6 185,109.36 184.07,110.29 v1(184.07,112.21) 184.07,112.83 v2(184.57,113.33)
  BOTTOM w0.102: v2(184.57,113.33) 185.06,113.82 UV1.AJ13
GPU_GPIO9: length 7.3
  TOP w0.102: v2(183.29,114.09) 184.44,114.09 185.01,113.52 185.01,111.22 v1(185.23,111) 185.5,110.73 RP60.5
  BOTTOM w0.102: v2(183.29,114.09) 183.29,114.53 UV1.AH15
GPU_GPIO11: length 15.5
  IN3 w0.102: v2(182.15,112.7) 182.14,112.7 181.49,112.05 181.49,108.98 182.14,108.32 182.14,106.92 182.59,106.47 182.59,105.7
  IN3 w0.127: v2(183.48,100.2) 182.59,101.09 182.59,105.7
  BOTTOM w0.102: RV81.2 v2(183.48,100.2) 183.55,100.2 v1(183.9,100.55) ; v2(182.15,112.7) 182.55,113.1 UV1.AK16
GPU_GPIO12: length 15
  TOP w0.102: v2(184.37,100.2) v1(184.37,99.67)
  IN3 w0.102: v2(182.14,111.87) 181.69,111.41 181.69,109.06 183.16,107.59 183.16,106.6 182.91,106.34 182.91,105.7
  IN3 w0.127: 182.91,105.7 182.91,103.54 183.67,102.78 183.67,100.9 v2(184.37,100.2)
  BOTTOM w0.102: v2(182.14,111.87) 182.58,112.3 UV1.AL16 ; v2(184.37,100.2) RV82.2
GPU_GPIO13: length 14.5
  IN3 w0.102: v2(182.15,111.04) 182.48,110.71 182.48,108.76 184.56,106.68 184.56,105.7
  IN3 w0.127: v2(185.26,100.21) 185.26,100.92 184.56,101.61 184.56,105.7
  BOTTOM w0.102: v2(182.15,111.04) 182.61,111.5 UV1.AM16 ; v1(186.32,99.56) RV83.2 v2(185.26,100.21)
GPU_RST#: length 16.4
  TOP w0.102: v1(169.22,118.94) 169.73,118.94 170.33,119.54 v2(170.66,119.54)
  IN3 w0.102: 164.11,117.28 165.68,117.28 166.63,118.23 167.26,118.23 168.08,119.04 170.16,119.04 v2(170.66,119.54)
  IN3 w0.127: v2(162.35,115.29) 162.35,115.68 163.94,117.28 164.11,117.28
  BOTTOM w0.102: UV1.AA30 170.86,119.75 v2(170.66,119.54) ; UV13.4 161.27,112.4 161.72,112.85 RV66.1 161.72,114.66 v2(162.35,115.29)
GPU_THERMAL_D+: length 31.3
  TOP w0.102: v2(179.16,94.98) 179.16,93.32 179.02,93.18 179.02,92.92 v4(179.2,92.74)
  IN3 w0.102: 175.87,105.7 175.87,106.51 176.07,106.72 176.07,107.25 175.02,108.3 174.16,108.3 173.23,109.23 173.23,112.82 172.89,113.15 172.89,114.05 171.17,115.77 v2(171.17,115.9)
  IN3 w0.127: v2(179.16,94.98) 177.76,96.37 177.76,97.82 175.52,100.06 175.52,104.15 175.87,104.5 175.87,105.7
  BOTTOM w0.102: v2(179.16,94.98) 178.84,94.66 CV89.1 177.9,94.79 UV14.2
  BOTTOM w0.254: v2(171.17,115.9) 171.17,115.94 171.66,116.44 UV1.AF29
GPU_THERMAL_D-: length 25.6
  TOP w0.102: v2(177.25,97.7) v4(177.25,98.27)
  IN3 w0.102: v2(171.25,114.91) 172.69,113.47 172.69,113.07 173.03,112.73 173.03,109.14 174.07,108.1 174.93,108.1 175.82,107.21 175.82,106.78 175.62,106.57 175.62,105.7
  IN3 w0.127: v2(177.25,97.7) 175.26,99.68 175.26,100.46 174.46,101.26 174.46,103.45 175.62,104.61 175.62,105.7
  BOTTOM w0.102: v2(177.25,97.7) UV14.3 177.25,94.79 CV89.2
  BOTTOM w0.254: UV1.AG29 171.62,115.3 171.25,114.94 v2(171.25,114.91)
GPU_VGA_B: length 5
  BOTTOM w0.102: UV1.AF37 165.75,116.5 162.83,113.58 T87.1
GPU_VGA_DDCCLK: length 3.2
  TOP w0.102: v2(172.49,111.88) 172.7,112.08 T90.1
  BOTTOM w0.102: v2(172.49,111.88) 171.61,111.88 171.31,112.17 171.31,112.75 170.95,113.1 UV1.AK30
GPU_VGA_DDCDAT: length 1.6
  TOP w0.102: T91.1 172.43,112.96 v2(172.43,112.64)
  BOTTOM w0.102: UV1.AK29 171.97,113.1 v2(172.43,112.64)
GPU_VGA_G: length 5.5
  BOTTOM w0.102: UV1.AE36 166.24,117.3 165.86,116.92 165.41,116.92 165,117.34 164.39,117.34 162.82,115.76 T86.1
GPU_VGA_HSYNC: length 4.1
  BOTTOM w0.102: UV1.AC36 166.12,118.9 165.75,118.53 164.53,118.53 163.24,117.24 T88.1
GPU_VGA_R: length 5.3
  BOTTOM w0.102: T85.1 162.18,115.66 164.62,118.1 UV1.AD39
GPU_VGA_VSYNC: length 4.8
  BOTTOM w0.102: T89.1 161.78,116.91 162.39,117.52 162.81,117.52 163.17,117.88 163.37,117.88 164.25,118.76 165.37,118.76 165.51,118.9 UV1.AC38
GPU_VID1: length 85.1
  TOP w0.102: v2(212.56,63.12) v1(213.24,63.12)
  IN3 w0.102: 186.46,105.7 186.46,108.05 185.43,109.08 185.43,110.99 v2(184.49,111.93)
  IN3 w0.127: 186.46,105.7 186.46,102.47 186.97,101.96 187.86,101.96 188.28,101.54 188.28,96.34 187.35,95.41 187.35,85.03 191.33,81.06 191.33,67.43 198.78,59.97 198.78,57.81 199.75,56.85 208.31,56.85 212.27,60.81 212.27,62.83 v2(212.56,63.12)
  BOTTOM w0.102: UV1.AL13 184.86,112.3 v2(184.49,111.93)
  BOTTOM w0.254: v2(212.56,63.12) 213,62.69 PR828.2 212.2,62.41 PR819.2 211.6,63.01 210.81,63.01 210.28,62.47 PR810.1
GPU_VID2: length 81.5
  TOP w0.102: v2(210.72,61.01) v1(211.29,61.01)
  IN3 w0.102: 186.72,105.7 186.72,108.09 185.64,109.16 185.64,111.41 v2(184.47,112.58)
  IN3 w0.127: v2(210.72,61.01) 210.13,60.42 210.13,59.03 208.2,57.1 199.85,57.1 199.04,57.92 199.04,60.08 191.58,67.54 191.58,81.16 187.6,85.14 187.6,95.3 188.53,96.23 188.53,101.7 188.01,102.22 187.1,102.22 186.72,102.6 186.72,105.7
  BOTTOM w0.102: v2(184.47,112.58) 183.95,113.1 UV1.AK14
  BOTTOM w0.254: PR812.1 210.26,61.23 210.27,61.23 210.42,61.08 210.42,61.08 210.48,61.01 v2(210.72,61.01) 211.61,61.01 212.13,61.53 PR834.2 212.2,61.52 PR826.2
GPU_VID3: length 82.7
  TOP w0.102: v2(212.69,60.76) 212.69,60.46 v1(213,60.15)
  IN3 w0.102: 186.18,105.7 186.18,107.58 185.13,108.63 185.13,110.54 v2(184.49,111.17)
  IN3 w0.127: v2(212.69,60.76) 212.58,60.76 207.69,55.87 202.28,55.87 201.74,56.4 199.83,56.4 198.53,57.71 198.53,59.87 191.07,67.32 191.07,80.95 187.09,84.93 187.09,95.51 188.02,96.45 188.02,100.3 186.18,102.15 186.18,105.7
  BOTTOM w0.102: v2(184.49,111.17) 184.82,111.5 UV1.AM13
  BOTTOM w0.254: v2(212.69,60.76) 212.69,60.76 212.69,60.51 213,60.2 PR835.2 PR836.2 211.6,60.53 210.42,60.53 210.26,60.69 PR807.1
GPU_VID4: length 83.1
  TOP w0.102: v2(212.18,58.28) v1(211.61,58.28)
  IN3 w0.102: 185.68,106.38 185.68,106.65 183.77,108.55 183.77,111.41 v2(183.24,111.95)
  IN3 w0.127: v2(212.18,58.28) 210.46,58.28 207.79,55.61 202.17,55.61 201.64,56.15 199.73,56.15 198.28,57.6 198.28,59.76 190.82,67.22 190.82,80.85 186.84,84.82 186.84,98.22 185.95,99.11 185.95,101.65 185.68,101.93 185.68,106.38
  BOTTOM w0.102: v2(183.24,111.95) 183.69,111.5 UV1.AM14
  BOTTOM w0.254: v2(212.18,58.28) 212.44,58.28 213,58.84 PR837.2 PR838.2 211.6,58.57 210.86,58.57 210.42,59.01 210.42,59.3 210.27,59.45 210.26,59.45 PR809.1
GPU_VID5: length 84.1
  TOP w0.102: v2(212.18,56.95) v1(212.88,56.95)
  IN3 w0.127: v2(212.18,56.95) 211.93,57.2 209.74,57.2 207.9,55.36 202.07,55.36 201.53,55.89 199.62,55.89 198.02,57.5 198.02,59.65 190.56,67.11 190.56,80.74 186.59,84.72 186.59,98.12 185.7,99 185.7,100.83 184.81,101.72 184.81,106.86 183.4,108.27 183.4,110.17 182.64,110.93 182.64,112.96 v2(182.14,113.46)
  BOTTOM w0.102: v2(182.14,113.46) 182.59,113.9 UV1.AJ16
  BOTTOM w0.254: PR806.1 209.98,58.92 210.7,58.19 211.52,58.19 PR840.2 ; PR840.2 212.13,57 v2(212.18,56.95) ; PR840.2 PR839.2
H_CATERR#: length 6.1
  TOP w0.089: v2(89.58,122.25) 90.08,121.75 RC58.2 90.74,121.59 v1(91.08,121.92)
  BOTTOM w0.076: v2(89.58,122.25) 89.71,122.12 89.73,122.12 89.96,121.89 90.69,121.89 90.73,121.85 91.16,121.85 91.42,121.6 91.77,121.6 91.94,121.77 91.94,121.94 92.18,122.18 92.7,122.18 UC1.K61
H_CPU_SVIDALRT#: length 8.8
  BOTTOM w0.076: UC1.L62 92.06,121.14 91.77,120.85 91.46,120.85 90.96,121.35 87.57,121.35 86.92,120.7 86.76,120.7
  BOTTOM w0.102: 86.76,120.7 v1(85.12,120.7) R254.1
H_CPU_SVIDCLK: length 10.6
  BOTTOM w0.089: UC1.N63 91.54,120.5 87.15,120.5 86.78,120.13 86.76,120.13
  BOTTOM w0.102: R248.2 C5212.1 83.66,119.36 85.08,119.36 85.51,119.79 v1(86.05,119.79) 86.39,120.13 86.76,120.13
H_CPU_SVIDDATA: length 12.5
  BOTTOM w0.076: UC1.L63 91.41,121.14 91.03,121.52 87.11,121.52
  BOTTOM w0.089: 87.11,121.52 86.85,121.26 86.76,121.26
  BOTTOM w0.102: R257.1 79.92,122.51 R256.2 81.56,121.59 81.89,121.26 v1(86.38,121.26) 86.76,121.26
H_CPUPWRGD: length 82
  TOP w0.102: v2(85.67,127.21) v4(85.67,127.91)
  IN3 w0.127: v2(85.67,127.21) 84.54,127.21 79.84,122.51 69.52,122.51 56.73,109.73 56.73,97.72 59.56,94.89 59.56,90.03 v2(60.83,88.76)
  BOTTOM w0.076: UC1.C61 93.27,126.76 93.29,126.77 93.29,127.36 93.22,127.43 93.22,127.8 92.95,128.07 91.99,128.07 91.09,128.97
  BOTTOM w0.102: v2(60.83,88.76) 60.83,88.76 64.71,88.76 66.13,90.19 66.13,91.18 65.44,91.87 RC48.1 ; 91.09,128.97 90.71,129.34 90.13,129.34 89.22,130.25 89.22,130.84 RC66.1 88.61,130.28 87.11,130.28 CC27.1 86.31,130.65 86.31,127.86 v2(85.67,127.21)
H_PROCHOT#: length 310.9
  TOP w0.089: 88.37,122.94 RC67.1
  TOP w0.102: CE19.1 179.43,57.27 UE2.4 179.43,55.73 179.67,55.49 180.48,55.49 RE44.2 180.5,53.34 v1(180.09,52.94) v2(179.52,52.36) ; PQ3.3 129.65,164.31 129.76,164.2 v2(129.76,163.82) ; v2(130.27,171.44) 129.95,171.44 129.82,171.31 129.82,170.93 129.93,170.82 PQ2.6 ; v2(87.02,123.09) 87.43,122.68 88.04,122.68 RC60.2 88.32,122.94 88.37,122.94 ; PQ3.6 131.3,165.61 131.47,165.79 131.47,167.25 v2(131.41,167.31)
  IN1 w0.114: v2(129.76,163.82) 131.41,165.47 v2(131.41,167.31) 131.41,168.01 130.27,169.15 v2(130.27,171.44)
  IN1 w0.127: v2(129.76,163.82) 129.76,163.09 130.33,162.52 130.33,142.74 128.24,140.65 119.19,140.65 117.87,139.33 114.52,139.33 112.53,137.34 109.4,137.34 108.76,136.7 96.49,136.7 96.32,136.54 91.13,136.54 90.58,135.98 v2(89.12,135.98)
  IN3 w0.127: v2(89.12,135.98) 89.12,134.55 87.72,133.15 87.72,131.31 89.37,129.66 89.37,125.35 88.5,124.48 88.03,124.48 87.02,123.47 v2(87.02,123.09) 87.02,121.97 86.58,121.53 85.81,121.53 83.28,119 78.94,119 78.2,119.74 68.94,119.74 59.95,110.75 59.95,106.7 59.64,106.4 59.64,96.03 60.07,95.6 60.07,90.98 61.35,89.7 61.35,76.01 64.4,72.96 64.4,57.08 69.86,51.62 178.78,51.62 v2(179.52,52.36)
H_PROCHOT#_R: length 2.4
  TOP w0.089: RC67.2 90.48,122.56 v2(90.2,122.28)
  BOTTOM w0.076: v2(90.2,122.28) 90.53,122.28 90.79,122.02 91.52,122.02 UC1.K63
H_THERMTRIP#: length 16.5
  BOTTOM w0.076: UC1.D60 93.43,125.77 92.97,126.23 92.97,126.44 92.63,126.78 92.63,126.98 92.44,127.18 92.01,127.18 91.62,127.57 90.69,127.57 90.31,127.95 89.46,127.95
  BOTTOM w0.102: R2346.2 v1(81,125.43) 83.15,125.43 84.37,126.65 85.97,126.65 87.99,128.67 88.75,128.67 89.46,127.95
H_VCCST_PWRGD_XDP: length 5
  BOTTOM w0.102: JXDP1.39 63.7,94.24 64.2,93.75 64.47,93.75 65.17,93.04 RC48.2 65.94,93.04 v1(66.67,92.32)
H_VR_READY: length 18.6
  TOP w0.254: PR540.2 v2(85.45,138.58)
  IN3 w0.127: v2(82.39,136.45) 83.34,137.4 84.93,137.4 85.45,137.92 v2(85.45,138.58)
  BOTTOM w0.102: v2(82.39,136.45) 82.74,136.45 83.61,135.57 84.88,135.57 85.64,134.81 85.64,133.45 86.53,132.57 v1(86.52,132.57) 86.52,132.58 86.83,132.26 89.7,132.26 R251.1
  BOTTOM w0.203: PU501.3 86.62,138.83 86.56,138.77 86.18,138.77 85.71,139.24 PR524.2
  BOTTOM w0.254: PR524.2 v2(85.45,138.58)
HDA_SPKR: length 178.2
  TOP w0.102: v2(37.94,73.09) 37.94,56.14 v1(47.78,46.3) 49.42,44.66 DA8.3
  IN2 w0.089: v2(136.14,116.98) 135.21,116.06 135.21,115.44 134.39,114.62 134.39,114.02 133.71,113.33 133.71,112.41 131.98,110.68 131.98,109.6 131.54,109.16 131.54,105.29 131.03,104.78 131.03,101.02 130.65,100.64 130.65,100.15 129.93,99.43 126.9,99.43 125.64,98.17 125.64,97.03 124.24,95.62
  IN2 w0.127: v2(37.94,73.09) 38.21,72.82 45.39,72.82 59.23,86.67 113.25,86.67 121.8,95.22 123.83,95.22 124.24,95.62
  BOTTOM w0.076: v2(136.14,116.98) 135.34,117.78 131.41,117.78 131.27,117.65 130.16,117.65 129.86,117.35 UC1.V2
  BOTTOM w0.089: v2(136.14,116.98) 135.59,116.44 RC121.2
HDD_DET#: length 178.9
  TOP w0.089: RC9.1 135.08,117.48 135.6,116.96 v1(135.6,116.35) 135.6,115.56 135.6,115.56 v2(135.6,115.56)
  IN2 w0.127: v2(142.78,48.64) 142.46,48.96 142.46,66.08 142.27,66.27 142.27,70.51 142.46,70.7 142.46,75.24 140.06,77.64 140.06,99.8 136.74,103.11 136.74,112.13 135.47,113.4 135.47,115.44 v2(135.6,115.56)
  IN3 w0.084: v2(135.6,115.56) 135.38,115.34 133.27,115.34 132.54,116.07 130.52,116.07 129.19,114.73 128.62,114.73 128.25,114.37 128.25,113.8 128.04,113.59 127.66,113.59 v2(127.22,113.15)
  IN3 w0.127: v2(142.78,48.64) 143.02,48.89 178.06,48.89 178.76,49.59 179.66,49.59 179.93,49.33 180.5,49.33 182.89,46.94 184.28,46.94 184.85,47.51 186.97,47.51 188.23,48.77 190.01,48.77 190.68,48.11 193.27,48.11 200.67,40.71 209.32,40.71 211.1,42.48 217.06,42.48 223.19,48.62 228.13,48.62 JHDD.12
  BOTTOM w0.089: v2(127.22,113.15) 126.99,112.92 UC1.AG6
HDMI_HPLUG: length 10.8
  BOTTOM w0.102: JHDMI.19 10.65,113.02 v1(12.63,113.02) 14.63,113.02 CX20.1 14.63,113.93 14.6,113.93 RX15.2 14.18,114.73 14.19,114.75 RX34.1
HOST_ALERT1_R_N: length 22.8
  TOP w0.102: v1(145.05,115.27) 144.67,114.89 v2(144.59,114.89)
  IN1 w0.084: 137.68,113.27 137.15,113.27 136.23,112.36 134.74,112.36 134.51,112.13 130.74,112.13 130,112.88 130,114.05 129.57,114.48 127.03,114.48 v2(126.65,114.1)
  IN1 w0.127: v2(144.59,114.89) 144.53,114.95 143.65,114.95 141.98,113.27 137.68,113.27
  BOTTOM w0.089: UC1.AD7 126.34,114.41 v2(126.65,114.1)
  BOTTOM w0.102: v2(144.59,114.89) 144.67,114.81 RC120.2
HPOUT-L: length 9
  TOP w0.102: v1(29.19,26.8) RA55.1
  TOP w0.203: UA1.32 35.63,24.22 35.53,24.32 34.79,24.32 v2(34.7,24.24)
  TOP w0.254: RA55.1 29.67,25.61 v2(30.06,25.21)
  IN1 w0.254: v2(34.7,24.24) 34.3,24.64 30.76,24.64 30.19,25.21 v2(30.06,25.21)
HPOUT-R: length 10.2
  TOP w0.203: UA1.33 35.34,23.82 35.33,23.82 v2(35.33,23.82)
  TOP w0.254: v2(27.65,25.15) 27.65,25.21 28.05,25.61 RA56.1
  IN1 w0.254: v2(35.33,23.82) 35.25,23.73 34.91,23.73 34.41,23.73 34,24.13 30.43,24.13 29.79,24.77 28.03,24.77 v2(27.65,25.15)
I2C0_SCL: length 7.9
  BOTTOM w0.089: UC1.F3 129.37,124.45 129.88,124.45 130.15,124.71 130.42,124.71 130.53,124.83 131.61,124.83 131.62,124.83 133.1,124.83 135.05,126.79 RP53.4
I2C0_SDA: length 7
  BOTTOM w0.076: 131.69,124.66 131.68,124.65 130.61,124.65 130.49,124.54 130.22,124.54 130.15,124.47 130.14,124.47 129.77,124.1 UC1.F2
  BOTTOM w0.089: 131.69,124.66 133.18,124.66 134.81,126.29 RP53.3
I2C1_SCL_TCH_PAD: length 6.1
  BOTTOM w0.089: RP53.2 135.27,125.79 135.13,125.64 134.95,125.64 134.74,125.43 134.28,125.43 133.33,124.48 132.27,124.48 132.27,124.48 130.68,124.48 130.56,124.36 130.51,124.36 UC1.F1
I2C1_SDA_TCH_PAD: length 8.4
  BOTTOM w0.089: UC1.G4 128.7,123.76 130.38,123.76 130.84,124.23 131.18,124.23 131.27,124.13 v1(131.7,124.13) 132.23,124.13 132.36,124.26 133.42,124.26 134.37,125.21 134.83,125.21 135.04,125.43 135.13,125.43 135.27,125.29 RP53.1
ILMT_1.05V: length 4.3
  BOTTOM w0.254: PU300.3 146.13,156.54 v1(146.69,155.98) 146.95,155.71 146.95,155.57 147.74,154.79 PR304.2 PR306.1
ILMT_VDDCI: length 8.1
  TOP w0.254: v2(182.78,178.06) v1(183.68,178.06) 184.31,178.06 185.08,178.83 PR1202.1 185.32,179.45 185.7,179.83 v2(185.7,181.17)
  BOTTOM w0.254: PR1203.2 183.01,178.96 182.78,178.73 v2(182.78,178.06) ; PU1200.3 185.93,181.39 v2(185.7,181.17)
IMON_CPU: length 4.4
  BOTTOM w0.102: v1(88.36,145.07) 88.61,144.82 PR501.2
  BOTTOM w0.203: PC508.2 89.42,143.04 PU501.13
  BOTTOM w0.254: PR501.2 88.83,144.15 89.67,143.31 PC508.2
IMVP_PWRGD: length 242.6
  TOP w0.102: UE1.85 v2(187.59,52.06)
  TOP w0.254: PR540.1 83.69,137.59 PC523.1 83.34,137.28 83.34,136.13 86.39,133.08 86.39,127.17 85.71,126.49 83.91,126.49 83.02,125.6 74.54,125.6 v1(73.22,124.28) 62.68,113.74 54.07,113.74 53.04,112.72 53.04,108.14 54.16,107.02 54.16,97.82 v2(54.51,97.46)
  IN3 w0.127: v2(187.59,52.06) 186.46,52.06 184.89,50.48 178.91,50.48 177.84,49.42 69.53,49.42 58.26,60.68 58.26,93.71 v2(54.51,97.46)
INT-SPK-L+: length 31.2
  TOP w0.203: UA1.42 39.14,21.3 39.28,21.16 39.28,20.45 39.14,20.32
  IN1 w0.762: 58.58,36.83 56.01,36.83 52.86,33.69 52.86,25.78 47.97,20.89 42.45,20.89 42.26,21.08 40.29,21.08
  vias: v1(58.87,37.24) v2(38.51,19.56) v2(38.95,19.94) v2(59.85,36.88) v2(60.48,36.88)
INT-SPK-L-: length 31.7
  TOP w0.203: UA1.43 39.54,21.33 39.61,21.26 39.61,19.99 39.65,19.94
  IN1 w0.762: 58.58,35.69 56.48,35.69 54,33.21 54,25.31 48.44,19.75 41.97,19.75 41.78,19.94 40.63,19.94 40.31,19.62
  vias: v1(59.02,35.41) v2(39.11,18.75) v2(39.53,19.17) v2(59.78,35.68) v2(60.42,35.68)
INT-SPK-R+: length 29.7
  TOP w0.203: 40.99,19.62 40.99,19.88 40.34,20.53 UA1.45
  IN1 w0.762: 42.32,18.61 49.53,18.61 55.4,24.48 55.4,31.37 58.07,34.04 59.08,34.04
  vias: v1(60.07,33.95) v2(41.3,18.98) v2(41.3,18.39) v2(60.67,34.02) v2(61.31,34.02)
INT-SPK-R-: length 30.7
  TOP w0.203: UA1.44 39.94,20.36 40.29,20.01 40.29,19.62
  IN1 w0.762: 59.08,32.9 58.54,32.9 56.54,30.9 56.54,24.01 50,17.47 41.18,17.47
  vias: v1(40.3,18.71) v2(40.28,17.92) v2(40.3,17.34) v2(60.61,32.69) v2(61.24,32.69)
INTRUDER#: length 12.5
  BOTTOM w0.076: UC1.AU6 127.23,106.6 127.23,106.1 127.19,106.06 127.19,104.73
  BOTTOM w0.089: 131.57,102.19 130.62,102.19 130.12,102.69 129.04,102.69 128.31,103.42 128.13,103.42 127.47,104.08 127.47,104.23 127.47,104.46 127.19,104.73
  BOTTOM w0.102: v1(135.91,101.66) RC7.2 134.38,102.19 131.57,102.19
ISOLATEB: length 3.2
  BOTTOM w0.102: RL33.2 RL35.2 41.87,88.14 v1(41.1,88.14) UL1.20
ISUM+: length 8.2
  BOTTOM w0.203: 202.15,59.04 202.3,58.89 202.72,58.89 202.85,59.02 PU800.10
  BOTTOM w0.254: PR827.1 199.3,59.3 v1(200.24,59.3) 201.9,59.3 202.15,59.04 ; PR827.1 PR816.1 ; PR827.1 PC820.1 PC819.1 199.1,61.28 PR829.2
ISUM-: length 2.9
  BOTTOM w0.203: 202.02,58.66 202.12,58.56 202.86,58.56 202.92,58.62 PU800.9
  BOTTOM w0.254: PR825.1 201.59,58.41 v1(201.84,58.66) 202.02,58.66
ISUM-1: length 31.4
  TOP w0.254: PC821.2 200.39,56.63 200.05,56.96 v2(200.05,57.52) 197.58,60 v1(197.58,61.2) v2(197.58,62.28)
  BOTTOM w0.254: PR827.2 PC820.2 PC819.2 198.21,61.28 PR830.2 197.72,62.14 v2(197.58,62.28) 197.58,63.62 200.43,66.47 200.43,76.28 203.42,79.26 PH800.2 ; PR825.2 v2(200.05,57.52)
ISUM-2: length 25.7
  BOTTOM w0.254: PH800.1 202.81,80.49 202.81,79.61 v1(201.48,78.28) 200.05,76.86 200.05,66.63 197.2,63.77 197.2,62.73 197.07,62.6 197.07,61.96 197.64,61.39 197.64,59.04 198.09,58.6 PR816.2
JACK_PLUG#: length 43.2
  TOP w0.254: v2(42.83,28.96) RA4.1 42.94,29.76 43.78,30.6 v1(43.78,30.97) 43.78,31.26 43.5,31.54 RA1.2
  IN1 w0.254: v2(30,26.74) 30.13,26.74 30.7,27.31 35.65,27.31 36.35,28.01 37.91,28.01 38.42,27.5 40.7,27.5 41.46,28.26 42.13,28.26 v2(42.83,28.96)
  IN3 w0.254: JHP.5 13.65,21.72 24.98,21.72 v2(30,26.74)
  BOTTOM w0.254: RA3.1 27.84,24.51 28.54,25.21 29.3,25.21 30,25.91 v2(30,26.74)
JACK_SENSE#: length 21.4
  TOP w0.102: v2(26.44,26.36) v1(26.44,27.04)
  TOP w0.254: v2(41.68,29.09) 41.37,29.4 41.37,30.47 41.57,30.67 RA51.2 RA4.2
  IN1 w0.254: v2(41.68,29.09) 41.27,28.67 41.27,28.6 40.54,27.88 38.57,27.88 38.07,28.39 36.19,28.39 35.49,27.69 30.54,27.69 30.1,27.24 29.52,27.24 29.01,26.74 26.83,26.74 v2(26.44,26.36)
  BOTTOM w0.254: v2(26.44,26.36) 26.44,27.18 QA5.3
JHDD_P10: length 17.6
  TOP w0.102: JHDD.10 226.76,42.87 223.7,42.87 219.68,46.89 v1(219.68,50.09) RS8.2 RS7.2
KB_BL_PWM: length 3.7
  TOP w0.102: JKBBL.4 39.81,117.33 39.65,117.49 39.65,118.53 v1(38.76,119.42)
  vias: v2(40.92,118.05)
KB_CAPS_PWR: length 3.9
  TOP w0.102: v4(230.45,159.99) 229.89,159.43 JKB.4 v2(227.55,159.43)
  BOTTOM w0.102: RE60.2 228.2,159.43 v2(227.55,159.43)
KB_DET#: length 193.9
  TOP w0.102: v2(48.9,114.15) 48.9,116.16 46.28,118.77 41.28,118.77 40.12,119.93 38.38,119.93 37.95,119.5 36.55,119.5 36.35,119.29 v1(36.35,119.22) RE68.1 36.35,117.73 36.73,117.35 QE4.1
  IN2 w0.089: 120.68,95.62 124.1,99.04 124.61,99.04 126.03,100.46 126.03,106.83 126.24,107.05 126.24,109.17 126.85,109.78 v2(126.97,109.78)
  IN2 w0.127: 120.68,95.62 112.79,87.73 57.97,87.73 47.57,77.33 43.76,77.33 42.75,78.34 42.75,90.5 40.04,93.21 40.04,106.73 47.46,114.15 v2(48.9,114.15)
  IN3 w0.084: v2(126.97,109.78) 127.41,110.22 127.41,110.67 128.95,112.21 128.95,112.64 129.23,112.91 129.51,112.91 131.35,114.75 134.31,114.75 135.22,113.84 137.82,113.84
  IN3 w0.127: 137.82,113.84 142.79,113.84 144.5,112.13 v2(149.57,112.13)
  BOTTOM w0.089: v2(126.97,109.78) 127.25,109.49 UC1.AN5
  BOTTOM w0.102: v2(149.57,112.13) 149.75,112.31 149.75,113.84 148.99,114.61 RC103.1
KB_LED_PWM: length 228.7
  TOP w0.102: v1(190.05,35.85) 190.64,36.45 v2(190.85,36.45) 191.19,36.79 UE1.21
  IN3 w0.127: v2(43.97,114.45) 44.48,113.95 44.48,107.13 40.48,103.13 40.48,87.19 37.05,83.76 35.98,83.76 35.12,82.9 35.12,60.08 51.4,43.8 61.32,43.8 61.59,44.07 62.58,44.07 63.83,42.81 80.26,42.81 80.61,42.47 89.63,42.47 91.58,40.52 174.72,40.52 175.07,40.16 176.9,40.16 178.07,38.99 182.38,38.99 183.6,37.77 185.14,37.77 186.46,36.45 v2(190.85,36.45)
  BOTTOM w0.102: v2(43.97,114.45) 43.97,114.94 43.75,115.16 QE5.3
KB_RST#: length 148.7
  TOP w0.102: UE1.2 v2(183.59,38.98)
  IN1 w0.127: v2(191.42,39.74) 191.42,39.76 194.11,42.45 194.11,52.32 194.31,52.52 194.31,55.82 194.05,56.08 194.05,56.25 192.88,57.42 192.88,58.45 191.39,59.94 191.39,66.97 190.31,68.05 190.31,78.09 183.12,85.28 179.1,85.28 174.06,90.32 167.89,90.32 165.75,92.46 165.75,94.26 155.22,104.79 155.22,106.61 154.15,107.68 154.15,110.53 147.99,116.69 147.99,117.66 v2(147.67,117.97)
  IN3 w0.084: 137.92,116.56 132.05,116.56 131.2,117.4 128.35,117.4 v2(127.85,117.9)
  IN3 w0.127: v2(183.59,38.98) 184.22,38.34 190.3,38.34 190.97,39.01 190.97,39.3 v2(191.42,39.74) ; v2(147.67,117.97) 147.41,117.97 146.87,117.43 144.23,117.43 144.07,117.27 141.94,117.27 140.74,116.08 139.28,116.08 138.81,116.56 137.92,116.56
  BOTTOM w0.089: UC1.V4 128.33,117.42 v2(127.85,117.9)
  BOTTOM w0.102: RP43.8 141.57,124.33 141.21,123.97 141.21,122.64 141.22,122.63 141.22,122.6 142.36,121.46 142.9,121.46 143.28,121.08 144.61,121.08 v1(145.13,120.57) 145.13,118.67 145.83,117.97 v2(147.67,117.97)
KSI0: length 133.7
  TOP w0.102: v2(221.83,143.47) 221.89,143.52 223.56,143.52 225.07,145.03 JKB.22 v1(231.87,145.03) ; v2(198.47,48.19) 198.4,48.12 UE1.55
  IN3 w0.127: v2(198.47,48.19) 198.47,48.2 199.4,49.14 204.06,49.14 204.41,49.49 216.66,49.49 220.59,53.42 220.59,62.95 221.23,63.58 221.23,75.19 218.15,78.26 218.15,85.47 218.95,86.27 218.95,89.34 216.29,92 215.46,92 214.66,92.79 214.66,94.51 214.79,94.64 214.79,101.63 215.7,102.55 215.7,103.38 219.65,107.33 219.65,123.62 219.77,123.74 219.77,136.43 220.78,137.43 220.78,138.17 221.63,139.03 221.63,140.82 221.31,141.14 221.31,142.94 v2(221.83,143.47)
KSI1: length 133.2
  TOP w0.102: v1(231.68,143.09) 231.34,143.43 JKB.24 224.37,143.43 223.23,142.29 v2(221.9,142.29) ; UE1.56 198.16,48.52 198.28,48.63 198.61,48.63 v2(199.05,48.19)
  IN3 w0.127: v2(221.9,142.29) 221.77,142.29 221.57,142.09 221.57,141.28 221.89,140.97 221.89,138.18 220.03,136.32 220.03,123.41 220.62,122.83 220.62,118.78 219.91,118.07 219.91,107.23 215.95,103.27 215.95,95.44 214.91,94.4 214.91,92.9 215.56,92.25 216.4,92.25 219.21,89.44 219.21,86.17 218.41,85.37 218.41,78.38 221.48,75.31 221.48,63.48 220.84,62.84 220.84,53.31 216.78,49.24 204.52,49.24 204.15,48.87 199.72,48.87 199.05,48.2 v2(199.05,48.19)
KSI2: length 129.5
  TOP w0.102: UE1.57 198.9,48.92 v1(199.03,48.79) v2(199.63,48.19) ; v2(222,141.46) 222.02,141.44 227.07,141.44 227.47,141.83 JKB.26
  IN3 w0.127: v2(199.63,48.19) 199.63,48.2 200.04,48.61 204.25,48.61 204.62,48.99 216.89,48.99 221.09,53.19 221.09,62.73 221.73,63.37 221.73,75.42 218.66,78.5 218.66,85.26 219.46,86.06 219.46,89.55 216.5,92.5 215.67,92.5 215.17,93 215.17,94.29 216.21,95.33 216.21,101.85 220.9,106.54 220.9,112.25 220.17,112.97 220.17,117.96 220.88,118.67 220.88,122.93 220.29,123.52 220.29,136.21 222.17,138.09 222.17,141.28 v2(222,141.46)
KSI3: length 134.3
  TOP w0.102: v1(230.15,144.23) JKB.23 224.85,144.23 223.5,142.89 v2(221.9,142.89) ; v2(200.22,48.19) 199.09,49.31 198.28,49.31 198.27,49.32 UE1.58
  IN3 w0.127: v2(200.22,48.19) 204.18,48.19 204.73,48.73 217.01,48.73 221.35,53.07 221.35,62.63 221.99,63.28 221.99,75.53 218.91,78.61 218.91,85.16 219.72,85.96 219.72,89.65 216.61,92.76 215.77,92.76 215.43,93.09 215.43,94.18 216.48,95.22 216.48,101.25 217.78,102.55 219.12,102.55 221.16,104.59 221.16,112.36 220.44,113.08 220.44,117.44 221.16,118.16 221.16,131.88 222.64,133.36 222.64,142.45 222.21,142.89 v2(221.9,142.89)
KSI4: length 127.8
  TOP w0.102: v2(220.95,140.37) 222.07,140.37 222.73,141.03 JKB.27 229.26,141.03 v4(230.29,139.99) ; v2(198.47,49.72) UE1.59
  IN3 w0.127: v2(198.47,49.72) 198.47,49.78 199.54,50.85 211.05,50.85 211.38,51.18 216.87,51.18 219.57,53.89 219.57,63.37 220.21,64.01 220.21,74.73 217.14,77.8 217.14,85.89 217.9,86.66 217.9,88.95 215.87,90.98 215.03,90.98 213.6,92.41 213.6,94.94 213.74,95.08 213.74,102.9 218.6,107.77 218.6,124.05 218.72,124.17 218.72,138.15 v2(220.95,140.37)
KSI5: length 130.1
  TOP w0.102: v2(220.93,140.95) 220.93,141.26 221.56,141.88 226.17,141.88 226.91,142.63 JKB.25 229.52,142.63 v4(230.32,141.84) ; UE1.60 198.33,50.12 198.34,50.12 198.64,50.12 v2(199.05,49.72)
  IN3 w0.127: v2(199.05,49.72) 199.05,49.78 199.86,50.59 203.32,50.59 203.65,50.26 216.31,50.26 219.82,53.77 219.82,63.26 220.46,63.9 220.46,74.84 217.39,77.92 217.39,85.79 218.16,86.56 218.16,89.05 215.98,91.23 215.14,91.23 213.87,92.51 213.87,94.83 214,94.97 214,102.79 218.87,107.66 218.87,123.95 218.99,124.07 218.99,138.04 220.89,139.95 221.12,139.95 221.37,140.19 221.37,140.54 220.96,140.95 v2(220.93,140.95)
KSI6: length 127.9
  TOP w0.102: UE1.61 198.83,50.52 v2(199.63,49.72) 200.87,48.48 v4(201.07,48.48) ; v2(221,139.45) 226.2,139.45 226.98,140.23 JKB.28
  IN3 w0.127: v2(199.63,49.72) 199.63,49.8 200.17,50.33 203.21,50.33 203.53,50 216.43,50 220.08,53.65 220.08,63.16 220.72,63.79 220.72,74.96 217.64,78.03 217.64,85.68 218.43,86.47 218.43,89.14 216.08,91.49 215.24,91.49 214.13,92.61 214.13,94.72 214.26,94.86 214.26,102.69 219.13,107.55 219.13,123.84 219.25,123.96 219.25,137.93 220.77,139.45 v2(221,139.45)
KSI7: length 126.4
  TOP w0.102: UE1.62 199.02,50.92 v2(200.22,49.72) 200.39,49.72 v4(200.89,50.22) ; v2(220.88,138.88) 226.55,138.88 227.1,139.43 JKB.29
  IN3 w0.127: v2(220.88,138.88) 220.51,138.51 220.51,137.54 219.51,136.54 219.51,123.85 219.39,123.73 219.39,107.44 215.45,103.5 215.45,102.66 214.52,101.74 214.52,94.75 214.39,94.61 214.39,92.7 215.35,91.74 216.19,91.74 218.68,89.24 218.68,86.36 217.9,85.58 217.9,78.15 220.97,75.07 220.97,63.69 220.33,63.05 220.33,53.54 216.54,49.75 204.31,49.75 203.96,49.4 200.54,49.4 v2(200.22,49.72)
