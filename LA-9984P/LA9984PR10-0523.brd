# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA0_29: length 14.9
  BOTTOM w0.102: 179.42,135.93 179.42,134.72 179.6,134.54 179.6,134.06 179.56,134.02 179.56,133.52 179.06,133.02 UV1.F20
  BOTTOM w0.127: UV4.U13 175.5,145.26 175.89,144.87 175.89,143.06 v1(178.7,140.25) 179.36,139.59 179.36,137.08 179.42,137.02 179.42,135.93
DQA0_30: length 15.7
  BOTTOM w0.102: UV1.D19 179.87,133.9 180.15,134.18 180.15,134.51 180.19,134.55 180.19,134.85 180.15,134.89 180.15,135.31 180.38,135.54 180.38,135.97
  BOTTOM w0.127: UV4.U11 175.64,146.86 176.3,146.19 176.3,143.18 179.74,139.74 v1(179.74,138.86) 179.74,136.76 180.38,136.12 180.38,135.97
DQA0_31: length 18
  BOTTOM w0.102: 180.66,135.72 180.66,135.53 180.36,135.23 180.36,134.97 180.4,134.93 180.4,134.47 180.36,134.43 180.36,133.65 180.51,133.5 UV1.E18
  BOTTOM w0.127: 180.66,135.72 180.66,136.44 180.12,136.98 180.12,139.9 v1(178.09,141.94) 176.69,143.34 176.69,146.67 176.08,147.28 174.7,147.28 UV4.T11
DQA1_0: length 15.3
  TOP w0.102: 182.73,137.4 182.73,137.29 182.35,136.91 181.84,136.91 180.56,135.62 v1(180.56,134.99) 180.56,134.33 v2(180.98,133.91) ; UV3.U11 182.39,146.39
  TOP w0.127: 182.73,137.4 182.73,139.37 182.17,139.94 182.17,146.17 182.39,146.39
  BOTTOM w0.102: v2(180.98,133.91) 180.66,134.23 UV1.C18
DQA1_1: length 12.9
  TOP w0.102: 183.11,137.4 183.11,137.1 182.59,136.58 v1(182.16,136.58) 181.86,136.58 181.45,136.16 181.45,135.14 v2(180.98,134.67)
  TOP w0.127: UV3.U13 182.73,145.19 182.4,144.86 182.4,143.63 182.65,143.37 182.65,139.99 183.11,139.53 183.11,137.4
  BOTTOM w0.102: v2(180.98,134.67) 180.66,134.99 UV1.A18
DQA1_2: length 17.9
  TOP w0.102: v2(180.43,133.08) 180.15,133.35 180.15,135.57 181.78,137.2 182.26,137.2 182.35,137.29 182.35,137.4 ; UV3.T11 183.19,147.19
  TOP w0.127: 183.19,147.19 182.37,147.19 181.79,146.62 v1(181.79,141.02) 181.79,139.78 182.35,139.22 182.35,137.4
  BOTTOM w0.102: UV1.F18 180.81,132.7 v2(180.43,133.08)
DQA1_3: length 15.7
  TOP w0.102: 184.64,137.4 184.64,136.78 v1(183.8,135.94) 183.1,135.24 183.1,134.71 182.74,134.35 182.28,134.35 181.96,134.66 v2(181.96,134.68) ; UV3.N11 185.59,146.39
  TOP w0.127: 185.59,146.39 185.59,142.6 184.78,141.78 184.78,139.47 184.64,139.32 184.64,137.4
  BOTTOM w0.102: UV1.D17 181.46,134.18 v2(181.96,134.68)
DQA1_4: length 11.3
  TOP w0.102: v2(181.89,135.56) 182.04,135.56 183.5,137.01 183.5,137.4
  TOP w0.127: 183.5,137.4 v1(183.5,137.94) 183.5,139.69 183.19,139.99 183.19,144.79 UV3.T13
  BOTTOM w0.102: v2(181.89,135.56) 182.26,135.18 UV1.A16
DQA1_5: length 14.7
  TOP w0.102: UV3.M13 187.19,144.79 ; v2(182.91,133.21) v1(183.35,133.65) 185.13,135.43 185.13,136.46 185.5,136.83 185.5,137.4
  TOP w0.127: 187.19,144.79 187.19,143.47 186.78,143.05 186.78,142.7 185.54,141.47 185.54,139.15 185.5,139.1 185.5,137.4
  BOTTOM w0.102: v2(182.91,133.21) 182.91,133.07 182.54,132.7 UV1.F16
DQA1_6: length 12.8
  TOP w0.102: v1(185.11,137.15) 185.11,136.79 183.36,135.03 v2(183.36,134.32) ; UV3.N13 186.39,144.79
  TOP w0.127: v1(185.11,137.15) 185.11,139.26 185.16,139.31 185.16,141.63 186.39,142.86 186.39,144.79
  BOTTOM w0.102: UV1.D15 183.06,134.02 v2(183.36,134.32)
DQA1_7: length 16.7
  TOP w0.102: v2(183.69,133.04) v1(185.45,134.8) 185.45,136.26 185.88,136.69 185.88,137.4 ; UV3.M11 187.19,146.39
  TOP w0.127: 187.19,146.39 187.19,145.92 187.52,145.59 187.79,145.59 187.99,145.4 187.99,143.56 187.23,142.8 187.23,142.61 185.96,141.34 185.96,139.02 185.88,138.94 185.88,137.4
  BOTTOM w0.102: UV1.E14 183.86,133.21 v2(183.69,133.04)
DQA1_8: length 38.4
  BOTTOM w0.102: 183.17,137.4 184.07,136.5 184.07,135.33 184.17,135.23 184.17,134.92 184.15,134.91 184.15,134.49 184.28,134.37 184.28,132.91 UV1.F14
  BOTTOM w0.127: UV6.F4 186.8,152.61 187.25,153.06 187.25,155.67 185.83,157.09 181.35,157.09 v1(179.5,155.24) 178.08,153.82 178.08,142.48 183.17,137.4
DQA1_9: length 33.7
  BOTTOM w0.102: UV1.D13 184.66,134.27 184.36,134.57 184.36,134.83 184.37,134.84 184.37,135.31 184.27,135.41 184.27,136.83 183.71,137.4
  BOTTOM w0.127: UV6.F2 186.45,154.34 186.45,155.52 185.26,156.71 181.51,156.71 178.46,153.66 v1(178.46,153.15) 178.46,142.64 183.48,137.62 183.48,137.62 183.71,137.4
DQA1_10: length 33.6
  BOTTOM w0.102: 184.25,137.4 184.69,136.96 184.69,136.13 185.07,135.75 185.07,133.91 185.16,133.82 185.16,133.37 185.66,132.87 UV1.F12
  BOTTOM w0.127: UV6.E2 185.59,154.4 185.59,155.7 184.96,156.33 181.77,156.33 178.84,153.4 v1(178.84,151.04) 178.84,142.8 184.25,137.4
DQA1_11: length 31.1
  BOTTOM w0.102: 184.79,137.4 185,137.18 185,136.2 185.3,135.9 185.3,135.26 UV1.A12
  BOTTOM w0.127: 184.79,137.4 179.37,142.81 v1(179.37,148.71) 179.37,153.11 182.21,155.94 184.5,155.94 184.8,155.65 184.8,154.63 185.07,154.36 185.31,154.36 185.58,154.09 185.58,152.81 UV6.E4
DQA1_12: length 24
  BOTTOM w0.102: 186.56,137.4 186.56,136.34 186.58,136.32 186.58,135.34 186.55,135.31 186.55,134.89 186.57,134.88 186.57,134.57 186.26,134.27 UV1.D11
  BOTTOM w0.127: UV6.A2 182.44,153.64 181.93,153.64 180.52,152.22 180.52,143.96 v1(185.64,138.83) 186.56,137.91 186.56,137.4
DQA1_13: length 24
  BOTTOM w0.102: UV1.F10 187.26,133.25 187.54,133.53 187.97,133.53 188.18,133.74 188.18,134 188.15,134.03 188.15,134.51 188.26,134.61 188.26,134.79 188.15,134.89 188.15,135.69 187.9,135.94 187.9,137.4
  BOTTOM w0.127: 187.9,137.4 187.9,138.19 v1(185.39,140.7) 181.96,144.13 181.96,151.31 182.65,152.01 183.21,152.01 UV6.B4
DQA1_14: length 20.7
  BOTTOM w0.102: 187.34,137.4 187.34,136.19 187.16,136.01 187.16,135.2 UV1.A10
  BOTTOM w0.127: 187.34,137.4 v1(187.34,138.21) 181.28,144.27 181.28,151.17 182.5,152.39 UV6.A4
DQA1_15: length 23.9
  BOTTOM w0.102: UV1.C10 186.77,134.59 186.77,134.96 186.76,134.97 186.76,135.23 186.96,135.43 186.96,136.4 186.96,136.4 186.96,137.38 186.94,137.4
  BOTTOM w0.127: UV6.B2 183.16,153.56 183.16,153.02 182.91,152.77 182.34,152.77 180.9,151.33 180.9,144.12 v1(183.67,141.34) 186.94,138.07 186.94,137.4
DQA1_16: length 31.1
  TOP w0.102: v2(185.45,132.26) 185.45,132.39 186.02,132.96 186.18,132.96 186.23,133.01 186.75,133.01 186.97,133.24 186.97,136.39 187.16,136.58
  TOP w0.127: 187.16,136.58 187.16,136.89 187.79,137.52 187.79,137.76 187.6,137.95 187.6,138.13 187.78,138.31 187.96,138.31 188.15,138.12 188.39,138.12 188.62,138.35 v1(189,138.35) 192.07,138.35 197.35,143.63 197.35,148.99 197.13,149.2 197.13,149.38 197.4,149.66 197.4,149.84 197.22,150.02 197.04,150.02 196.77,149.74 196.59,149.74 196.12,150.22 196.12,151.6 195.69,152.02 195.17,152.02 UV3.B4
  BOTTOM w0.102: UV1.G13 185.42,132.26 185.44,132.26 185.45,132.26 v2(185.45,132.26)
DQA1_17: length 34.7
  TOP w0.102: 188.36,137.01 187.93,136.58 187.76,136.58 187.38,136.2 187.38,135.27 188.08,134.57 188.08,132.96 186.42,131.31 184.81,131.31 v2(184.62,131.5)
  TOP w0.127: UV3.B2 195.23,153.56 195.73,153.56 196.04,153.25 196.51,153.25 196.88,152.88 196.88,151.76 198.16,150.47 198.16,143.37 v1(193.44,138.64) 192.38,137.59 188.94,137.59 188.36,137.01
  BOTTOM w0.102: v2(184.62,131.5) 185.02,131.1 UV1.H13
DQA1_18: length 33.4
  TOP w0.102: 188.34,136.55 188.28,136.49 188.28,132.88 186.2,130.8 v2(185.7,130.8)
  TOP w0.127: 188.34,136.55 189.14,137.36 192.69,137.36 v1(196.11,140.77) 198.55,143.21 198.55,150.63 197.26,151.91 197.26,153.17 196.71,153.72 196.08,153.72 195.8,154 UV3.A2
  BOTTOM w0.102: UV1.J13 185.2,130.3 v2(185.7,130.8)
DQA1_19: length 31.2
  TOP w0.102: 187.53,136.72 187.38,136.57 187.38,136.49 187.25,136.36 187.24,136.36 187.18,136.3 187.18,133.53 187.18,133.53 187.18,133.15 186.83,132.81 186.73,132.81 186.46,132.54 186.46,131.94 186.21,131.69 v2(185.77,131.69)
  TOP w0.127: 187.53,136.72 188.78,137.97 v1(191.48,137.97) 192.23,137.97 197.78,143.52 197.78,150.31 197.35,150.75 197.17,150.75 196.89,150.47 196.71,150.47 196.53,150.65 196.53,150.83 196.81,151.11 196.81,151.29 196.5,151.6 196.5,152.27 196.37,152.39 UV3.A4
  BOTTOM w0.102: UV1.H11 185.77,131.6 v2(185.77,131.69)
DQA1_20: length 40
  TOP w0.102: v2(188.43,131.5) 188.43,132.13 188.94,132.64 188.94,134.1 191.1,136.26
  TOP w0.127: 191.1,136.26 191.29,136.45 193.41,136.45 199.69,142.73 v1(199.69,146) 199.69,153.26 197.06,155.88 194.02,155.88 193.65,155.51 193.65,154.77 193.27,154.4 193.1,154.4 192.85,154.14 192.85,152.85 UV3.E4
  BOTTOM w0.102: v2(188.43,131.5) 187.67,131.5 UV1.G10
DQA1_21: length 41.2
  TOP w0.102: 190.97,135.28 190.89,135.28 189.35,133.74 189.35,132.47 189.26,132.38 v2(189.26,131.5)
  TOP w0.127: UV3.F2 192.02,154.42 192.02,156.12 192.89,156.99 197.03,156.99 200.45,153.57 v1(200.45,142.95) 200.45,142.4 193.99,135.94 192.73,135.94 192.07,135.28 190.97,135.28
  BOTTOM w0.102: UV1.G8 188.87,131.9 189.26,131.51 189.26,131.5 v2(189.26,131.5)
DQA1_22: length 46.9
  TOP w0.102: 190.47,134.55 190.15,134.23 190.15,133.28 189.64,132.77 189.64,131.3 189.42,131.08 189.11,131.08 188.88,130.85 188.88,130.32 v2(188.46,129.9)
  TOP w0.127: 190.47,134.55 190.91,134.99 192.37,134.99 192.94,135.56 194.15,135.56 200.83,142.24 200.83,153.73 v1(199.48,155.08) 197.08,157.48 192.59,157.48 191.33,156.22 191.33,155.65 191.15,155.47 191.15,152.84 UV3.F4
  BOTTOM w0.102: UV1.K9 v2(188.46,129.9)
DQA1_23: length 41.5
  TOP w0.102: v2(187.66,129.91) 187.66,130.15 188.08,130.57 188.08,130.86 188.34,131.12 188.65,131.12 188.81,131.28 188.81,132.22 189.14,132.55 189.14,133.92 191.16,135.94
  TOP w0.127: UV3.E2 192.4,154.12 192.84,154.56 192.84,155.8 193.56,156.52 196.96,156.52 200.07,153.41 200.07,142.58 v1(198.2,140.71) 193.72,136.22 191.44,136.22 191.16,135.94
  BOTTOM w0.102: v2(187.66,129.91) 187.26,129.51 UV1.K10
DQA1_24: length 18.5
  BOTTOM w0.102: 190.46,137.21 190.21,136.96 190.15,136.96 189.08,135.88 189.08,135.48 189.2,135.36 189.2,134.85 189.07,134.72 189.07,134.28 188.94,134.15 188.94,133.65 188.97,133.63 188.97,133.37 188.37,132.77 188.37,132.21 UV1.G9 ; UV6.N11 192.4,146.79 192.79,146.4 192.79,146.38
  BOTTOM w0.127: 192.79,146.38 192.79,145.11 193.07,144.83 193.34,144.83 193.6,144.58 193.6,142.75 193.64,142.71 v1(193.64,141.24) 193.64,139.58 192.22,138.16 191.41,138.16 190.46,137.21
DQA1_25: length 12.7
  BOTTOM w0.102: UV1.A8 188.67,135.11 188.67,136.08 188.98,136.39 188.98,136.56 ; 188.98,136.8 189.57,137.4
  BOTTOM w0.127: 188.98,136.56 188.98,136.8 ; 189.57,137.4 191.12,138.94 191.75,138.94 191.93,139.12 191.93,139.14 v1(192.6,139.81) 192.88,140.09 192.88,142.03 191.99,142.91 191.99,144.8 UV6.M13
DQA1_26: length 13.7
  BOTTOM w0.102: 190.11,137.4 189.47,136.75 189.47,136.56 188.87,135.97 188.87,135.4 188.99,135.28 188.99,134.93 188.66,134.6 UV1.C8
  BOTTOM w0.127: UV6.N13 192.4,144.93 192.79,144.53 192.79,143.02 193.26,142.55 193.26,139.74 192.08,138.56 v1(191.27,138.56) 190.11,137.4
DQA1_27: length 16.4
  BOTTOM w0.102: UV1.E8 188.62,133.54 188.62,133.85 188.36,134.11 188.36,134.43 188.46,134.53 188.46,134.87 188.36,134.97 188.36,135.23 188.47,135.34 188.47,136.24 188.65,136.42 188.65,136.59 ; 191.2,146.4 191.59,146.79 UV6.M11
  BOTTOM w0.127: 188.65,136.59 188.65,137.16 v1(189.56,138.08) 191.18,139.69 191.94,139.69 192.5,140.25 192.5,141.76 191.2,143.06 191.2,146.4
DQA1_28: length 13.9
  BOTTOM w0.127: UV1.A6 190.43,135.26 190.43,135.77 191.67,137.02 192.69,137.02 194.18,138.51 196.05,140.37 v1(196.05,141.33) 196.05,144.45 195.74,144.76 195.42,144.76 194.99,145.19 UV6.T13
DQA1_29: length 14.7
  BOTTOM w0.102: 190.78,135.4 190.78,134.82 UV1.C6
  BOTTOM w0.127: 190.78,135.4 190.78,135.72 191.85,136.79 193,136.79 194.39,138.17 v1(195.99,139.78) 196.43,140.22 196.43,144.77 196.01,145.19 UV6.U13
DQA1_30: length 19.9
  BOTTOM w0.102: UV1.E6 190.26,133.87 191,134.61 191.23,134.61 191.48,134.86 191.48,135.79 191.89,136.2 193.49,136.2 193.79,136.49
  BOTTOM w0.127: UV6.T11 195.21,147.21 196.59,147.21 197.2,146.61 v1(197.2,140.67) 197.2,139.9 193.79,136.49
DQA1_31: length 15.7
  BOTTOM w0.127: UV6.U11 196.15,146.79 196.82,146.13 196.82,140.06 v1(195.2,138.45) 193.27,136.51 191.9,136.51 191.16,135.78 UV1.A5
DQB0_0: length 19.3
  TOP w0.102: v2(190.97,133.85) 191.35,133.47 191.81,133.47 191.99,133.64 192.82,133.64 193.44,133.02 194.09,133.02
  TOP w0.127: UV7.T13 205.13,141.15 203.79,141.15 v1(196.82,134.18) 195.52,132.88 194.23,132.88 194.09,133.02
  BOTTOM w0.102: v2(190.97,133.85) 191.16,134.04 UV1.C5
DQB0_1: length 18.7
  TOP w0.102: v2(191.61,133.85) 192.9,133.85 193.49,133.26 194.39,133.26
  TOP w0.127: 194.39,133.26 195.36,133.26 v1(199.07,136.97) 204.14,142.04 205.04,142.04 UV7.U13
  BOTTOM w0.102: UV1.C3 v2(191.61,133.85)
DQB0_2: length 19.5
  TOP w0.102: v2(193.45,134.04) 193.85,133.64 194.39,133.64 ; UV7.U11 206.76,141.92
  TOP w0.127: 206.76,141.92 206.49,142.18 206.26,142.42 203.98,142.42 v1(201.31,139.75) 195.2,133.64 194.39,133.64
  BOTTOM w0.127: UV1.E3 192.31,133.4 192.75,133.84 193.26,133.84 v2(193.45,134.04)
DQB0_3: length 20.5
  TOP w0.102: UV7.T11 207.56,141.12 ; 194.39,134.02 194.1,134.02 v2(194.08,134.04)
  TOP w0.127: 194.39,134.02 v1(194.85,134.02) 195.05,134.02 203.82,142.8 206.7,142.8 207.56,141.95 207.56,141.12
  BOTTOM w0.127: v2(194.08,134.04) 194.08,133.85 193.64,133.4 UV1.E1
DQB0_4: length 17.8
  TOP w0.102: 194.39,131.74 194.07,131.74 v2(194.06,131.75) ; UV7.N11 206.76,138.72
  TOP w0.127: 206.76,138.72 203.97,138.72 202.85,137.59 201.85,137.59 v1(196.44,132.19) 195.94,131.69 195.79,131.69 195.74,131.74 194.39,131.74
  BOTTOM w0.102: UV1.F1 193.46,132.5 194.04,131.92 194.04,131.75 v2(194.06,131.75)
DQB0_5: length 17.8
  TOP w0.102: v2(192.46,132.8) 192.46,131.66 192.75,131.37 193.42,131.37 193.62,131.17 194.04,131.17 194.22,130.98 194.23,130.97 194.39,130.97 ; UV7.M13 205.56,137.52 205.16,137.12
  TOP w0.127: 205.16,137.12 203.71,137.12 203.42,136.83 202.17,136.83 v1(198.12,132.78) 196.26,130.93 195.47,130.93 195.42,130.97 194.39,130.97
  BOTTOM w0.102: UV1.F3 192.15,132.5 v2(192.46,132.8)
DQB0_6: length 20.7
  TOP w0.102: 194.39,130.59 194.26,130.59 193.89,130.96 193.54,130.96 193.33,131.17 192.67,131.17 192.15,131.69 v2(190.91,131.69) ; UV7.M11 207.16,137.52 206.76,137.12
  TOP w0.127: 206.76,137.12 206.28,137.12 205.96,136.79 205.96,136.52 205.76,136.32 203.42,136.32 202.98,135.89 201.76,135.89 196.42,130.54 v1(195.61,130.54) 195.31,130.54 195.26,130.59 194.39,130.59
  BOTTOM w0.102: UV1.F5 191.18,132.42 191.18,132.11 190.91,131.84 v2(190.91,131.69)
DQB0_7: length 17.4
  TOP w0.102: UV7.N13 205.56,138.32 205.16,137.92 ; 194.39,131.35 194.23,131.35 194.22,131.37 193.83,131.37 193.5,131.7 v2(193.5,131.81)
  TOP w0.127: 194.39,131.35 195.58,131.35 195.63,131.31 196.1,131.31 v1(200.3,135.51) 202.01,137.21 203.23,137.21 203.93,137.92 205.16,137.92
  BOTTOM w0.102: v2(193.5,131.81) 193.12,132.2 192.78,132.2 192.59,132.01 192.34,132.01 192.03,131.7 UV1.G4
DQB0_8: length 43
  BOTTOM w0.102: 194.39,131.49 194.23,131.33 193.88,131.33 193.83,131.38 193.1,131.38 193.07,131.41 192.65,131.41 192.63,131.38 192.3,131.38 192.27,131.41 191.85,131.41 191.34,130.9 UV1.H5
  BOTTOM w0.127: UV8.F2 214.71,137.87 215.88,137.87 217.07,139.05 217.07,142.8 214.98,144.9 v1(209.99,144.9) 208.38,144.9 208.05,145.23 202.94,145.23 198.35,140.64 198.35,139.47 195.8,136.92 195.8,132.9 194.39,131.49
DQB0_9: length 46.6
  BOTTOM w0.102: UV1.H6 190.9,131.1 191.36,131.56 191.36,131.83 191.67,132.14 191.67,132.58 192.28,133.18 192.65,133.18 192.74,133.1 193.87,133.1 194.39,133.61
  BOTTOM w0.127: UV8.F4 213.21,137.06 215.97,137.06 217.45,138.55 217.45,142.97 215,145.42 v1(212.13,145.42) 208.4,145.42 208.21,145.61 202.74,145.61 197.96,140.83 197.96,139.63 195.42,137.09 195.42,134.65 194.39,133.61
DQB0_10: length 41.4
  BOTTOM w0.102: 194.39,130.53 194.32,130.53 193.6,129.81 192.6,129.81 192.59,129.8 191.97,129.8 UV1.J4
  BOTTOM w0.127: 194.39,130.53 194.54,130.53 196.56,132.55 196.56,136.59 199.13,139.15 199.13,140.32 v1(201.06,142.25) 203.13,144.32 207.86,144.32 208.2,143.99 214.42,143.99 216.31,142.1 216.31,139.82 216.01,139.52 214.99,139.52 214.72,139.24 214.72,139 214.46,138.74 213.18,138.74 UV8.E4
DQB0_11: length 43
  BOTTOM w0.102: 194.39,130.94 193.25,130.94 192.99,131.21 192.74,131.21 192.71,131.18 192.21,131.18 192.19,131.21 191.94,131.21 191.61,130.88 191.61,130.48 190.63,129.5 UV1.K6
  BOTTOM w0.127: 194.39,130.94 194.42,130.94 196.18,132.71 196.18,136.76 198.73,139.31 198.73,140.48 203.1,144.85 207.89,144.85 208.23,144.51 v1(214.21,144.51) 214.72,144.51 216.69,142.55 216.69,139.35 216.07,138.72 214.77,138.72 UV8.E2
DQB0_12: length 33.2
  BOTTOM w0.102: UV1.K5 191.57,129 192.99,129 193.09,129.1 193.26,129.1 193.3,129.14 193.82,129.14 194.04,129.35 194.39,129.35
  BOTTOM w0.127: 194.39,129.35 194.98,129.35 198.24,132.61 198.24,136.65 v1(199.61,138.02) 200.27,138.68 200.27,139.79 203.67,143.18 207.39,143.18 207.72,142.84 213.68,142.84 214.36,142.16 UV8.A2
DQB0_13: length 33.3
  BOTTOM w0.102: UV1.L4 191.84,128.32 192.21,128.32 192.34,128.2 192.62,128.2 192.65,128.22 192.81,128.22 192.88,128.29 193.53,128.29 194.21,128.97 194.39,128.97
  BOTTOM w0.127: UV8.B2 213.95,141.12 213.95,142.03 213.52,142.46 207.57,142.46 207.23,142.8 203.82,142.8 200.65,139.63 200.65,138.52 198.62,136.49 v1(198.62,133.39) 198.62,132.45 195.14,128.97 194.39,128.97
DQB0_14: length 31.9
  BOTTOM w0.102: UV1.M6 190.65,128.09 192.16,128.09 192.25,127.99 192.71,127.99 192.73,128.02 192.89,128.02 192.96,128.09 193.61,128.09 194.12,128.59 194.39,128.59
  BOTTOM w0.127: 194.39,128.59 195.3,128.59 199,132.29 v1(199,135.82) 199,136.33 201.03,138.36 201.03,139.47 203.98,142.42 207.07,142.42 207.41,142.08 212.49,142.08 212.76,141.81 UV8.A4
DQB0_15: length 30.9
  BOTTOM w0.102: 194.16,128.21 193.84,127.88 193.05,127.88 UV1.M1
  BOTTOM w0.127: 194.16,128.21 195.46,128.21 199.48,132.23 199.48,136.13 201.51,138.16 v1(201.51,139.18) 201.51,139.37 202.34,140.2 202.52,140.2 202.91,139.8 203.09,139.8 203.27,139.98 203.27,140.16 202.88,140.55 202.88,140.73 204.08,141.94 207.01,141.94 207.1,141.85 212.18,141.85 212.37,141.66 212.37,141.1 UV8.B4
DQB0_16: length 18.1
  BOTTOM w0.102: UV1.M3 192.06,127.54 192.11,127.49 192.59,127.49 192.69,127.4 193,127.4 193.27,127.66 194.06,127.66 194.23,127.83 194.39,127.83 ; UV8.M11 207.16,132.72 206.76,133.12
  BOTTOM w0.127: 206.76,133.12 203.43,133.12 202.64,132.33 202.64,131.86 201.2,130.42 v1(200.4,130.42) 198.78,130.42 196.19,127.83 194.39,127.83
DQB0_17: length 17.1
  BOTTOM w0.102: UV1.M5 191.26,127.64 191.67,127.24 192.53,127.24 192.59,127.18 193.09,127.18 193.35,127.45 194.39,127.45
  BOTTOM w0.127: 194.39,127.45 v1(196.02,127.45) 196.35,127.45 198.94,130.04 201.36,130.04 203.03,131.7 203.03,132.07 203.27,132.32 205.16,132.32 UV8.M13
DQB0_18: length 16.4
  BOTTOM w0.102: UV1.N4 191.66,126.73 191.77,126.63 192.27,126.63 192.34,126.55 192.55,126.55 192.62,126.61 193.67,126.61 194.12,127.07 194.39,127.07
  BOTTOM w0.127: 194.39,127.07 196.51,127.07 v1(198.76,129.31) 199.1,129.66 201.52,129.66 203.38,131.52 204.9,131.52 205.3,131.92 UV8.N13
DQB0_19: length 19.3
  BOTTOM w0.102: 206.75,131.52 206.76,131.52 207.16,131.91 UV8.N11 ; 194.39,126.69 194.03,126.69 193.75,126.41 192.73,126.41 192.61,126.28 192.32,126.28 192.18,126.42 190.59,126.42 UV1.P6
  BOTTOM w0.127: 194.39,126.69 196.67,126.69 v1(197.77,127.79) 199.26,129.27 201.68,129.27 203.12,130.72 204.94,130.72 205.2,130.97 205.2,131.24 205.47,131.52 206.75,131.52
DQB0_20: length 16.6
  BOTTOM w0.102: 194.39,125.54 194.38,125.54 194.21,125.71 193.21,125.71 193.1,125.59 192.65,125.59 192.45,125.8 191.94,125.8 191.63,126.1 UV1.P5
  BOTTOM w0.127: 194.39,125.54 v1(196.04,125.54) 197.14,125.54 199.73,128.13 202.15,128.13 202.32,128.3 204.85,128.3 205.13,128.57 205.13,128.89 205.56,129.32 UV8.T13
DQB0_21: length 15.9
  BOTTOM w0.102: UV1.R4 192.03,125.3 192.34,125 192.59,125 192.6,125.01 192.65,125.01 193.07,125.01 193.18,124.91 193.78,124.91 194.03,125.16 194.39,125.16
  BOTTOM w0.127: UV8.U13 205.56,128.3 205.17,127.92 202.47,127.92 202.31,127.75 199.89,127.75 v1(197.86,125.72) 197.3,125.16 194.39,125.16
DQB0_22: length 19.4
  BOTTOM w0.102: UV1.T6 190.46,125.02 190.72,125.27 191.26,125.27 191.54,125 192.05,125 192.26,124.79 192.72,124.79 192.74,124.81 192.99,124.81 193.09,124.7 193.95,124.7 194.02,124.78 194.39,124.78
  BOTTOM w0.127: 194.39,124.78 197.46,124.78 v1(199.49,126.81) 200.05,127.37 202.47,127.37 202.59,127.5 206.5,127.5 207.16,128.16 UV8.U11
DQB0_23: length 18.1
  BOTTOM w0.102: UV1.T1 194.28,124.5 194.38,124.4 194.39,124.4
  BOTTOM w0.127: UV8.T11 207.58,129.1 207.58,127.72 206.98,127.12 202.75,127.12 202.62,126.99 v1(201.41,126.99) 200.21,126.99 197.62,124.4 194.39,124.4
DQB0_24: length 23.9
  TOP w0.127: UV7.A4 212.76,128.32 212.26,127.81 210.94,127.81 210.04,126.91 195.78,126.91 v1(195.39,126.51) 192.94,124.06 v2(192.94,123.96)
  BOTTOM w0.102: UV1.U4 191.98,123.39 192.64,123.39 192.94,123.68 v2(192.94,123.96)
DQB0_25: length 25.3
  TOP w0.127: UV7.B4 212.39,129.14 212.39,128.62 211.96,128.2 210.79,128.2 209.88,127.29 v1(200.96,127.29) 194.77,127.29 v2(190.91,123.43)
  BOTTOM w0.102: UV1.V6 190.58,123.1 v2(190.91,123.43)
DQB0_26: length 25
  TOP w0.127: UV7.B2 213.93,129.08 213.93,128.58 213.61,128.27 213.61,127.8 213.25,127.43 211.1,127.43 210.2,126.53 v1(197.17,126.53) 196.48,126.53 194.08,124.13 v2(194.08,124.12)
  BOTTOM w0.102: UV1.V1 192.86,123.03 193.39,123.56 193.72,123.56 194.08,123.93 v2(194.08,124.12)
DQB0_27: length 25.5
  TOP w0.127: v2(193.53,124.06) 193.87,123.73 194.28,123.73 196.71,126.15 v1(199.23,126.15) 210.36,126.15 211.26,127.05 213.53,127.05 214.08,127.61 214.08,128.23 214.36,128.51 UV7.A2
  BOTTOM w0.102: UV1.V3 192.35,123.18 192.73,123.18 193.53,123.99 v2(193.53,124.06)
DQB0_28: length 35.5
  TOP w0.127: UV7.E4 213.21,131.46 214.51,131.46 214.76,131.21 214.76,130.92 215.02,130.66 216.02,130.66 216.35,130.33 216.35,127.86 213.49,125 v1(205.96,125) 197.18,125 194.75,122.57 191.7,122.57 v2(190.91,121.77)
  BOTTOM w0.102: v2(190.91,121.77) 190.46,121.33 UV1.Y6
DQB0_29: length 34
  TOP w0.127: UV7.F2 214.79,132.29 215.96,132.29 217.35,130.89 217.35,127.79 213.81,124.24 v1(210.58,124.24) 197.5,124.24 195.06,121.81 193.46,121.81 v2(193.45,121.8)
  BOTTOM w0.102: v2(193.45,121.8) 192.95,121.3 UV1.Y1
DQB0_30: length 33.4
  TOP w0.127: v2(192.88,121.85) 193.22,122.19 194.91,122.19 197.34,124.62 v1(203.47,124.62) 213.65,124.62 216.88,127.86 216.88,130.75 216.16,131.48 214.93,131.48 214.49,131.92 UV7.E2
  BOTTOM w0.102: UV1.Y3 192.33,121.3 v2(192.88,121.85)
DQB0_31: length 38.9
  TOP w0.127: v2(191.67,120.98) 192.08,121.39 195.18,121.39 195.91,122.11 v1(196.26,122.47) 197.65,123.86 213.97,123.86 217.74,127.63 217.74,131.05 216.14,132.64 216.14,132.86 215.83,133.17 213.21,133.17 UV7.F4
  BOTTOM w0.102: v2(191.67,120.98) 191.35,121.3 UV1.Y5
DQB1_0: length 39.3
  BOTTOM w0.102: UV1.AA4 191.98,120.5 192.47,121 193.19,121 193.97,121.78 194.39,121.78
  BOTTOM w0.127: UV10.F4 213.02,116.67 216.16,116.67 217.26,117.77 217.26,122.57 214.05,125.79 200.86,125.79 198.93,123.86 196.85,121.78 v1(196.26,121.78) 194.39,121.78
DQB1_1: length 37.2
  BOTTOM w0.102: 194.39,121.4 194.28,121.4 193.09,120.21 192.61,120.21 192.59,120.18 191,120.18 190.46,119.64 UV1.AB6
  BOTTOM w0.127: 194.39,121.4 197.01,121.4 199.09,123.48 200.87,125.26 v1(202.06,125.26) 214.02,125.26 216.88,122.4 216.88,118.66 215.69,117.47 214.52,117.47 UV10.F2
DQB1_2: length 32.9
  BOTTOM w0.102: 194.39,120.64 194.09,120.64 193.15,119.7 UV1.AB1
  BOTTOM w0.127: UV10.E4 212.99,118.34 214.27,118.34 214.53,118.61 214.53,118.85 214.8,119.12 215.82,119.12 216.12,119.42 216.12,121.71 213.47,124.35 v1(207.06,124.35) 201.04,124.35 199.17,122.48 199.16,122.48 197.32,120.64 194.39,120.64
DQB1_3: length 33.7
  BOTTOM w0.102: 194.39,121.02 194.18,121.02 193.17,120.01 192.69,120.01 192.67,119.98 192.34,119.98 UV1.AB3
  BOTTOM w0.127: 194.39,121.02 197.17,121.02 199.24,123.1 201.03,124.88 v1(204.33,124.88) 213.77,124.88 216.5,122.15 216.5,118.95 215.88,118.33 214.58,118.33 UV10.E2
DQB1_4: length 24.9
  BOTTOM w0.102: UV1.AD6 191.03,117.9 191.14,117.8 191.63,117.8 191.83,117.59 192.34,117.59 192.54,117.79 193.42,117.79 193.97,118.35 194.39,118.35
  BOTTOM w0.127: 194.39,118.35 v1(198.01,118.35) 198.27,118.35 201.69,121.77 211.67,121.77 212.18,121.26 212.18,120.71 UV10.B4
DQB1_5: length 22.8
  BOTTOM w0.102: 194.39,118.73 193.96,118.73 193.32,118.1 UV1.AD1
  BOTTOM w0.127: 194.39,118.73 198.11,118.73 v1(200.69,121.3) 201.83,122.45 212.44,122.45 212.57,122.32 UV10.A4
DQB1_6: length 25.6
  BOTTOM w0.102: UV1.AD3 192.14,118.1 192.85,118.81 193.2,118.81 193.88,119.5 194.39,119.5
  BOTTOM w0.127: UV10.A2 214.15,121.14 214.15,122.04 212.98,123.21 201.51,123.21 v1(198.69,120.38) 197.8,119.5 194.39,119.5
DQB1_7: length 26.9
  BOTTOM w0.102: 194.39,119.11 193.79,119.11 193.28,118.6 192.93,118.6 192.5,118.17 192.5,118.04 192.26,117.8 191.91,117.8 191.61,118.1 UV1.AD5
  BOTTOM w0.127: 194.39,119.11 v1(196.09,119.11) 197.96,119.11 201.67,122.83 212.82,122.83 213.76,121.89 213.76,120.73 UV10.B2
DQB1_8: length 16.5
  TOP w0.127: v2(194.73,117.34) 195.15,117.76 195.24,117.76 v1(198.3,120.82) 199.24,121.76 206.33,121.76 UV9.U11
  BOTTOM w0.102: UV1.AF1 192.96,116.6 193.31,116.6 193.43,116.73 194.12,116.73 194.39,116.99
  BOTTOM w0.127: 194.39,116.99 v2(194.73,117.34)
DQB1_9: length 20.5
  TOP w0.127: v2(193.56,117.35) 193.56,116.73 193.26,116.42 193.26,115.46 193.59,115.13 195.85,115.13 196.37,115.65 196.37,115.99 v1(197.96,117.58) 199.84,119.46 202.62,119.46 203.76,118.32 206.57,118.32 UV9.N11
  BOTTOM w0.102: UV1.AF3 192.06,116.73 192.33,117 192.34,117 192.59,117 192.61,117.02 193.12,117.02 193.45,117.35 v2(193.56,117.35)
DQB1_10: length 21.1
  TOP w0.127: v2(194.16,117.35) 194.16,117.36 194.96,118.16 195.11,118.16 199.08,122.14 v1(200.14,122.14) 206.56,122.14 207.37,121.33 207.37,120.72 UV9.T11
  BOTTOM w0.102: v2(194.16,117.35) 193.74,116.93 193.35,116.93 193.23,116.82 192.71,116.82 192.42,116.53 192.42,116.4 192.14,116.12 190.96,116.12 190.78,116.3 UV1.AF6
DQB1_11: length 16.3
  TOP w0.127: UV9.U13 204.96,121.53 203.66,121.53 203.47,121.34 199.36,121.34 v1(197.16,119.14) 195.32,117.3 v2(195.32,117.29)
  BOTTOM w0.102: 194.39,116.47 193.48,116.47 193.07,116.07 192.38,116.07 192.02,115.7 UV1.AG4
  BOTTOM w0.127: 194.39,116.47 194.5,116.47 v2(195.32,117.29)
DQB1_12: length 16.7
  TOP w0.127: UV9.T13 204.97,120.72 199.36,120.72 v1(196.19,117.54) 195.5,116.86 195.18,116.86 194.31,115.99 v2(194.31,115.97)
  BOTTOM w0.102: v2(194.31,115.97) 193.77,115.42 192.59,115.42 192.41,115.24 191.81,115.24 191.47,114.9 UV1.AH5
DQB1_13: length 18.4
  TOP w0.127: v2(195.22,114.25) 196.1,114.25 197.15,115.29 197.15,115.69 200.15,118.7 v1(201.35,118.7) 201.78,118.7 203.76,116.72 204.96,116.72 UV9.M13
  BOTTOM w0.102: UV1.AH6 190.77,114.7 190.91,114.56 192.2,114.56 192.25,114.61 192.67,114.61 192.69,114.59 193.01,114.59 193.23,114.81 193.83,114.81 193.96,114.68 194.39,114.68
  BOTTOM w0.127: 194.39,114.68 194.78,114.68 v2(195.22,114.25)
DQB1_14: length 17.1
  TOP w0.127: v2(194.05,114.24) 194.54,114.73 196.03,114.73 196.76,115.47 v1(196.76,115.85) 199.99,119.08 202.24,119.08 203.8,117.52 204.96,117.52 UV9.N13
  BOTTOM w0.102: v2(194.05,114.24) 193.68,114.61 193.31,114.61 193.09,114.39 192.6,114.39 192.59,114.41 192.34,114.41 192.27,114.34 192,114.34 191.76,114.1 UV1.AJ4
DQB1_15: length 19.2
  TOP w0.127: UV9.M11 206.57,116.72 206.09,116.72 205.77,116.4 205.77,116.12 205.57,115.93 203.76,115.93 201.37,118.32 200.31,118.32 197.62,115.62 197.62,115.23 v1(196.22,113.83) 195.01,113.83 v2(194.62,114.23)
  BOTTOM w0.102: UV1.AK3 192.26,113.3 192.79,113.83 194.22,113.83 194.39,114
  BOTTOM w0.127: 194.39,114 v2(194.62,114.23)
DQB1_16: length 32.6
  TOP w0.127: v2(188.99,115.98) 188.99,115.87 189.37,115.48 191.21,115.48 192.69,114.01 192.69,112.07 193.13,111.63 195.33,111.63 195.46,111.5 195.46,111.25 195.58,111.13 195.84,111.13 195.96,111.25 195.96,111.5 196.09,111.63 196.34,111.63 196.47,111.5 196.47,111.25 196.6,111.13 196.85,111.13 196.98,111.25 196.98,111.51 197.11,111.64 197.31,111.64 197.43,111.51 197.43,111.25 197.56,111.13 197.86,111.13 v1(198.99,109.99) 202.85,106.13 211.61,106.13 212.57,107.09 UV9.A4
  BOTTOM w0.102: UV1.AF8 188.86,116.11 v2(188.99,115.98)
DQB1_17: length 33
  TOP w0.127: UV9.B4 212.2,108.75 212.2,107.57 211.91,107.29 211.73,107.29 211.46,107.56 211.23,107.56 211.01,107.34 211.01,107.16 211.21,106.96 211.21,106.78 211.03,106.6 210.85,106.6 210.65,106.8 210.47,106.8 210.24,106.57 202.96,106.57 v1(200.78,108.75) 197.51,112.02 193.23,112.02 192.97,112.28 192.97,114.23 190.77,116.42 188.72,116.42 v2(188.32,116.02)
  BOTTOM w0.102: UV1.AF9 188.06,116.28 v2(188.32,116.02)
DQB1_18: length 32.6
  TOP w0.127: UV9.A2 214.17,108.17 213.89,107.9 213.89,107.21 212.05,105.37 202.52,105.37 197.53,110.37 v1(193.81,110.37) 193.13,110.37 192.09,111.41 192.09,113.46 191.2,114.35 189.41,114.35 v2(189,114.76)
  BOTTOM w0.102: v2(189,114.76) 188.86,114.9 UV1.AG8
DQB1_19: length 32
  TOP w0.127: v2(189.56,114.76) 191.34,114.76 192.36,113.74 192.36,111.9 193.01,111.25 193.63,111.25 194.14,110.75 v1(196.04,110.75) 197.7,110.75 202.7,105.75 211.77,105.75 213.42,107.4 213.42,107.87 213.73,108.19 213.73,108.68 UV9.B2
  BOTTOM w0.102: v2(189.56,114.76) 189.66,114.86 UV1.AG7
DQB1_20: length 41.5
  TOP w0.127: v2(189.27,113.48) 189.98,112.77 190.39,112.77 191.11,112.04 191.11,110.75 192.74,109.12 197.07,109.12 201.96,104.23 v1(210.46,104.23) 213.62,104.23 216.16,106.77 216.16,109.94 215.83,110.27 214.83,110.27 214.57,110.52 214.57,110.81 214.32,111.07 213.02,111.07 UV9.E4
  BOTTOM w0.102: UV1.AK9 188.36,113.1 188.74,113.48 v2(189.27,113.48)
DQB1_21: length 41.3
  TOP w0.127: v2(190.07,111.9) 190.48,111.49 190.48,109.45 192.15,107.77 v1(195,107.77) 197.29,107.77 201.59,103.47 213.94,103.47 217.16,106.69 217.16,110.66 215.93,111.89 214.6,111.89 UV9.F2
  BOTTOM w0.102: v2(190.07,111.9) 189.67,112.3 UV1.AL7
DQB1_22: length 40.8
  TOP w0.127: v2(189.27,111.91) 189.74,112.37 190.25,112.37 190.78,111.84 190.78,109.69 192.32,108.16 v1(196.97,108.16) 197.45,108.16 201.76,103.85 213.78,103.85 216.69,106.76 216.69,110.36 215.97,111.08 214.73,111.08 214.29,111.52 UV9.E2
  BOTTOM w0.102: v2(189.27,111.91) 188.86,111.5 UV1.AM8
DQB1_23: length 44.2
  TOP w0.127: UV9.F4 213.02,112.77 215.64,112.77 215.83,112.59 215.85,112.59 217.66,110.78 217.66,106.65 214.1,103.08 201.44,103.08 197.13,107.39 v1(192.79,107.39) 192.07,107.39 190.08,109.38 v2(190.08,111.15)
  BOTTOM w0.102: v2(190.08,111.15) 189.73,111.5 UV1.AM7
DQB1_24: length 15.9
  BOTTOM w0.102: UV1.AK1 193.17,113.6 194.39,113.6
  BOTTOM w0.127: UV10.M11 206.56,112.73 203.48,112.73 202.12,111.37 200.42,111.37 199.05,112.74 v1(196.16,112.74) 195.62,112.74 194.76,113.6 194.39,113.6
DQB1_25: length 15.2
  BOTTOM w0.102: 194.39,112.3 194.3,112.3 194.15,112.15 193.79,112.15 193.67,112.03 193.28,112.03 193.1,112.21 192.65,112.21 192.61,112.17 192.31,112.17 192.27,112.21 191.94,112.21 191.66,112.48 UV1.AL4
  BOTTOM w0.127: UV10.M13 204.96,111.91 203.5,111.91 202.51,110.93 200.32,110.93 198.96,112.3 v1(198.48,112.3) 194.39,112.3
DQB1_26: length 16.2
  BOTTOM w0.102: 194.39,111.91 193.91,111.91 193.82,111.83 193.2,111.83 193.02,112.01 192.74,112.01 192.7,111.97 192.23,111.97 192.19,112.01 190.97,112.01 UV1.AM6
  BOTTOM w0.127: UV10.N13 205.22,111.52 204.82,111.11 203.51,111.11 202.94,110.54 200.17,110.54 v1(199.69,111.03) 198.8,111.91 194.39,111.91
DQB1_27: length 15.6
  BOTTOM w0.102: UV1.AM1 192.94,111.62 193.7,111.62 193.79,111.53 194.39,111.53
  BOTTOM w0.127: 194.39,111.53 198.64,111.53 200.07,110.1 v1(201.37,110.1) 203.25,110.1 203.47,110.31 204.7,110.31 204.93,110.54 204.93,110.87 205.17,111.11 206.56,111.11 UV10.N11
DQB1_28: length 15.9
  BOTTOM w0.102: UV1.AN4 192.03,110.9 192.35,110.58 192.87,110.58 193.04,110.4 193.52,110.4 193.54,110.38 194.39,110.38
  BOTTOM w0.127: 194.39,110.38 198.17,110.38 199.73,108.83 202.24,108.83 v1(202.48,108.59) 203.24,107.83 204.71,107.83 204.99,108.1 204.99,108.45 205.37,108.82 UV10.T13
DQB1_29: length 18.9
  BOTTOM w0.102: 194.39,109.22 193.39,109.22 193.04,109.57 192.56,109.57 192.06,110.06 UV1.AP3
  BOTTOM w0.127: UV10.T11 207.41,108.68 207.41,107.61 206.45,106.66 202.53,106.66 201.62,107.57 v1(200.97,107.57) 199.37,107.57 197.72,109.22 194.39,109.22
DQB1_30: length 14.1
  BOTTOM w0.102: 194.39,110 192.96,110 UV1.AP1
  BOTTOM w0.127: 194.39,110 198.02,110 v1(198.22,109.8) 199.58,108.44 202.09,108.44 203.11,107.42 204.7,107.42 205.37,108.09 UV10.U13
DQB1_31: length 18.3
  BOTTOM w0.102: UV1.AP5 191.41,110.1 191.76,110.45 192.17,110.45 192.42,110.2 192.42,110.05 192.68,109.79 193.2,109.79 193.38,109.61 194.39,109.61
  BOTTOM w0.127: 194.39,109.61 v1(196.28,109.61) 197.87,109.61 199.46,108.02 201.71,108.02 202.7,107.04 206.29,107.04 207.06,107.81 207.06,108.22 UV10.U11
DRAM_RST#: length 108
  TOP w0.102: v2(189.59,153.59) 189.2,153.99 UV3.J2 ; v2(169.07,153.66) 169.07,153.68 168.68,154.06 UV5.J2 ; UV9.J2 214.17,114.72 v2(213.77,114.32) ; UV7.J2 214.36,135.12 213.98,134.74 v2(213.96,134.74)
  TOP w0.127: v2(209.96,102.64) RV143.1 RV138.2
  IN3 w0.102: v2(169.07,153.66) 169.07,153.72 169.49,154.14 169.49,155.27 ; 214.21,112.96 214.21,113.34 214.19,113.36 214.19,113.9 v2(213.77,114.32) 214.15,114.7 214.15,121.53 ; 215.6,134.3 215.39,134.3 215.38,134.31 214.44,134.31 214.02,134.74 v2(213.96,134.74) 214.34,135.12 214.34,142.17 214.32,142.18 ; 182.13,153.99 189.2,153.99 v2(189.59,153.59) 189.98,153.98 196.35,153.98
  IN3 w0.157: 214.15,121.53 214.15,125.69 216.31,127.85 216.31,133.59 215.6,134.3 ; v2(209.96,102.64) 214.21,106.9 214.21,112.96 ; 182.13,153.99 179.34,153.99 176.39,156.94 170.56,156.94 169.49,155.87 169.49,155.27 ; 214.32,142.18 212.94,143.56 204.13,143.56 202.76,144.94 202.76,149.66 198.43,153.98 196.35,153.98
  BOTTOM w0.102: v2(189.59,153.59) 189.2,153.99 UV3.J2 ; UV5.J2 168.68,154.04 v2(169.07,153.66) ; UV7.J2 214.36,135.12 213.98,134.74 v2(213.96,134.74) ; UV9.J2 214.17,114.72 v2(213.77,114.32)
  BOTTOM w0.127: v2(209.96,102.64) v1(209.96,102.01)
DRAM_RST#_R: length 29.6
  TOP w0.127: RV144.2 RV145.2 206.21,101.84 205.39,101.84 204.59,102.64 195.27,102.64 193.37,104.54 v1(193.37,104.55) 191.33,106.59 191.33,107.4 189.16,109.57 188.29,109.57 187.24,110.63 187.24,111.8 186.08,112.95 186.08,114.29 v2(185.95,114.42)
  BOTTOM w0.102: UV1.AH11 186.24,114.7 v2(185.95,114.42)
DROOP_CPU: length 6.4
  BOTTOM w0.102: v1(93.58,137.4) PC513.2
  BOTTOM w0.203: PU501.25 90.62,137.05 90.77,136.89 90.96,136.89
  BOTTOM w0.254: 90.96,136.89 91.09,136.89 91.11,136.92 93.04,136.92 PC513.2 PR532.1 PR529.2
DSWODVREN: length 10.6
  BOTTOM w0.076: v1(130.74,101.79) 130.01,102.52 127.81,102.52 127.37,102.96 127.37,103.52 127.12,103.77 126.81,103.77 126.71,103.77 126.45,104.04 126.45,105.3 UC1.AW7
  BOTTOM w0.089: v1(130.74,101.79) 130.83,101.7 131.57,101.7
  BOTTOM w0.102: R2337.1 R2338.1 133.09,101.7 131.57,101.7
EC_ENVDD: length 155.2
  TOP w0.102: v2(214.72,172.21) 215.17,172.66 RX8.2 ; v2(193.48,54.6) 193.41,54.6 193.19,54.37 UE1.71
  IN2 w0.127: v2(214.72,172.21) 215.78,171.16 215.78,156.89 224.83,147.84 224.83,125.61 223.68,124.46 223.68,92.95 220.33,89.61 220.33,81.18 221.9,79.61 221.9,61.88 216.35,56.34 v2(216.35,54.61)
  BOTTOM w0.102: v2(216.35,54.61) 216.1,54.61 215.37,53.87 214.87,53.87 214.11,53.12 214.11,52.42 212.67,50.98 204.19,50.98 204.02,51.14 199.53,51.14 v1(198.69,51.99) 196.52,54.15 193.93,54.15 v2(193.48,54.6)
EC_LID_OUT#: length 123.8
  TOP w0.102: v2(190.63,50.24) 188.8,50.24 188.42,49.86 182.64,49.86 182.38,50.12 UE1.101
  IN1 w0.084: 137.92,109.81 137.76,109.65 135.69,109.65 135.09,110.25 134.36,110.25 133.89,110.72 133.89,110.92 133.61,111.2 129.74,111.2 129.59,111.36 128.1,111.36 127.69,110.95 127.69,110.95 127.53,110.8 125.19,110.8 124.57,111.41 124.57,111.49 124.56,111.49 124.56,112.19 124.61,112.23 124.61,113 125.27,113.67 125.27,114.35 125.6,114.68 126.86,114.68 v2(127.22,115.04)
  IN1 w0.127: v2(190.63,50.24) 190.26,50.6 190.26,51.88 187.76,54.39 187.76,56.51 188.31,57.06 188.31,65.71 187.15,66.87 187.15,75.1 179.76,82.49 177.94,82.49 174.26,86.17 172.21,86.17 171.57,86.82 166.91,86.82 160.21,93.52 160.21,95.99 152.68,103.52 152.68,103.67 147.9,108.46 147.9,109.29 146.99,110.2 144.47,110.2 144.07,110.61 138.72,110.61 137.92,109.81
  BOTTOM w0.089: UC1.AD6 126.99,114.81 v2(127.22,115.04)
  BOTTOM w0.102: v2(190.63,50.24) v1(191.32,50.24)
EC_MUTE#: length 197.1
  TOP w0.102: v2(51.21,46.87) v1(52.78,45.29) 53.65,44.43 53.65,26.52 46.84,19.71 44.53,19.71 43.65,20.59 43.65,21.82 43.14,22.34 42.43,22.34 42.26,22.16 42.26,21.28 41.88,20.9 41.41,20.9 41.14,21.18 UA1.47 ; v2(188.2,54.54) 188.39,54.35 UE1.83
  IN1 w0.127: v2(188.2,54.54) 190.52,52.22 190.52,51.11 191.07,50.56 191.07,43.9 v2(190.47,43.3)
  IN3 w0.127: v2(51.21,46.87) 52.82,45.26 62.49,45.26 63.04,44.71 69.59,44.71 69.89,44.41 79.02,44.41 80.71,42.72 90.77,42.72 91.68,41.81 159.1,41.81 159.64,41.27 182.15,41.27 183.48,42.6 185.81,42.6 186.27,42.14 189.31,42.14 v2(190.47,43.3)
EC_ON: length 71.5
  TOP w0.102: UE1.112 180.72,45.72 180.4,46.04 179.92,46.04 v2(179.67,45.78)
  TOP w0.254: v2(165.95,45.72) v4(165.95,37.49) 165.95,37.14 168.29,34.81 177.33,34.81 180.55,31.6 189.98,31.6 193.37,28.21 197.53,28.21 198.14,28.83 198.14,29.69 199.2,30.74 202.26,30.74 203.13,29.87 203.13,27.79 PR102.1
  IN3 w0.127: v2(179.67,45.78) 177.93,44.05 167.63,44.05 v2(165.95,45.72)
EC_RSMRST#: length 88.5
  TOP w0.089: v2(130.05,100.36) 129.82,100.13 v1(129.82,99.53) 129.82,99.46 129.43,99.06 RC41.1
  TOP w0.102: UE1.100 179.91,50.52 179.53,50.14 177.79,50.14 177.37,50.56 v2(177.37,50.58)
  IN1 w0.127: v2(130.05,100.36) 130.05,99.95 130.69,99.3 132.02,99.3 133.23,98.1 133.46,98.1 134.14,97.41 134.14,96.82 134.73,96.23 135.56,96.23 136.25,95.54 139.6,95.54 155.35,79.8 157.37,79.8 159.75,77.41 169.38,77.41 173.42,73.37 173.42,66.42 174.44,65.4 174.44,62.49 176.76,60.16 176.76,51.19 v2(177.37,50.58)
  BOTTOM w0.089: RE2.2 130.57,100.88 v2(130.05,100.36)
EC_RST#: length 4.4
  TOP w0.102: RE8.1 199.47,40.27 199.71,40.03 v1(199.71,39.99) ; RE8.1 199.28,41.14 198.2,41.14 197.98,40.92 UE1.37 ; RE8.1 CE11.1
EC_RX: length 168
  TOP w0.102: UE1.31 195.19,38.75 v2(195.48,39.04) ; RM13.1 114.98,150.79 115.3,151.11 115.3,151.52 115.5,151.71 JMINI.51
  IN2 w0.127: v2(195.48,39.04) 194.91,38.47 189.23,38.47 188.13,39.57 188.13,43.16 188.29,43.33 188.29,46.57 186.91,47.95 186.91,56.44 187.8,57.33 187.8,63.92 186.38,65.35 186.38,67.58 187.03,68.22 187.03,76.17 184.62,78.57 184.62,79.81 182.91,81.52 182.49,81.52 162.1,101.91 162.1,102.77 161.63,103.24 158.21,103.24 153.42,108.03 153.42,110.38 152.38,111.42 152.38,113.13 151.58,113.93 151.58,116.91 148.74,119.75 144.68,119.75 144.02,120.41 144.02,123.73 137.38,130.37 137.38,140.47 127.18,150.67 116.34,150.67 115.5,151.51 JMINI.51
  BOTTOM w0.102: v2(195.48,39.04) v1(196.08,39.04)
EC_SCI#: length 127.2
  TOP w0.102: v2(155.08,107.34) 154.65,107.34 v1(154.25,106.94) ; UE1.20 190.79,38.54 191.23,38.98 v2(191.42,38.98)
  IN1 w0.127: v2(155.08,107.34) 155.48,106.95 155.48,104.89 166.01,94.36 166.01,92.56 168,90.57 174.17,90.57 179.2,85.54 184.35,85.54 189.51,80.37 189.51,79.3 190.66,78.16 190.66,68.07 191.65,67.08 191.65,60.04 194.31,57.38 194.31,56.18 194.57,55.92 194.57,52.41 194.36,52.21 194.36,42.34 191.96,39.94 191.96,39.52 v2(191.42,38.98)
  IN3 w0.084: v2(127.86,110.02) 129.46,110.02 130.28,109.2 137.82,109.2
  IN3 w0.127: v2(155.08,107.34) 155.08,107.46 152.38,110.15 149.74,110.15 149.33,109.74 147.11,109.74 146,108.64 144.79,108.64 143.94,109.48 138.75,109.48 138.47,109.2 137.82,109.2
  BOTTOM w0.089: UC1.AM2 129.49,109.86 129.12,110.22 128.06,110.22 v2(127.86,110.02)
EC_SMB_CK1: length 240.9
  TOP w0.102: PR18.2 143.36,185.66 143.42,185.6 144.71,185.6 v2(145.16,186.06) ; v2(173.01,172.64) 172.89,172.52 172.51,172.52 PR714.1 ; RP36.4 190.9,56.03 191.2,55.73 191.2,55 190.79,54.6 v2(190.79,54.58) 190.79,54.57 UE1.77
  IN1 w0.127: v2(173.01,172.64) 173.18,172.64 174.23,173.7 174.23,175.72 171.41,178.54 164.91,178.54 162.1,181.34 156.67,181.34 151.47,186.54 145.65,186.54 v2(145.16,186.06)
  IN2 w0.127: v2(173.01,172.64) 172.94,172.64 172.18,171.88 172.18,165.55 174.08,163.64 179.67,163.64 181.26,165.23 188.69,165.23 190.3,166.84 193.73,166.84 198.95,161.62 209.01,161.62 223.05,147.58 223.05,126.99 222.28,126.22 222.28,126.07 222.28,126.07 222.28,93.53 218.93,90.18 218.93,80.6 220.5,79.03 220.5,62.8 213.8,56.1 213.8,52.59 v2(214.72,51.67)
  BOTTOM w0.102: v2(190.79,54.58) 190.93,54.58 v1(192.55,52.95) 193.66,52.95 194.2,52.42 194.2,51.31 195.05,50.46 203.74,50.46 203.9,50.29 212.96,50.29 214.33,51.67 v2(214.72,51.67)
EC_SMB_CK2: length 221.2
  TOP w0.102: v2(152.07,109.01) 152.25,108.83 152.48,108.83 152.64,108.99 152.64,111.03 152.45,111.22 152.45,116.07 151.81,116.71 151.81,127.71 152.46,128.36 156.36,128.36 v2(156.43,128.43) ; QV15.6 178.54,92.67 178.9,92.32 180.42,92.32 180.62,92.52 181.98,92.52 182.46,92.04 182.46,91.56 182.21,91.3 175.51,91.3 171.51,95.3 170.53,95.3 170.23,95.59 170.23,96.46 v2(170.08,96.61) ; UE1.79 189.99,54.51 v2(189.77,54.73) 190.17,55.13 190.17,55.48 189.9,55.75 RP36.2 ; QX6.3 196.55,164.93 196.69,164.79 196.69,163.36 196.5,163.17 195.74,163.17 195.56,162.99 195.56,161.67 195.91,161.32 198.14,161.32 198.7,160.76 198.7,157.33 v2(198.87,157.15)
  IN1 w0.127: v2(189.77,54.73) 189.6,54.89 189.36,54.89 189.04,55.2 189.04,58.69 188.81,58.92 188.81,65.95 187.66,67.11 187.66,76.87 186.17,78.36 185.94,78.36 185.86,78.28 v2(185.86,78.06) ; v2(156.43,128.43) 156.61,128.25 156.81,128.25 157.75,129.19 157.75,134.76 161.06,138.08 161.06,156.05 162.42,157.41 165.52,157.41 166.36,158.24 198.31,158.24 198.7,157.85 198.7,157.33 v2(198.87,157.15)
  IN3 w0.127: v2(152.07,109.01) 152.3,108.78 153.05,108.78 155.08,106.75 159.91,106.75 164.03,102.63 164.03,101.99 169.89,96.13 170.16,96.13 170.27,96.24 170.27,96.43 v2(170.08,96.61) 170.26,96.79 170.26,97.09 170.63,97.46 173.06,97.46 174.12,96.4 174.12,91.5 186.21,79.41 186.21,78.66 185.86,78.32 v2(185.86,78.06)
  BOTTOM w0.102: QH1.6 147.9,115.89 147.68,116.12 147.32,116.12 147.21,116.01 147.21,115.83 147.67,115.37 149.77,115.37 150.21,114.93 150.21,113.05 151.41,111.85 151.41,109.15 151.73,108.83 151.89,108.83 v2(152.07,109.01)
EC_SMB_DA1: length 238.5
  TOP w0.102: UE1.78 190.39,54.9 190.79,55.31 v2(190.79,55.56) 190.4,55.95 RP36.3 ; PR20.2 143.51,185.83 144.36,185.83 v2(144.58,186.05) ; v2(172.97,172.06) 172.43,172.06 PR715.1
  IN1 w0.127: v2(144.58,186.05) 144.58,186.22 145.15,186.79 151.58,186.79 156.77,181.6 162.21,181.6 165.01,178.79 171.52,178.79 174.58,175.73 174.58,173.6 173.04,172.06 v2(172.97,172.06)
  IN2 w0.127: v2(172.97,172.06) 173.38,171.65 173.38,165.06 174.29,164.15 179.46,164.15 181.05,165.74 188.48,165.74 190.09,167.35 193.94,167.35 199.16,162.13 209.22,162.13 223.69,147.66 223.69,126.76 222.79,125.86 222.79,93.32 219.44,89.97 219.44,80.81 221.01,79.24 221.01,62.59 214.7,56.28 v2(214.7,54.51)
  BOTTOM w0.102: v2(190.79,55.56) 190.88,55.65 193.83,55.65 194.86,54.61 197.32,54.61 v1(197.76,54.17) 200.33,51.6 204.21,51.6 204.38,51.44 212.48,51.44 213.65,52.61 213.65,53.47 v2(214.7,54.51)
EC_SMB_DA2: length 207.2
  TOP w0.102: v2(156.43,127.85) 156.14,128.13 152.56,128.13 152.04,127.62 152.04,116.81 152.68,116.16 152.68,111.31 152.87,111.12 152.87,108.9 152.57,108.6 152.25,108.6 v2(152.07,108.42) ; RP36.1 189.4,55.68 v2(189.77,55.31) 189.36,54.9 189.36,54.54 189.59,54.31 UE1.80 ; QX6.6 194.85,163.63 195.33,163.15 195.33,161.57 195.81,161.09 198.05,161.09 198.47,160.67 198.47,157.33 v2(198.29,157.15) ; QV15.3 177.24,96.46 177.14,96.56 177,96.56 176.69,96.25 172.73,96.25 172.01,95.53 170.62,95.53 170.46,95.69 170.46,96.38 v2(170.69,96.61)
  IN1 w0.127: v2(189.77,55.31) 189.6,55.14 189.46,55.14 189.3,55.31 189.3,58.8 189.07,59.02 189.07,66.06 187.91,67.21 187.91,76.98 186.28,78.61 185.84,78.61 185.7,78.47 v2(185.45,78.47) ; v2(198.29,157.15) 198.44,157.3 198.44,157.75 198.2,157.99 166.46,157.99 165.62,157.15 162.53,157.15 161.32,155.94 161.32,137.97 158,134.66 158,129.08 156.91,127.99 156.58,127.99 v2(156.43,127.85)
  IN3 w0.127: v2(152.07,108.42) 152.17,108.52 152.95,108.52 154.97,106.49 159.81,106.49 163.78,102.52 163.78,101.88 169.79,95.87 170.26,95.87 170.52,96.13 170.52,96.44 v2(170.69,96.61) 170.69,96.64 170.51,96.83 170.51,96.99 170.73,97.21 172.95,97.21 173.87,96.29 173.87,91.39 185.95,79.31 185.95,78.77 185.66,78.47 v2(185.45,78.47)
  BOTTOM w0.102: v2(152.07,108.42) 151.89,108.6 151.64,108.6 151.18,109.05 151.18,111.75 149.98,112.96 149.98,114.83 149.67,115.14 147.58,115.14 146.99,115.73 146.99,117 146.79,117.19 QH1.3
EC_SMI#: length 122.7
  TOP w0.102: UE1.15 188.79,39.47 v2(188.8,39.49)
  IN1 w0.127: v2(145.14,112.99) 147.02,112.99 149.74,110.28 150.16,110.28 151.12,109.31 151.12,107.39 151.74,106.77 152.55,106.77 153.44,105.87 153.44,103.83 161.03,96.25 161.03,93.78 167.23,87.58 171.88,87.58 172.53,86.93 174.57,86.93 178.25,83.25 182.13,83.25 188.26,77.12 188.26,67.23 189.32,66.17 189.32,59.13 190.22,58.23 190.22,53.44 190.77,52.9 190.77,51.21 191.32,50.66 191.32,42.02 189.11,39.8 189.11,39.79 188.8,39.49 v2(188.8,39.49)
  IN2 w0.127: v2(134.97,116.96) 135.41,117.4 137.04,117.4 141.09,113.35 143.25,113.35 143.9,112.7 144.85,112.7 v2(145.14,112.99)
  BOTTOM w0.089: v2(134.97,116.96) v1(134.44,117.48) 134.35,117.57 131.58,117.57 131.36,117.35 UC1.V1
  BOTTOM w0.102: RC107.1 144.5,112.99 v2(145.14,112.99)
EC_SPI_CLK_R: length 70.9
  TOP w0.102: UE1.126 v2(182.89,40.12)
  IN1 w0.127: v2(182.89,40.12) 181.26,40.12 180.42,40.96 178.95,40.96 175.21,44.7 175.21,48.27 175.61,48.66 175.61,56.2 v2(174.15,57.66)
  BOTTOM w0.102: v2(174.15,57.66) 173.83,57.98 173.83,59.5 174.72,60.39 186.07,60.39 186.09,60.42 186.43,60.42 186.45,60.39 187.25,60.39 187.57,60.71 187.57,78.08 182.85,82.81 178.24,82.81 T185.1
EC_SPI_CS0#: length 83.1
  TOP w0.102: UE1.128 182.73,39.32 v2(182.85,39.44)
  IN1 w0.127: v2(174.34,59.12) 173.57,58.36 173.57,56.9 175.35,55.12 175.35,48.77 174.96,48.38 174.96,44.59 178.85,40.71 180.05,40.71 181.32,39.44 v2(182.85,39.44)
  BOTTOM w0.102: v2(174.34,59.12) 174.59,59.38 180.11,59.38 181.38,58.11 181.38,56.45 183.56,54.28 186.39,54.28 186.91,54.8 186.91,56.78 188.05,57.93 188.05,78.5 183.12,83.43 175.12,83.43 T186.1
EC_SPI_MISO_1: length 89.7
  TOP w0.102: v2(174.27,58.36) 173.98,58.36 173.19,57.57 172.11,57.57 170.91,56.37 170.91,50.55 171.29,50.17 171.29,48.41 177.04,42.66 177.83,42.66 177.96,42.79 180.2,42.79 180.47,42.52 UE1.120
  BOTTOM w0.102: v2(174.27,58.36) 177.64,58.36 182.45,53.55 187,53.55 187.68,54.23 187.68,56.43 189.02,57.76 189.02,78.9 183.52,84.39 182.72,84.39 170.87,84.39 168.87,82.4 T184.1
EC_SPI_MOSI_1: length 84.6
  TOP w0.102: v2(175.29,58.87) 175.29,58.11 174.34,57.15 172.38,57.15 171.39,56.17 171.39,50.75 171.92,50.22 171.92,48.1 177.13,42.89 177.74,42.89 177.87,43.02 180.33,43.02 180.43,42.92 UE1.119
  BOTTOM w0.102: v2(175.29,58.87) 175.31,58.89 179.91,58.89 180.9,57.9 180.9,56.25 183.23,53.93 186.72,53.93 187.3,54.51 187.3,56.5 188.54,57.73 188.54,78.7 183.32,83.91 182.92,83.91 172.03,83.91 T183.1
EC_TX: length 168.6
  TOP w0.102: UE1.30 194.79,36.74 v2(195.05,36.48) 195.05,35.36 v1(194.96,35.27) ; JMINI.49 114.7,151.84 114.42,151.56 114.42,151.18 114.09,150.85 RM11.2
  IN2 w0.127: v2(195.05,36.48) 194.33,37.2 190.14,37.2 187.87,39.46 187.87,43.27 188.04,43.43 188.04,46.46 186.66,47.85 186.66,56.55 187.54,57.43 187.54,63.82 186.12,65.24 186.12,67.68 186.77,68.33 186.77,76.06 184.37,78.46 184.37,79.55 182.78,81.14 182.52,81.14 160.7,102.96 158.13,102.96 153.16,107.92 153.16,110.27 152.12,111.31 152.12,113.02 151.32,113.82 151.32,116.81 148.64,119.5 144.58,119.5 143.77,120.3 143.77,123.62 137.13,130.27 137.13,140.37 127.07,150.42 116.23,150.42 114.7,151.95 JMINI.49
ECAGND: length 175.5
  TOP w0.203: LE2.2 194.15,55.94 194.15,54.35 193.99,54.19 UE1.69
  TOP w0.254: v2(172.23,60.84) 172.05,61.01 172.05,64.15 171.21,64.99 171.21,80.04 160.84,90.41 120.87,90.41 116.95,94.33 116.95,97.7 116.55,98.1 116.55,103.32 116.36,103.51 116.36,105.75 115.87,106.23 115.87,112.18 v1(115.88,112.18) 115.88,112.48 113.47,114.89 107.22,114.89 106.86,115.24 106.86,115.51 PH1.2 ; CE7.2 203.37,36.5 204.89,38.02 204.89,46.89 v2(201.96,49.82) 201.96,49.85 CE9.1 ; v2(194.99,55.22) 194.86,55.35 194.78,55.35 194.21,55.92 LE2.2
  IN2 w0.254: v2(201.96,49.82) 201.53,49.82 197.15,54.2 196,54.2 v2(194.99,55.22)
  BOTTOM w0.254: v2(194.99,55.22) 194.98,55.22 194.03,56.17 190.72,56.17 190.31,55.76 190.31,53.63 189.27,52.6 183.96,52.6 183.32,51.96 182.35,51.96 181.7,51.31 178.81,51.31 178.62,51.5 175.74,51.5 171.86,55.38 171.86,60.47 v2(172.23,60.84)
EDCA0_0: length 13.7
  TOP w0.102: 167.27,137.4 167.48,137.18 167.48,135.37 v2(168.18,134.67)
  TOP w0.127: 167.27,137.4 163.48,141.18 v1(163.48,141.37) 163.48,142.01 163.6,142.13 163.73,142.13 163.86,142.26 163.86,142.51 163.73,142.64 163.6,142.64 163.48,142.77 163.48,144.85 UV5.R13
  BOTTOM w0.102: UV1.C34 167.86,134.36 v2(168.18,134.67)
EDCA0_1: length 35.6
  BOTTOM w0.102: UV1.D29 171.86,134.27 172.17,134.57 172.17,134.83 171.98,135.02 171.98,135.78 171.64,136.12
  BOTTOM w0.127: 171.64,136.12 170.35,137.41 167.66,137.41 167,138.07 166.88,138.07 166.58,137.78 166.4,137.78 166.21,137.97 166.21,138.15 166.48,138.41 166.48,138.59 166.3,138.77 166.12,138.77 165.83,138.49 165.65,138.49 165.47,138.67 165.47,138.85 165.76,139.13 165.76,139.31 165.58,139.49 165.4,139.49 165.11,139.2 164.94,139.2 164.76,139.38 164.76,139.56 165.04,139.85 165.04,140.03 164.86,140.21 164.68,140.21 164.4,139.92 v1(164.22,139.92) 164.04,140.1 164.04,140.28 164.25,140.49 164.25,140.67 164.07,140.85 163.89,140.85 163.68,140.64 163.5,140.64 163.29,140.85 161.49,140.85 160.58,141.77 160.58,153.42 161.57,154.42 163.24,154.42 163.6,154.06 UV4.C2
EDCA0_2: length 30.2
  TOP w0.127: v2(174.84,138.36) 178.03,141.55 v1(178.03,150.97) 178.03,151.23 177.91,151.36 177.32,151.36 177.19,151.48 177.19,151.82 177.32,151.94 177.91,151.94 178.03,152.07 178.03,152.39 177.91,152.52 177.32,152.52 177.19,152.64 177.19,152.99 177.32,153.12 177.91,153.12 178.03,153.24 178.03,153.58 177.91,153.7 177.07,153.7 176.52,154.25 175.53,154.25 175.33,154.45 174.2,154.45 173.81,154.06 UV5.C2
  BOTTOM w0.102: UV1.D25 175.06,133.74 174.97,133.65 174.72,133.65 174.59,133.77 174.59,133.91 174.77,134.09 174.77,134.54 174.76,134.55 174.76,134.91 174.78,134.93 174.78,135.3 174.66,135.42 174.66,135.64 174.68,135.66 174.68,135.75
  BOTTOM w0.127: v2(174.84,138.36) 175.16,138.04 175.16,137.59 174.68,137.11 174.68,135.75
