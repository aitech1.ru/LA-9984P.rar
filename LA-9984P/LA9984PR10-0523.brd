# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CASB0#: length 37.9
  TOP w0.102: v2(213.14,133.94) 213.14,133.94 UV7.G3
  IN3 w0.102: 194.39,123.8 194.25,123.66 193.17,123.66 192.76,123.25 191.45,123.25 191.17,122.97 190.54,122.97 190.31,123.2 190.31,123.38 190.09,123.6 188.78,123.6 v2(188.31,123.13) ; 214.09,127.96 214.09,128.77 214.66,129.34 214.66,132.66 213.38,133.94 v2(213.14,133.94)
  IN3 w0.157: 194.39,123.8 194.49,123.9 200.97,123.9 202.11,125.05 211.17,125.05 214.09,127.96
  BOTTOM w0.102: v2(213.14,133.94) 213.14,133.94 UV7.G3 ; UV1.W10 187.49,122.5 188.12,123.13 v2(188.31,123.13)
CASB1#: length 35
  TOP w0.102: v2(212.95,113.54) 213.37,113.12 UV9.G3
  IN3 w0.102: v2(212.95,113.54) 212.58,113.91 211.97,113.91 211.8,114.07 211.8,114.91 210,116.71 210,118.99 209.22,119.77 209.22,120.38 208.09,121.5 203.47,121.5 ; v2(187.7,119.48) 187.7,120.35 188.5,121.15 190.24,121.15 190.45,120.94 191.05,120.94 191.93,120.06 193.13,120.06 193.33,120.26 194.39,120.26
  IN3 w0.157: 194.39,120.26 202.23,120.26 203.47,121.5
  BOTTOM w0.102: v2(212.95,113.54) 213.37,113.12 UV9.G3 ; UV1.AA10 187.66,119.71 187.66,119.53 v2(187.7,119.48)
CE_EN: length 170.1
  TOP w0.102: UE1.17 189.59,38.86 v2(189.47,38.98) ; v2(219.73,177.47) 219.73,177.88 RX18.1
  IN2 w0.127: v2(219.73,177.47) 220.12,177.87 220.82,177.87 220.97,177.71 220.97,176.51 221.07,176.41 221.07,151.95 225.08,147.94 225.08,123.92 223.93,122.77 223.93,92.85 220.58,89.5 220.58,81.29 222.15,79.72 222.15,79.44 222.15,79.44 222.15,61.78 216.77,56.4 216.77,54.21 v2(216.31,53.75)
  BOTTOM w0.102: v2(189.47,38.98) 189.84,38.61 190.54,38.61 190.88,38.94 190.88,40.73 195.57,45.42 209.12,45.42 210.87,47.17 v1(211.61,47.17) 212.09,47.17 216.63,51.71 216.63,53.43 v2(216.31,53.75)
CE_EN_R: length 7.3
  TOP w0.102: RX53.2 218.11,179.01 v1(218.29,179.19) 218.55,179.45 219.94,179.45 RX20.1 RX18.2 220.41,177.51 v2(220.5,177.42)
  BOTTOM w0.102: v2(220.5,177.42) 220.6,177.32 220.73,177.32 221.01,177.04 221.01,176.57 JLVDS.18
CFD_PWRBTN#_XDP: length 5.1
  BOTTOM w0.102: JXDP1.41 63.2,93.51 RC49.2 64.57,92.14 64.57,91.84 v1(65.26,91.15)
CFG0: length 37.9
  IN3 w0.127: v2(76.55,110.24) 77.37,110.24 78.52,111.39 81.15,111.39 82.49,112.74 89.35,112.74 90.48,113.87 v2(90.48,114.53)
  BOTTOM w0.076: UC1.AC60 93.31,114.82 92.83,114.82 92.79,114.85 92,114.85 91.84,114.69 91.46,114.69 91.22,114.92 90.87,114.92 v2(90.48,114.53)
  BOTTOM w0.102: v2(76.55,110.24) v1(76.12,109.81) 75.97,109.67 75.97,107.68 75.72,107.43 75.72,106.18 75.26,105.72 74.7,105.72 74.03,105.05 74.03,98.58 73.36,97.91 71.85,97.91 71.2,97.26 JXDP1.9
CFG1: length 47.8
  IN3 w0.127: v2(85.95,116.43) 85.48,115.95 84.05,115.95 82.67,114.57 79.12,114.57 77.78,113.23 76.58,113.23 71.86,108.51 71.86,104.91 71.13,104.18 71.13,101.82 68.17,98.86 68.17,93.01 v2(68.1,92.94)
  BOTTOM w0.076: UC1.AC62 92.06,115.15 91.77,114.85 91.53,114.85 91.29,115.09 89.63,115.09 89.57,115.03 88.91,115.03
  BOTTOM w0.102: JXDP1.11 70.7,92.54 70.54,92.38 v1(70.31,92.38) 70.18,92.38 69.23,93.33 68.5,93.33 v2(68.1,92.94) ; 88.91,115.03 88.91,115.04 87.29,115.04 85.95,116.37 v2(85.95,116.43)
CFG2: length 37.3
  IN3 w0.127: v2(86.57,116.38) 85.87,115.69 84.16,115.69 82.78,114.31 79.23,114.31 77.88,112.96 76.69,112.96 72.13,108.4 72.13,104.8 71.97,104.64 71.97,102.29 70.05,100.36 v2(70.05,97.35)
  BOTTOM w0.076: UC1.AC63 91.54,115.26 88.93,115.26 88.91,115.27
  BOTTOM w0.102: v2(70.05,97.35) 69.7,97.01 JXDP1.15 ; v2(86.57,116.38) v1(87.25,115.71) 87.68,115.27 88.91,115.27
CFG3: length 59.7
  IN1 w0.127: v2(56.16,102.67) 56.35,102.86 59.85,102.86 60.78,103.79 63.43,103.79 63.9,104.26 65.37,104.26 66.83,105.72 71.32,105.72 72.21,104.83 72.94,104.83 v2(73.32,104.45)
  IN3 w0.127: v2(88.32,116.38) 88.32,116.28 86.94,114.9 84.48,114.9 83.11,113.53 79.56,113.53 78.21,112.18 77.01,112.18 74.11,109.28 74.11,105.89 73.49,105.27 73.49,104.63 v2(73.32,104.45)
  BOTTOM w0.076: UC1.AA63 91.52,115.77 91.39,115.77 91.37,115.75 89.87,115.75 89.64,115.98 89.03,115.98
  BOTTOM w0.102: v2(73.32,104.45) 73.32,104.4 v1(73.67,104.05) 73.75,103.97 73.75,99.55 73.74,99.54 73.74,98.93 73.03,98.22 69.88,98.22 69.2,97.55 JXDP1.17 ; RC56.2 56.16,103.33 v2(56.16,102.67) ; 89.03,115.98 89.01,115.97 88.93,115.97 88.91,115.98 88.72,115.98 v2(88.32,116.38)
CFG3_R: length 3.2
  BOTTOM w0.102: JXDP1.60 58.7,102.16 v1(58.04,102.82) 57.62,103.24 RC56.1
CFG4: length 43.3
  TOP w0.089: 88.91,115.34 89.19,115.07 92.85,115.07 v2(93.3,115.52)
  TOP w0.102: v2(83.85,116.32) v1(84.86,116.32) 84.97,116.32 85.55,115.74 88.51,115.74 88.91,115.34
  IN3 w0.127: v2(83.85,116.32) 82.36,114.84 77.45,114.84 71.34,108.73 71.34,105.12 70.63,104.41 70.63,102.05 66.57,98 v2(66.57,97.35)
  BOTTOM w0.089: v2(93.3,115.52) 93.6,115.82 UC1.AA60
  BOTTOM w0.102: v2(66.57,97.35) 66.7,97.23 JXDP1.27 ; RC138.1 83.1,115.51 83.85,116.26 v2(83.85,116.32)
CFG5: length 44.9
  IN3 w0.127: v2(69.12,92.85) 69.76,93.49 69.76,95.22 70.96,96.42 70.96,100.54 74.01,103.59 74.01,105.05 74.64,105.68 74.64,108.93 76.38,110.67 77.43,110.67 78.41,111.66 81.04,111.66 82.39,113 86.77,113 v2(90.21,116.44)
  BOTTOM w0.076: v2(90.21,116.44) 90.21,116.38 90.5,116.08 91.19,116.08 91.46,116.35 91.77,116.35 92.06,116.64 UC1.Y62
  BOTTOM w0.102: JXDP1.29 66.2,94.28 66.51,93.97 67.21,93.97 67.66,93.52 67.66,92.81 67.95,92.51 v1(68.49,92.51) 68.78,92.51 v2(69.12,92.85)
CFG6: length 52.6
  TOP w0.089: 88.91,117.02 v2(92.65,117.02)
  TOP w0.102: 88.91,117.02 81.5,117.02 v1(79.7,115.22) 75.73,111.25 75.73,103.16 v2(76.29,102.6)
  BOTTOM w0.076: UC1.Y61 92.95,116.72 v2(92.65,117.02)
  BOTTOM w0.102: v2(76.29,102.6) 75.47,102.6 74.72,101.86 74.72,92.14 74.58,92 68.14,92 67.43,92.71 67.43,93.43 67.12,93.74 66.42,93.74 66.32,93.84 65.38,93.84 65.2,94.02 JXDP1.33
CFG7: length 48.6
  TOP w0.102: v2(66.96,92.89) v1(66.96,93.74)
  IN3 w0.127: v2(66.96,92.89) 66.96,92.7 67.21,92.44 68.23,92.44 68.55,92.76 68.55,94.37 70.64,96.47 70.64,100.59 73.75,103.7 73.75,105.16 74.37,105.78 74.37,109.17 77.12,111.92 78.32,111.92 79.67,113.27 86.45,113.27 89.56,116.38 v2(89.56,116.44)
  BOTTOM w0.076: v2(89.56,116.44) 89.56,116.38 90.02,115.92 91.26,115.92 91.53,116.19 91.84,116.19 92,116.35 92.79,116.35 92.83,116.31 93.31,116.31 UC1.Y60
  BOTTOM w0.102: v2(66.96,92.89) 66.95,92.89 66.25,93.59 65.31,93.59 64.7,94.19 JXDP1.35
CFG8: length 40.9
  IN3 w0.127: v2(67.03,105.3) 66.86,105.47 66.86,106.29 66.39,106.77 66.39,109.03 73.04,115.69 v2(73.24,115.69)
  BOTTOM w0.076: 89.12,116.87 91.46,116.87 91.53,116.94 91.84,116.94 UC1.V62
  BOTTOM w0.102: 89.12,116.87 89.1,116.89 v1(80.9,116.89) 80.42,116.89 79.94,116.41 73.97,116.41 v2(73.24,115.69) ; v2(67.03,105.3) 67.2,105.47 68.81,105.47 69.65,104.62 70.27,104.62 70.93,103.97 70.93,103.49 71.2,103.22 JXDP1.10
CFG9: length 44.3
  IN3 w0.127: v2(75.75,117.81) 75.75,117.81 75.34,117.4 74.29,117.4 66.13,109.24 66.13,106.66 66.6,106.19 66.6,104.9 v2(66.37,104.66)
  BOTTOM w0.076: 89.3,117.12 89.38,117.03 91.21,117.03 91.28,117.1 91.77,117.1 91.94,117.27 91.94,117.45 92.18,117.69 92.7,117.69 UC1.V61
  BOTTOM w0.102: JXDP1.12 70.7,103.87 70.18,104.4 69.56,104.4 68.71,105.24 68.38,105.24 68.03,104.89 66.59,104.89 v2(66.37,104.66) ; 89.3,117.12 84.84,117.12 83.61,118.35 v1(78.5,118.35) 76.29,118.35 v2(75.75,117.81)
CFG10: length 36.8
  TOP w0.089: v2(93.3,117.02) 91.58,115.29 89.83,115.29 v1(89.57,115.55) 89.15,115.97 88.91,115.97
  TOP w0.102: v2(83.21,116.32) 83.62,116.73 85.01,116.73 85.76,115.97 88.91,115.97
  IN3 w0.127: v2(69.82,103.91) 69.82,104.75 70.16,105.09 70.16,105.74 69.92,105.98 69.92,108.96 72.25,111.29 72.58,111.29 75.01,113.72 75.97,113.72 77.34,115.1 81.99,115.1 v2(83.21,116.32)
  BOTTOM w0.076: UC1.V60 93.6,117.32 v2(93.3,117.02)
  BOTTOM w0.102: JXDP1.16 69.7,102.85 69.42,103.14 69.42,103.51 v2(69.82,103.91)
CFG11: length 38.3
  IN3 w0.127: v2(68.55,104.83) 68.55,105.04 69.09,105.58 69.09,109.6 70.18,110.69 70.18,111.71 72.18,113.72 73.43,113.72 76.28,116.56 81.19,116.56 81.92,117.3 85.52,117.3 85.6,117.37 87.82,117.37 88.14,117.69 v2(88.14,117.8)
  BOTTOM w0.076: UC1.U60 93.31,117.81 92.83,117.81 92.79,117.85 92,117.85 91.84,117.69 91.46,117.69 91.25,117.9 90.93,117.9 90.24,117.21 89.45,117.21 89.3,117.37
  BOTTOM w0.102: v2(88.14,117.8) 88.56,117.37 89.3,117.37 ; JXDP1.18 69.2,103.03 69.1,103.13 v1(69.1,103.88) 69.1,104.27 68.55,104.83 v2(68.55,104.83)
CFG12: length 38.6
  IN3 w0.127: v2(66.64,103.62) 66.64,103.79 65.94,104.49 65.94,105.02 66.34,105.41 66.34,106.1 65.88,106.56 65.88,109.35 74.35,117.82 v2(75.17,117.82)
  BOTTOM w0.076: 88.91,118.71 90.56,118.71 90.75,118.89 UC1.T63
  BOTTOM w0.102: 88.91,118.71 v1(76.06,118.71) v2(75.17,117.82) ; JXDP1.28 66.7,103.56 v2(66.64,103.62)
CFG13: length 38.4
  IN3 w0.127: v2(67.65,104.48) 67.65,104.54 68.84,105.72 68.84,109.72 69.75,110.63 69.75,111.66 72.99,114.89 74.01,114.89 75.94,116.82 81.08,116.82 81.81,117.56 85.43,117.56 85.5,117.63 86.78,117.63 v2(87.21,118.06)
  BOTTOM w0.076: 88.91,118.23 90.56,118.23 90.76,118.43 91.84,118.43 91.85,118.45 91.85,118.45 UC1.T62
  BOTTOM w0.102: v2(87.21,118.06) 87.38,118.23 88.91,118.23 ; v2(67.65,104.48) 67.65,104.26 67.42,104.03 66.21,104.03 v1(65.98,103.8) 65.98,102.76 66.2,102.54 JXDP1.30
CFG14: length 41.7
  TOP w0.102: v2(67.03,104.48) 67.03,104.48 67.69,103.81 v1(67.69,102.82)
  IN3 w0.127: v2(86.58,118.06) 85.57,118.06 85.33,117.82 81.71,117.82 80.97,117.08 75.83,117.08 73.9,115.15 72.88,115.15 69.49,111.77 69.49,110.74 67.42,108.67 67.42,105.72 67.45,105.68 67.45,104.89 v2(67.03,104.48)
  BOTTOM w0.076: UC1.T61 92.7,119.18 92.18,119.18 91.94,118.95 91.94,118.77 91.77,118.6 90.69,118.6 90.56,118.47 88.91,118.47
  BOTTOM w0.102: 88.91,118.47 86.99,118.47 v2(86.58,118.06) ; v2(67.03,104.48) 66.81,104.26 65.83,104.26 65.2,103.63 JXDP1.34
CFG15: length 46.5
  TOP w0.089: v2(93.3,118.52) 92.83,118.99 91.31,118.99 91.24,118.91 88.91,118.91
  TOP w0.102: v2(80.83,117.79) v1(81.31,118.27) 81.51,118.47 83.31,118.47 84.19,119.36 85.03,119.36 85.5,119.83 85.94,119.83 86.86,118.91 88.91,118.91
  BOTTOM w0.076: v2(93.3,118.52) 93.6,118.82 UC1.T60
  BOTTOM w0.102: JXDP1.36 64.7,106.38 63.72,107.36 63.72,114.16 66.2,116.64 79.68,116.64 v2(80.83,117.79)
CFG16: length 31.6
  IN3 w0.127: v2(87.15,116.38) 87.15,116.32 86.25,115.42 84.26,115.42 82.89,114.05 79.34,114.05 77.99,112.7 76.8,112.7 72.39,108.3 72.39,104.54 72.4,104.53 v2(72.4,104.23)
  BOTTOM w0.076: UC1.AA62 92.24,115.84 92.24,115.84 91.84,115.44 91.53,115.44 91.51,115.42 89.61,115.42 89.53,115.51 88.91,115.51
  BOTTOM w0.102: JXDP1.6 72.2,103.18 71.99,103.39 71.99,103.82 71.9,103.91 v1(71.9,104.07) 71.9,104.12 72,104.23 v2(72.4,104.23) ; v2(87.15,116.38) 87.15,116.32 87.96,115.51 88.02,115.51 88.03,115.51 88.91,115.51
CFG17: length 32.4
  TOP w0.102: v2(72.4,103.61) v1(72.4,102.97)
  IN3 w0.127: v2(72.4,103.61) 72.82,104.03 72.82,104.67 73.23,105.08 73.23,105.38 73.84,105.99 73.84,109.38 76.9,112.44 78.1,112.44 79.45,113.79 83,113.79 84.37,115.16 86.56,115.16 87.74,116.33 v2(87.74,116.38)
  BOTTOM w0.076: 88.91,115.74 89.58,115.74 89.74,115.59 91.44,115.59 91.46,115.6 91.77,115.6 92.01,115.84 92.01,116.02 92.18,116.19 92.7,116.19 UC1.AA61
  BOTTOM w0.102: v2(72.4,103.61) 72.7,103.3 JXDP1.4 ; v2(87.74,116.38) 87.74,116.38 87.74,116.37 88.36,115.74 88.91,115.74
CFG18: length 46.6
  TOP w0.102: v2(69.66,105.19) v1(70.44,105.19)
  IN3 w0.127: v2(69.66,105.19) 69.66,109.07 72.33,111.74 72.65,111.74 74.9,113.99 75.86,113.99 77.23,115.36 81.62,115.36 83.03,116.77 85.72,116.77 85.8,116.85 89.06,116.85 v2(90.01,117.79)
  BOTTOM w0.076: v2(90.01,117.79) 90.36,117.79 90.79,118.23 91.56,118.23 UC1.U63
  BOTTOM w0.102: JXDP1.24 67.7,99.7 68.16,99.24 73.12,99.24 73.52,99.64 73.52,103.68 72.34,104.85 70,104.85 v2(69.66,105.19)
CFG19: length 37.1
  TOP w0.102: v1(69.16,103.85) 68.82,104.19 v2(68.61,104.19)
  IN3 w0.127: v2(89.43,117.79) 88.75,117.11 85.7,117.11 85.62,117.03 82.03,117.03 81.3,116.3 76.4,116.3 73.55,113.46 72.29,113.46 70.44,111.61 70.44,110.58 69.35,109.49 69.35,105.47 68.97,105.09 68.97,104.55 68.61,104.19 v2(68.61,104.19)
  BOTTOM w0.076: UC1.U62 92.06,118.14 91.77,117.85 91.53,117.85 91.32,118.06 90.86,118.06 90.18,117.38 89.85,117.38 v2(89.43,117.79)
  BOTTOM w0.102: JXDP1.22 68.2,103.78 v2(68.61,104.19)
CFG_RCOMP: length 1.9
  TOP w0.089: RC132.1 91.27,117.67 v2(91.07,117.48) v1(90.54,117.48)
  BOTTOM w0.089: v2(91.07,117.48) 91.16,117.39 UC1.V63
CHG_B+:
  vias: v3(149.38,164.64) v3(149.38,164.01) v3(152.62,164.71) v3(152.62,164.07) v3(153.57,164.71) v3(153.57,164.07) v3(154.46,164.71) v3(154.46,164.07) v3(155.41,164.71) v3(155.41,164.07) v4(151.69,163.67)
CKEA0: length 35.6
  TOP w0.102: UV5.J3 v2(168.28,152.86)
  IN3 w0.102: 178.06,137.4 178.06,137.19 177.73,136.86 177.73,133.93 177.52,133.73 177.52,132.76 177.8,132.48 177.8,130.14 v2(177.26,129.59) ; 172.73,154.07 171.89,153.23 170.91,153.23 170.13,152.46 169.7,152.46 169.68,152.48 168.67,152.48 v2(168.28,152.86)
  IN3 w0.157: 178.06,137.4 178.06,150.87 175.46,153.47 174.66,153.47 174.06,154.07 172.73,154.07
  BOTTOM w0.102: UV5.J3 v2(168.28,152.86) ; UV1.K21 177.35,129.5 v2(177.26,129.59)
CKEA1: length 32.3
  TOP w0.102: v2(188.79,152.8) 189.19,153.2 UV3.J3
  IN3 w0.102: v2(178.59,130.75) 178.21,131.14 178.21,131.66 178.51,131.96 178.72,131.96 178.84,132.08 178.84,135.46 178.98,135.6 178.98,136.49 179.39,136.91 179.45,136.91 179.74,137.19 179.74,137.25 179.75,137.26 179.75,137.4 ; v2(188.79,152.8) 188.38,153.21 183.29,153.21 182.13,152.05
  IN3 w0.157: 182.13,152.05 179.75,149.67 179.75,137.4
  BOTTOM w0.102: UV3.J3 189.19,153.2 v2(188.79,152.8) ; UV1.J20 179.05,130.3 v2(178.59,130.75)
CKEB0: length 37.9
  TOP w0.102: UV7.J3 v2(213.16,135.52)
  IN3 w0.102: v2(187.48,123.12) 188.17,123.81 190.74,123.81 190.75,123.81 191.23,123.81 ; 213.58,128.15 213.58,129.76 213.58,129.76 213.58,130.08 213.58,130.08 213.58,130.56 213.58,130.56 213.58,132.91 212.69,133.8 212.69,134.18 212.78,134.27 212.78,135.14 v2(213.16,135.52)
  IN3 w0.157: 191.23,123.81 191.95,124.53 200.9,124.53 202.11,125.74 211.17,125.74 213.58,128.15
  BOTTOM w0.102: v2(187.48,123.12) 187.26,123.33 UV1.U10 ; UV7.J3 v2(213.16,135.52)
CKEB1: length 35.2
  TOP w0.102: v2(212.97,115.12) 213.37,114.72 UV9.J3
  IN3 w0.102: 210.45,121.79 210.66,121.58 210.66,116.91 212.45,115.12 v2(212.97,115.12) ; v2(187.08,120.7) 187.73,120.7 188.75,121.72 188.75,121.94 188.97,122.16 190.48,122.16 190.48,122.16 191.5,122.16 191.72,122.37 192.89,122.37 193.06,122.2 193.06,122.2 193.08,122.18 193.61,122.18 194.06,121.73 194.39,121.73
  IN3 w0.157: 194.39,121.73 201.59,121.73 202.86,122.99 209.25,122.99 210.45,121.79
  BOTTOM w0.102: UV1.AA11 v2(187.08,120.7) ; v2(212.97,115.12) 213.37,114.72 UV9.J3
CLK_BIASREF: length 5.7
  BOTTOM w0.089: 115.18,127.91 115.16,127.9 115.16,127.25 115.27,127.14 115.27,126.75 115.33,126.69 115.33,126.52 115.3,126.48 115.3,126.47 115.12,126.3 115.11,126.3 115,126.19 UC1.C26
  BOTTOM w0.305: RC13.1 115.62,131.14 v1(115.62,130.25) 115.62,128.87 115.18,128.43 115.18,127.91
CLK_CPU_ITP: length 3.7
  BOTTOM w0.089: UC1.A35 109.47,127.62 109.47,128.49 108.74,129.21 v3(108.74,129.82) 108.74,130.4 RC139.2
CLK_CPU_ITP#: length 4.4
  BOTTOM w0.089: RC140.2 108.99,130.47 108.99,129.32 109.72,128.59 109.72,127.22 UC1.B35
CLK_PCI_LPC: length 119.9
  TOP w0.089: v2(127.53,98.41) 127.11,98 126.25,98 R2336.1
  TOP w0.102: UE1.12 187.59,36.75 187.42,36.58 R2354.2 187.42,35.55 185.81,33.94 181.41,33.94 178.71,36.64 178.71,37.99 176.55,40.15 173.37,40.15 v1(172.94,40.58) 169.68,43.84 169.68,52.24 v2(168.43,53.49)
  IN1 w0.084: v2(127.53,98.41) 127.36,98.41 125.12,100.65 125.12,100.97 125.44,101.29 125.44,101.29 125.46,101.3 126.18,101.3 126.77,100.72 126.83,100.72 126.84,100.71 127.86,100.71 129.06,99.51 130.17,99.51 130.89,98.79 131.57,98.79
  IN1 w0.127: v2(168.43,53.49) 169.95,55.01 169.95,62.85 170.18,63.07 170.18,64.55 171.29,65.67 171.29,72.13 169.33,74.09 160.43,74.09 156.4,78.12 152.12,78.12 133.63,96.61 133.63,97.2 133.25,97.59 133.01,97.59 131.81,98.79 131.57,98.79
CLK_PCIE_LAN: length 111.4
  IN1 w0.127: v2(42.07,119.39) 42.26,119.58 43.73,119.58 44.83,120.69 59.87,120.69 60.32,121.15 66.64,121.15 79.76,134.27 91.23,134.27 91.71,134.75 95.6,134.75 97.5,132.85 97.5,130.48 99.32,128.66 103.46,128.66 104.27,129.47 104.51,129.47 104.64,129.34 104.64,129.13 v2(104.47,128.96)
  BOTTOM w0.089: v2(104.47,128.96) 104.8,128.62 104.8,128.2 104.98,128.03 104.98,127.04 104.58,126.63 104.58,126.52 104.86,126.24 104.93,126.24 104.99,126.31 104.99,126.57 UC1.B42
  BOTTOM w0.102: v2(42.07,119.39) 42.25,119.57 43.91,119.57 44.48,119 44.48,114.18 41.18,110.87 41.18,99.38 38.81,97.01 38.81,90.54 38.75,90.48 UL1.15
CLK_PCIE_LAN#: length 111.5
  IN1 w0.127: v2(42.07,119.97) 42.12,119.91 43.59,119.91 44.7,121.02 59.73,121.02 60.19,121.48 66.5,121.48 79.62,134.6 91.09,134.6 91.57,135.08 95.74,135.08 97.83,132.98 97.83,130.62 99.45,129 103.33,129 104.14,129.8 104.65,129.8 104.99,129.46 104.99,129.01 v2(105.05,128.96)
  BOTTOM w0.089: v2(105.05,128.96) 105.06,128.95 105.06,128.31 105.24,128.13 105.24,126.75 105.27,126.72 105.27,126.54 UC1.C41
  BOTTOM w0.102: v2(42.07,119.97) 42.2,119.84 44.02,119.84 44.75,119.11 44.75,114.07 41.44,110.76 41.44,99.27 39.08,96.9 39.08,90.54 39.15,90.48 UL1.16
CLK_PCIE_WLAN: length 55.7
  IN3 w0.114: JMINI.13 97.1,151.78 96.83,151.51 96.83,151.17 97.91,150.09 112.95,150.09 113.83,149.2 113.83,148.77 115.77,146.83 119.13,146.83 119.88,146.08 119.88,141.16 113.98,135.25 113.98,133.74 111.46,131.22 106.79,131.22 106.58,131.01 106.58,130.78 106.74,130.62 v2(106.74,130.61)
  BOTTOM w0.102: UC1.C37 107.85,126.46 107.85,126.67 107.6,126.93 107.6,129.42 106.74,130.27 v2(106.74,130.61)
CLK_PCIE_WLAN#: length 55.4
  IN3 w0.114: v2(106.16,130.61) 106.33,130.78 106.33,131.12 106.68,131.47 111.35,131.47 113.73,133.85 113.73,135.36 119.63,141.26 119.63,145.98 119.03,146.58 115.67,146.58 113.58,148.66 113.58,149.1 112.84,149.83 97.8,149.83 96.57,151.07 96.57,151.51 96.3,151.78 JMINI.11
  BOTTOM w0.102: v2(106.16,130.61) 106.2,130.61 106.47,130.34 106.47,130.16 107.33,129.31 107.33,126.74 UC1.B38
CLK_PEG_VGA: length 77.6
  IN1 w0.127: v2(105.94,129.13) 105.99,129.17 106.5,129.17 108.18,130.85 109.34,130.85 110.64,132.16 114.28,132.16 115.74,133.62 118.1,133.62 118.54,134.06 127.93,134.06 129.17,132.83 137.53,132.83 139.46,134.76 144.39,134.76 145.58,133.57 151.82,133.57 152.61,132.78 152.61,126.54 153.97,125.18 156.46,125.18 161.49,120.15 166.99,120.15 v2(167.03,120.19)
  BOTTOM w0.089: v2(105.94,129.13) 106.02,129.21 106.29,129.21 106.39,129.11 106.39,127.52 106.91,126.99 UC1.B39
  BOTTOM w0.102: UV1.AB35 166.86,120.02 v2(167.03,120.19)
CLK_PEG_VGA#: length 77.5
  IN1 w0.127: v2(166.9,120.76) 166.63,120.48 161.63,120.48 156.6,125.51 154.11,125.51 152.94,126.68 152.94,132.92 151.96,133.9 145.72,133.9 144.53,135.09 139.32,135.09 137.4,133.16 129.3,133.16 128.07,134.39 118.41,134.39 117.96,133.95 115.6,133.95 114.14,132.49 110.51,132.49 109.2,131.18 108.04,131.18 106.37,129.5 106.15,129.5 v2(105.94,129.71)
  BOTTOM w0.089: v2(105.94,129.71) 106.19,129.47 106.39,129.47 106.65,129.21 106.65,127.62 106.7,127.57 UC1.A39
  BOTTOM w0.102: v2(166.9,120.76) 166.65,120.5 UV1.AA36
CLK_SMB: length 37.2
  TOP w0.254: PR18.1 141.88,184.73 v2(141.7,184.55)
  IN1 w0.254: PBATT.7 169.07,187.52 165.38,183.84 155.92,183.84 151.73,188.03 147.35,188.03 v2(146.78,187.45)
  BOTTOM w0.254: v2(141.7,184.55) 141.7,184.9 141.95,185.16 PD1.3 143.59,185.16 144.05,185.61 144.05,186.38 144.55,186.88 145.69,186.88 145.76,186.95 PD3.3 146.47,186.95 146.78,187.26 v2(146.78,187.45)
CLK_X1: length 4.7
  TOP w0.102: UG1.1 62.32,44.05 61.99,43.73 61.99,43.47 61.92,43.4 v1(61.5,43.4) 61.22,43.4 CG8.1 60.29,41.63 YG1.1
CLK_X2: length 8
  TOP w0.102: UG1.16 61.52,45.46 61.27,45.2 61.27,44.31 CG9.1 60.05,43.5 v1(59.33,42.78) 59.33,42.37 59.55,42.14 59.55,40.61 YG1.3
CLK_XDP: length 78.3
  IN1 w0.127: v2(99.34,131.5) 99.13,131.71 98.68,131.71 98.38,132.02 98.38,133.16 95.85,135.69 91.47,135.69 90.89,135.12 79.02,135.12 66.58,122.67 63.82,122.67 63.59,122.45 63.59,122.19 v2(63.74,122.04)
  BOTTOM w0.102: v2(99.34,131.5) 99.52,131.69 99.89,131.69 100.19,131.99 100.19,132.65 100.7,133.15 102.26,133.15 103.09,132.32 108.55,132.32 108.71,132.17 108.71,132.05 RC139.1 ; v2(63.74,122.04) 63.59,121.88 63.59,120.11 61.5,118.01 61.5,112.52 62.02,112 62.02,108.38 63.58,106.81 63.58,102.56 63.7,102.44 JXDP1.40
CLK_XDP#: length 79.2
  IN1 w0.127: v2(99.34,132.15) 99.23,132.04 98.82,132.04 98.71,132.15 98.71,133.3 95.99,136.02 91.33,136.02 90.76,135.45 78.89,135.45 66.44,123 63.68,123 63.26,122.58 63.26,122.14 v2(63.16,122.04)
  BOTTOM w0.102: JXDP1.42 63.2,102.44 63.32,102.56 63.32,106.7 61.75,108.27 61.75,111.89 61.23,112.41 61.23,118.12 63.33,120.22 63.33,121.87 v2(63.16,122.04) ; RC140.1 109.25,131.7 108.98,131.97 108.98,132.28 108.66,132.59 103.2,132.59 102.53,133.26 102.37,133.41 100.59,133.41 99.93,132.76 99.93,132.1 99.78,131.95 99.53,131.95 v2(99.34,132.15)
CLKA0: length 33.8
  TOP w0.102: UV5.J12 v2(168.28,146.46) ; v2(172.54,130.95) 172.85,130.63 172.85,130.02 RV42.2
  IN3 w0.14: v2(172.54,130.95) 172.3,131.18 172.07,131.18 171.8,131.46 171.8,133.11 168.9,136.01 165.66,136.01 164.77,136.89 164.77,139.12 164.55,139.34 163.25,139.34 162.97,139.62 162.97,140.27 163.25,140.55 164.7,140.55 164.83,140.67 164.83,141.12 164.7,141.25 163.26,141.25 162.98,141.52 162.98,142.18 163.26,142.45 164.68,142.45 164.77,142.55 164.77,143.06 165.15,143.44 168.01,143.44 168.68,144.11 168.68,144.43 168.9,144.64 168.9,145.68 168.44,146.13 168.44,146.3 v2(168.28,146.46)
  BOTTOM w0.102: UV1.H27 172.91,130.95 172.55,130.95 172.55,130.95 v2(172.54,130.95) ; UV5.J12 v2(168.28,146.46)
CLKA0#: length 34.8
  TOP w0.102: RV43.2 173.05,130.25 173.05,131 v2(172.52,131.53) ; UV5.J11 169.08,146.46 v2(169.14,146.46)
  IN3 w0.14: v2(169.14,146.46) 169.08,146.46 168.95,146.59 168.83,146.59 168.7,146.45 168.7,146.24 169.15,145.79 169.15,144.53 168.94,144.32 168.94,144 168.12,143.18 165.25,143.18 165.02,142.95 165.02,142.44 164.78,142.2 163.36,142.2 163.24,142.07 163.24,141.63 163.36,141.5 164.81,141.5 165.08,141.22 165.08,140.57 164.81,140.29 163.35,140.29 163.22,140.17 163.22,139.72 163.35,139.6 164.65,139.6 165.02,139.22 165.02,137 165.76,136.26 169,136.26 172.05,133.21 172.05,131.56 172.18,131.43 172.42,131.43 v2(172.52,131.53)
  BOTTOM w0.102: UV1.G27 172.69,131.53 v2(172.52,131.53) ; v2(169.14,146.46) 169.08,146.46 UV5.J11
CLKA1: length 31.3
  TOP w0.102: v2(189.65,146.4) 189.6,146.4 UV3.J12 ; v2(184.5,129.91) 185.13,129.27 RV44.2
  IN3 w0.14: v2(189.65,146.4) 189.59,146.4 189.46,146.52 189.34,146.52 189.21,146.39 189.21,146.18 190.02,145.36 190.02,143.55 190.27,143.31 194.57,143.31 194.85,143.03 194.85,142 194.57,141.72 192.98,141.72 192.81,141.55 192.81,139.72 188.74,135.65 188.74,135.08 188.43,134.76 188.43,132.47 188.04,132.09 188.04,131.84 187.52,131.31 186.92,131.31 186.77,131.17 186.77,131.17 186.48,130.87 186.48,130.53 186.04,130.09 184.67,130.09 v2(184.5,129.91)
  BOTTOM w0.102: UV1.J14 184.11,130.3 v2(184.5,129.91) ; v2(189.65,146.4) 189.6,146.4 UV3.J12
CLKA1#: length 30.4
  TOP w0.102: v2(188.79,146.39) 188.8,146.39 UV3.J11 ; RV45.2 185.05,130.16 v2(184.48,130.73)
  IN3 w0.14: v2(184.48,130.73) 184.48,130.62 184.76,130.34 185.93,130.34 186.22,130.63 186.22,130.97 186.52,131.27 186.52,131.27 186.81,131.57 187.41,131.57 187.79,131.94 187.79,132.2 188.17,132.58 188.17,134.87 188.49,135.18 188.49,135.76 192.56,139.83 192.56,141.66 192.88,141.97 194.47,141.97 194.59,142.1 194.59,142.93 194.47,143.05 190.16,143.05 189.77,143.45 189.77,145.26 188.95,146.07 188.95,146.23 v2(188.79,146.39)
  BOTTOM w0.102: v2(184.48,130.73) 184.23,130.73 UV1.H14 ; v2(188.79,146.39) 189.19,146.79 UV3.J11
CLKB0: length 35.5
  TOP w0.102: v2(206.76,135.52) 206.36,135.12 UV7.J12 ; RV46.2 187.3,128.52 v2(187.7,128.92)
  IN3 w0.102: v2(187.7,128.92) 187.75,128.92 187.98,129.15 187.98,129.34 188.15,129.52 189,129.52 189.01,129.53 189.44,129.53 190.03,130.13 190.31,130.13 190.46,130.27 190.46,130.71 190.88,131.13 191.38,131.13 193.1,132.85 193.99,132.85
  IN3 w0.14: v2(206.76,135.52) 206.6,135.35 206.43,135.35 205.98,134.91 205.01,134.91 204.54,135.37 204.13,135.37 203.55,135.95 203.55,137 203.27,137.28 201.3,137.28 201.02,137 201.02,136.35 200.89,136.23 200.45,136.23 200.32,136.35 200.32,137.17 200.05,137.44 199.07,137.44 198.79,137.17 198.79,136.29 198.65,136.15 198.23,136.15 198.1,136.29 198.1,137.19 197.82,137.47 197.16,137.47 196.89,137.19 196.89,136.29 196.75,136.15 196.33,136.15 196.19,136.29 196.19,137.19 195.91,137.47 194.94,137.47 194.67,137.19 194.67,133.52 194,132.85 193.99,132.85
  BOTTOM w0.102: UV7.J12 206.36,135.12 v2(206.76,135.52) ; UV1.L9 188.06,128.56 v2(187.7,128.92)
CLKB0#: length 37.7
  TOP w0.102: UV7.J11 206.76,134.72 v2(206.76,134.66) ; RV47.2 190.37,127.93 190,128.3 189.04,128.3 v2(188.45,128.89)
  IN3 w0.102: 193.96,132.6 193.92,132.6 193.88,132.64 193.2,132.64 191.47,130.91 190.97,130.91 190.67,130.62 190.67,130.18 190.4,129.91 190.12,129.91 189.53,129.32 189.1,129.32 189.09,129.3 188.24,129.3 188.19,129.25 188.19,129.07 188.37,128.89 v2(188.45,128.89)
  IN3 w0.14: 193.96,132.6 194.11,132.6 194.92,133.41 194.92,137.09 195.05,137.21 195.81,137.21 195.94,137.09 195.94,136.19 196.22,135.9 196.85,135.9 197.14,136.19 197.14,137.09 197.27,137.21 197.71,137.21 197.84,137.09 197.84,136.19 198.13,135.9 198.76,135.9 199.05,136.19 199.05,137.06 199.17,137.19 199.94,137.19 200.07,137.06 200.07,136.25 200.34,135.97 201,135.97 201.27,136.25 201.27,136.89 201.4,137.02 203.17,137.02 203.29,136.89 203.29,135.85 204.02,135.12 204.44,135.12 204.9,134.65 206.09,134.65 206.54,135.1 206.71,135.1 206.84,134.98 206.84,134.8 206.76,134.72 v2(206.76,134.66)
  BOTTOM w0.102: UV7.J11 206.76,134.72 v2(206.76,134.66) ; v2(188.45,128.89) 188.84,128.5 UV1.L8
CLKB1: length 33.1
  TOP w0.102: v2(206.57,114.27) 206.57,114.32 UV9.J12 ; RV48.2 188.71,117.45 v2(188.71,117.11)
  IN3 w0.102: v2(188.71,117.11) 188.87,116.96 188.87,116.71 189.13,116.45 190.3,116.45 192.31,114.44 192.31,112.22 192.99,111.53 194.34,111.53 194.36,111.51 194.39,111.51
  IN3 w0.14: v2(206.57,114.27) 206.57,114.32 206.67,114.42 206.67,114.59 206.54,114.72 206.36,114.72 205.68,114.03 204.12,114.03 203.42,113.34 203.42,112.07 203.17,111.82 202.53,111.82 202.4,111.69 202.4,111.25 202.53,111.12 203.16,111.12 203.42,110.86 203.42,108.87 203.14,108.6 202.17,108.6 201.9,108.87 201.9,109.42 201.73,109.59 196.7,109.59 194.77,111.51 194.39,111.51
  BOTTOM w0.102: UV1.AD8 188.86,117.26 v2(188.71,117.11) ; UV9.J12 206.57,114.32 v2(206.57,114.27)
CLKB1#: length 32.2
  TOP w0.102: UV9.J11 206.57,115.12 v2(206.57,115.12) ; RV49.2 189.25,117.21 v2(189.33,117.13)
  IN3 w0.102: v2(189.33,117.13) 189.3,117.13 189.08,116.9 189.08,116.8 189.22,116.66 190.39,116.66 192.52,114.53 192.52,112.31 193.08,111.75 194.36,111.75 194.37,111.77 194.39,111.77
  IN3 w0.14: v2(206.57,115.12) 206.43,114.99 206.27,114.99 205.57,114.29 204.01,114.29 203.17,113.44 203.17,112.17 203.07,112.07 202.43,112.07 202.15,111.8 202.15,111.14 202.43,110.86 203.05,110.86 203.17,110.75 203.17,108.98 203.04,108.85 202.28,108.85 202.15,108.98 202.15,109.53 201.83,109.84 196.8,109.84 194.88,111.77 194.39,111.77
  BOTTOM w0.102: v2(189.33,117.13) 189.33,117.33 189.66,117.66 UV1.AD7 ; UV9.J11 v2(206.57,115.12)
CLKOUT_LPC0: length 12.9
  TOP w0.102: v2(121.76,108.84) 122.52,108.09 v1(122.52,107.2) 122.52,101.41 122.8,101.13 123.35,101.13 123.8,100.68 123.8,98.97 124.36,98.41 R2336.2
  BOTTOM w0.076: v2(121.76,108.84) 122.09,109.17 UC1.AN15
CLKRUN#: length 1.9
  TOP w0.089: RC36.2 128.86,116.76 v2(128.62,117)
  BOTTOM w0.089: UC1.V5 127.87,117.42 128.29,117 v2(128.62,117)
CMSRC: length 27.9
  TOP w0.102: v2(144.55,168.14) v1(143.98,168.14)
  TOP w0.254: PU701.3 167.99,168.9 v2(168.18,168.71)
  IN3 w0.254: v2(168.18,168.71) 168.18,168.49 166.3,166.61 146.27,166.61 144.75,168.14 v2(144.55,168.14)
  BOTTOM w0.254: v2(144.55,168.14) 144.19,168.14 143.81,167.76 PR721.1
CODEC_IRQ: length 5.8
  BOTTOM w0.076: UC1.L4 128.62,120.77 129.06,120.77 129.18,120.64 131.16,120.64 v1(131.7,121.18) 132.05,121.53 132.5,121.53 132.82,121.21 RC88.1
COMP_CPU: length 4.8
  BOTTOM w0.203: PU501.26 90.22,137.06 90.24,137.04 90.24,136.92 90.9,136.26 PR531.2
  BOTTOM w0.254: PR531.2 PC514.2 92.17,135.59 92.26,135.5 PR532.2 PC513.1
CPPE#: length 5.9
  BOTTOM w0.089: UC1.J1 131.26,122.6 131.92,123.26 132.81,123.26 132.83,123.23 133.64,123.23 133.85,123.43 v1(134.41,123.43) 135.42,123.43 RC108.2
CPU_DETECT#: length 237.5
  TOP w0.102: CE33.1 181.19,35.18 181.69,35.68 RE11.1 180.31,37.33 v2(180.31,39.61) 180.41,39.72 UE1.127
  IN1 w0.127: v2(180.31,39.61) 178.29,39.61 174.13,43.77 v2(174.13,49.84)
  IN3 w0.127: v2(80.78,124.77) 76.71,124.77 74.72,122.77 68.27,122.77 63.27,117.78 63.27,116.64 54.34,107.71 54.34,98.71 58.77,94.28 58.77,76.54 60.9,74.41 60.9,58.78 69.07,50.61 173.35,50.61 174.12,49.84 v2(174.13,49.84)
  BOTTOM w0.076: UC1.D61 92.73,125.99 92.73,126.23 92.44,126.52 91.85,126.52 91.79,126.59 91.49,126.59 90.86,127.21 89.15,127.21 88.99,127.37
  BOTTOM w0.102: v2(80.78,124.77) v1(82.63,124.77) 83.28,124.77 84.6,126.09 86.2,126.09 87.48,127.37 88.99,127.37
CPU_DPB_AUX: length 7.3
  IN3 w0.127: v2(129.95,131.37) 130.33,130.99 130.33,130.65 130.02,130.34 129.68,130.34 v2(129.53,130.49)
  BOTTOM w0.076: 127.87,128.51 127.86,128.51 127.84,128.5 127.79,128.5 127.23,127.94 127.23,127.02 UC1.B5
  BOTTOM w0.089: RP51.3 v2(129.95,131.37)
  BOTTOM w0.102: 127.87,128.51 127.91,128.51 128.87,129.47 128.87,130.09 129.1,130.32 129.36,130.32 v2(129.53,130.49)
CPU_DPB_AUX#: length 8
  IN3 w0.127: v2(129.53,129.9) 129.72,130.09 130.13,130.09 130.58,130.54 130.58,131 v2(130.95,131.37)
  BOTTOM w0.076: UC1.C5 127.43,126.45 127.43,127.05 127.39,127.09 127.39,127.83 127.86,128.29 127.87,128.29
  BOTTOM w0.102: v2(129.53,129.9) 129.34,130.1 129.19,130.1 129.09,130 129.09,129.38 128,128.29 127.87,128.29 ; RP51.1 v2(130.95,131.37)
CPU_DPB_CTRLCLK: length 141.5
  TOP w0.102: v2(19.46,110.02) 19.28,110.2 19.12,110.2 18.39,109.47 17.3,109.47 16.74,110.03 15.84,110.03 15.19,109.38 QX4.1
  IN1 w0.127: v2(19.46,110.02) 19.61,110.16 23.15,110.16 30.05,117.06 42.32,117.06 45.16,119.9 60.26,119.9 60.68,120.32 67.4,120.32 74.88,127.8 82.14,127.8 86.34,131.99 90.06,131.99 92.04,133.97 95.27,133.97 96.66,132.58 96.66,128.72 97.53,127.85 106.11,127.85 108.09,129.83 109.64,129.83 111.1,131.29 114.61,131.29 116.13,132.81 119.65,132.81 120.06,133.22 124.62,133.22 125.11,132.74 126.09,132.74 126.41,133.05 127.27,133.05 127.57,132.75 127.57,132.53 127.41,132.37 126.97,132.37 v2(126.77,132.56)
  BOTTOM w0.076: UC1.B9 124.68,126.93 125.12,127.36 125.12,128.04 125.48,128.4 125.49,128.4 125.66,128.57 126.35,129.27 126.35,131.47 126.2,131.62 126.2,132.2 126.39,132.39 126.6,132.39 v2(126.77,132.56)
  BOTTOM w0.102: RP52.1 20.02,111.29 19.9,111.18 19.9,111.1 20.12,110.89 20.12,110.52 19.87,110.26 19.71,110.26 v2(19.46,110.02)
CPU_DPB_CTRLCLK_R: length 10.8
  TOP w0.102: QX4.6 15.19,110.13 15.01,109.95 14.35,109.95 RX16.1 13.7,109.95 13.25,109.95 13.24,109.96 12.65,109.96 12.64,109.95 12.56,109.95 11.46,111.05 v3(10.65,111.05) 9.3,111.05 8.41,110.16 8.41,108.78 JHDMI.15
CPU_DPB_CTRLDAT: length 140.3
  TOP w0.102: v2(19.46,110.6) 19.28,110.42 19.03,110.42 18.3,109.69 17.39,109.69 16.83,110.25 16.59,110.25 16.49,110.35 QX4.4
  IN1 w0.127: v2(126.77,131.98) 126.9,132.1 127.52,132.1 127.84,132.42 127.84,132.87 127.38,133.33 126.29,133.33 125.98,133.01 125.22,133.01 124.74,133.5 119.94,133.5 119.53,133.08 116.02,133.08 114.5,131.56 110.99,131.56 109.53,130.1 107.98,130.1 106,128.12 97.64,128.12 96.93,128.83 96.93,132.69 95.38,134.24 91.92,134.24 89.95,132.26 86.23,132.26 82.03,128.07 74.76,128.07 67.29,120.59 60.56,120.59 60.14,120.17 45.04,120.17 42.21,117.34 29.94,117.34 23.03,110.43 19.63,110.43 v2(19.46,110.6)
  BOTTOM w0.076: UC1.C9 124.93,126.9 125.28,127.26 125.28,127.93 125.56,128.21 125.56,128.21 125.79,128.44 126.54,129.19 126.54,131.55 126.39,131.7 126.39,132.12 126.46,132.18 126.58,132.18 v2(126.77,131.98)
  BOTTOM w0.102: v2(19.46,110.6) 19.58,110.48 19.78,110.48 19.9,110.61 19.9,110.8 19.69,111.01 19.69,111.14 19.52,111.31 RP52.2
CPU_DPB_CTRLDAT_R: length 11.8
  TOP w0.102: QX4.3 16.49,108.38 16.36,108.26 15.02,108.26 14.71,108.57 14.71,108.76 14.67,108.76 RX17.1 13.7,109.74 v3(12.92,109.74) 12.47,109.74 11.37,110.83 10.98,110.83 10.95,110.81 10.37,110.81 10.34,110.83 9.39,110.83 8.63,110.07 8.63,108.89 8.87,108.65 JHDMI.16
CPU_DPC_AUX: length 7.5
  BOTTOM w0.076: UC1.A6 126.53,127.32 126.43,127.22 126.29,127.22 126.2,127.32 126.2,127.79 126.38,127.97 126.54,127.97 126.67,128.1 126.67,128.15
  BOTTOM w0.089: 126.67,128.15 127.79,129.27 127.79,130.72 v3(127.94,130.88) 128.15,131.08 129.31,131.08 129.45,131.22 RP51.4
CPU_DPC_AUX#: length 8.3
  BOTTOM w0.076: 126.86,128.07 126.86,127.38 126.79,127.31 126.5,127.02 126.25,127.02 UC1.B6
  BOTTOM w0.089: 126.86,128.07 127.99,129.2 127.99,130.62 128.25,130.88 129.77,130.88 129.81,130.84 v3(130.04,130.84) 130.29,130.84 130.45,131 RP51.2
CPU_DPC_CTRLCLK: length 122.4
  IN1 w0.084: v2(124.42,125.28) 124.01,125.69 123.66,125.69 123.62,125.73 120.87,125.73 119.12,127.47 116.58,127.47 114.81,125.7 114.81,125.08 114.04,124.31 96.76,124.31 96.49,124.04 96.49,120.64 95.84,120 95.11,120 94.09,118.98 92.31,118.98 91.87,118.54 89.03,118.54 89.01,118.51 88.95,118.51 88.93,118.49 88.91,118.49
  IN1 w0.127: v2(43.27,108.16) 43.45,108.33 46.27,108.33 51.39,113.45 69.91,113.45 72.96,116.51 81.25,116.51 83.23,118.49 88.91,118.49
  IN3 w0.127: v2(18.06,110.22) 18.25,110.42 18.55,110.42 19.16,111.02 24.89,111.02 27.59,108.32 43.11,108.32 v2(43.27,108.16)
  BOTTOM w0.089: v2(124.42,125.28) 124.54,125.28 125.05,125.79 UC1.D9
  BOTTOM w0.102: RP52.3 19.02,111.27 18.88,111.12 18.88,110.72 18.56,110.41 18.25,110.41 v2(18.06,110.22)
CPU_DPC_CTRLDAT: length 122
  IN1 w0.084: v2(124.43,126.29) 124.05,125.92 123.76,125.92 123.72,125.96 120.96,125.96 119.22,127.7 116.49,127.7 114.58,125.8 114.58,125.18 113.95,124.54 96.66,124.54 96.26,124.14 96.26,120.73 95.75,120.22 95.01,120.22 94,119.21 92.22,119.21 91.77,118.76 88.91,118.76
  IN1 w0.127: v2(43.27,108.74) 43.41,108.6 46.16,108.6 51.28,113.72 69.79,113.72 72.85,116.78 81.14,116.78 83.12,118.76 88.91,118.76
  IN3 w0.127: v2(43.27,108.74) 43.1,108.57 27.69,108.57 24.99,111.28 19.05,111.28 18.44,110.67 18.2,110.67 v2(18.06,110.81)
  BOTTOM w0.089: UC1.D11 124.76,125.79 124.82,125.85 124.82,126.06 124.59,126.29 v2(124.43,126.29)
  BOTTOM w0.102: RP52.4 18.52,111.27 18.66,111.12 18.66,110.81 18.47,110.62 18.25,110.62 v2(18.06,110.81)
CPU_EDP_AUX#_C: length 3.3
  TOP w0.102: CX44.2 199.48,174.25 v2(200.1,174.25) 200.3,174.25 200.75,173.79 UX4.3
  BOTTOM w0.102: RX37.1 200.87,174.07 200.28,174.07 v2(200.1,174.25)
CPU_EDP_AUX_C: length 3.4
  TOP w0.102: CX43.2 199.8,173.65 v2(200.13,173.65) 200.32,173.65 200.58,173.39 UX4.4
  BOTTOM w0.102: v2(200.13,173.65) 200.33,173.85 200.8,173.85 RX39.1
CPU_EDP_HPD#: length 14.2
  BOTTOM w0.076: UC1.D6 127.08,125.79 127.38,126.08 127.63,126.08 127.8,126.25 127.8,126.35 128.08,126.63 128.53,126.63 128.67,126.77 128.67,127.09 128.54,127.21 128.22,127.21 128.05,127.38 128.05,127.71 129.02,128.67 130.12,128.67
  BOTTOM w0.102: QC3.1 134.41,132.72 134.73,132.4 RC78.2 RC89.1 133.52,131.9 133.42,131.8 RC105.2 132.86,131.21 v1(132.54,130.89) 132.49,130.94 132.39,130.94 130.12,128.67
CPU_EDP_N0_C: length 3.3
  TOP w0.102: UX4.8 200.82,171.79 200.71,171.9 200.38,171.9 v2(200.22,171.73) 200.05,171.9 199.82,171.9 CX46.2
  BOTTOM w0.102: RX43.1 200.9,171.99 200.47,171.99 v2(200.22,171.73)
CPU_EDP_N1_C: length 6.3
  TOP w0.102: CX39.2 197.88,170.61 198.37,170.61 198.49,170.49 v3(198.76,170.49) 199.3,170.49 v2(199.51,170.28) 199.76,170.54 199.95,170.54 200.46,171.04 200.7,171.04 200.76,170.99 UX4.10
  BOTTOM w0.102: RX47.1 200.84,170.28 200.26,170.28 200.07,170.47 199.7,170.47 v2(199.51,170.28)
CPU_EDP_P0_C: length 3.3
  TOP w0.102: UX4.7 200.78,172.19 200.7,172.11 200.42,172.11 v2(200.22,172.32) 200.02,172.11 199.71,172.11 CX42.2
  BOTTOM w0.102: RX41.1 200.77,172.2 200.33,172.2 v2(200.22,172.32)
CPU_EDP_P1_C: length 6.2
  TOP w0.102: CX38.2 197.95,170.83 198.45,170.83 198.57,170.71 199.11,170.71 199.13,170.7 199.34,170.7 v2(199.51,170.87) 199.62,170.75 199.86,170.75 200.37,171.26 200.68,171.26 200.81,171.39 UX4.9
  BOTTOM w0.102: v2(199.51,170.87) 199.68,170.69 200.16,170.69 200.35,170.49 200.84,170.49 RX45.1
CPU_PWR_DEBUG#: length 72
  TOP w0.102: v2(88.18,124.02) 88.36,124.2 88.36,124.89 87.98,125.27 86.36,125.27 85,123.92 v1(84.81,123.92) 82.11,123.92 80.8,122.61 72.68,122.61 65.18,115.1 v2(65.18,111.19)
  IN3 w0.127: v2(65.05,89.96) 64.68,90.33 64.68,93.03 65.01,93.36 65.01,97.53 65.9,98.42 65.9,101.78 65.22,102.46 65.22,104.13 64.51,104.85 64.51,105.92 65.18,106.59 v2(65.18,111.19)
  BOTTOM w0.076: UC1.H59 93.96,123.72 92.9,123.72 92.78,123.85 92,123.85 91.84,123.68 90.88,123.68 90.53,124.03 89.55,124.03 89.38,124.2 88.91,124.2
  BOTTOM w0.102: v2(65.05,89.96) 65.05,89.96 62.88,92.13 RC50.1 ; R253.1 81.91,122.47 82.63,122.47 82.69,122.53 83.66,122.53 R255.2 84.32,123.19 86.4,123.19 87.23,124.02 v2(88.18,124.02)
  BOTTOM w0.109: 88.91,124.2 88.36,124.2 v2(88.18,124.02)
CPU_PWR_DEBUG#_R: length 2.6
  BOTTOM w0.102: RC50.2 62.2,93.62 JXDP1.45
CPUSB#: length 7.6
  BOTTOM w0.089: UC1.K3 129.32,122.23 131.17,122.23 132.02,123.08 132.65,123.08 132.68,123.05 134.89,123.05 RC111.2
CS1: length 4.6
  TOP w0.102: PR105.1 203.46,22.82 v1(202.2,22.82)
  TOP w0.203: PR105.1 204.87,22.23 205.19,21.91 205.19,21.12 205.29,21.02 PU100.1
CS2: length 5.6
  TOP w0.102: PR108.1 v1(204.05,15.27)
  TOP w0.203: PU100.5 205.29,19.42 205.21,19.34 205.21,18.1 205.2,18.08 205.2,17.86
  TOP w0.254: PR108.1 204.82,16.45 205.41,17.05 205.41,17.64 205.2,17.86
CS_1.35V: length 4
  BOTTOM w0.102: PR205.2 157.34,21.95 v1(157.36,21.95)
  BOTTOM w0.203: PR205.2 158.72,23.33 158.72,24.52 158.51,24.73 PU200.13
CSA0#_0: length 32.3
  TOP w0.102: UV5.L12 v2(167.48,146.46)
  IN3 w0.102: v2(175.83,129.88) 175.3,130.42 174.75,130.42 174.13,131.04 173.31,131.04 173.11,131.24 173.11,132.38 172.63,132.85 172.63,133.83 171.03,135.43 171.03,136.2 170.46,136.77 169.83,136.77 169.42,137.18 169.42,137.4 ; 170.45,143.36 170.68,143.59 170.68,146.27 170.08,146.87 169.27,146.87 169.17,146.97 169.17,147.26 169.04,147.39 168.75,147.39 168.62,147.26 168.62,146.99 168.49,146.87 167.89,146.87 v2(167.48,146.46)
  IN3 w0.157: 170.45,143.36 170.27,143.18 170.05,143.18 168.74,141.87 166.53,141.87 166.36,141.7 166.36,138.93 166.59,138.7 169.29,138.7 169.42,138.57 169.42,137.4
  BOTTOM w0.102: UV5.L12 v2(167.48,146.46) ; UV1.K24 175.46,129.51 v2(175.83,129.88)
CSA1#_0: length 29.9
  TOP w0.102: UV3.L12 v2(187.99,146.39)
  IN3 w0.102: 186.66,137.22 185.45,136.01 185.45,135.23 185.13,134.92 185.13,133.12 184.91,132.89 184.66,132.89 183.94,132.17 183.94,131.16 183.72,130.95 183.72,130.48 183.15,129.91 v2(183.13,129.91) ; v2(187.99,146.39) 187.99,145.44 188.78,144.66 188.78,143.65 188.62,143.5 188.62,143.3
  IN3 w0.157: 188.62,143.3 188.62,142.55 189.4,141.78 190.4,141.78 190.53,141.66 190.53,141.1 190.4,140.97 190.08,140.97 189.96,140.85 189.96,139.14 189.6,138.78 189.38,138.78 189.02,139.14 188.84,139.14 188.58,138.87 188.58,138.69 188.93,138.34 188.93,138.12 188.71,137.89 188.49,137.89 187.89,138.49 187.71,138.49 187.44,138.23 187.44,137.9 187.88,137.46 187.88,137.24 187.61,136.97 187.29,136.97 186.97,137.29 186.73,137.29 186.66,137.22
  BOTTOM w0.102: UV1.M13 184.07,127.7 183.48,128.29 183.37,128.29 183.11,128.55 183.11,129.89 v2(183.13,129.91) ; UV3.L12 v2(187.99,146.39)
CSB0#_0: length 34.8
  TOP w0.102: UV7.L12 v2(206.76,136.32)
  IN3 w0.102: v2(187.94,127.86) 188.39,128.31 189.51,128.31 189.65,128.45 190.07,128.45 191.12,129.51 191.24,129.51 191.88,130.14 191.88,130.51 192.33,130.96 194.24,130.96 194.39,130.81 ; 203.66,133.12 206.57,133.12 207.17,133.72 207.17,135.91 v2(206.76,136.32)
  IN3 w0.157: 203.66,133.12 203.64,133.15 201.64,133.15 201.28,133.51 200.67,133.51 200.52,133.67 200.52,134.48 200.39,134.61 200.01,134.61 199.89,134.48 199.89,133.67 199.73,133.51 199.41,133.51 199.26,133.67 199.26,134.48 199.13,134.61 198.75,134.61 198.63,134.48 198.63,133.67 198.47,133.51 197.92,133.51 197.8,133.64 197.8,134.46 197.67,134.59 196.32,134.59 196.19,134.46 196.19,132.47 194.53,130.81 194.39,130.81
  BOTTOM w0.102: v2(187.94,127.86) 187.71,127.63 187.71,127.15 187.86,127 187.86,126.48 187.48,126.1 UV1.P10 ; UV7.L12 v2(206.76,136.32)
CSB1#_0: length 31.4
  TOP w0.102: UV9.L12 v2(206.57,115.92)
  IN3 w0.102: 194.39,115.02 193.44,115.02 192.14,116.32 192.14,116.99 191.38,117.75 188.5,117.75 v2(187.83,118.42) ; v2(206.57,115.92) 205.62,115.92 204.83,115.14 203.83,115.14 203.62,115.35 203.47,115.35
  IN3 w0.157: 194.39,115.02 195.79,115.02 196.34,114.47 196.34,112.25 197.41,111.18 198.48,111.18 198.58,111.28 198.58,111.66 198.68,111.76 199.11,111.76 199.21,111.66 199.21,111.29 199.31,111.19 199.76,111.19 199.86,111.29 199.86,112.11 199.97,112.21 200.46,112.21 200.56,112.31 200.56,112.74 200.46,112.84 199.97,112.84 199.86,112.94 199.86,114.05 199.99,114.18 202.01,114.18 203.17,115.35 203.47,115.35
  BOTTOM w0.102: v2(187.83,118.42) 187.83,118.27 UV1.AD10 ; UV9.L12 v2(206.57,115.92)
CSCL: length 14.2
  TOP w0.102: UX4.13 202.12,168.88 201.62,168.38 v3(201.4,168.38) 199.89,168.38 199.48,167.97 197.94,167.97 197.59,167.62 197.59,167.19 197.38,166.98 196.94,166.98 v2(196.78,167.14) 196.6,166.96 196.4,166.96 196.27,167.1 RP57.2 195.75,167.1 195.38,166.73 195.38,166.38 194.77,165.77 194.77,165.08 194.62,164.93 QX6.4
  BOTTOM w0.102: v2(196.78,167.14) 196.95,166.97 198.68,166.97 198.97,166.68 198.97,166.33 RX6.2
CSDA: length 15.4
  TOP w0.102: UX4.14 202.52,168.96 201.71,168.15 199.98,168.15 199.58,167.74 198.03,167.74 197.82,167.53 197.82,167.1 197.48,166.75 196.97,166.75 v2(196.78,166.56) 196.6,166.74 196.4,166.74 196.26,166.6 RP57.1 195.7,166.6 195.61,166.51 195.61,166.28 195,165.67 195,164.21 195.59,163.63 QX6.1
  BOTTOM w0.102: v2(196.78,166.56) 196.96,166.74 198.58,166.74 198.74,166.58 198.74,166.4 RX31.2
CSIN: length 30.2
  BOTTOM w0.254: PR702.3 142.71,164.2 142.4,163.88 142.4,162.82 142.61,162.61 164.59,162.61 165.93,163.95 167.1,165.12 v1(167.1,165.83) 167.1,166.73 PR704.2
CSIP: length 31.4
  BOTTOM w0.254: PR717.2 167.52,166.89 167.52,164.95 v1(166.26,163.69) 164.8,162.23 142.45,162.23 142.01,162.67 142.01,163.88 141.7,164.2 PR702.2
CSN1_CPU: length 23.2
  BOTTOM w0.203: PU501.18 91.92,140.43 91.95,140.47 92.4,140.47
  BOTTOM w0.254: PL502.3 101.57,142.17 101.88,142.48 101.88,145.91 100.68,147.12 95.41,147.12 v1(93.89,145.61) PR515.2 PR517.2 PC511.1 PC510.1 93.28,140.47 92.4,140.47
CSP1_CPU: length 12.3
  TOP w0.102: v2(95.85,146.29) v1(95.85,146.81)
  IN1 w0.254: v2(92.41,144.39) 92.51,144.49 92.51,144.99 93.69,146.17 95.72,146.17 v2(95.85,146.29)
  BOTTOM w0.203: 92.06,140.87 91.81,140.87 91.76,140.83 PU501.17
  BOTTOM w0.254: PH501.1 95.58,146.03 v2(95.85,146.29) ; 92.06,140.87 92.77,140.87 PC510.2 PC511.2 PR517.1 92.62,143.22 92.62,143.22 92.47,143.37 92.47,144.32 v2(92.41,144.39) 92.41,144.56 PR518.1
DAT_SMB: length 37.6
  TOP w0.102: v1(140.53,186.55) PR20.1
  TOP w0.254: PR20.1 141.88,187.26 142.27,187.66 v2(142.27,187.67)
  IN1 w0.254: v2(145.7,187.45) 146.65,188.41 151.89,188.41 156.08,184.22 165.22,184.22 167.07,186.06 PBATT.6
  BOTTOM w0.254: v2(142.27,187.67) 142.27,187.66 142.24,187.62 PD1.1 143.01,187.06 143.98,188.03 145.69,188.03 145.76,187.95 PD3.2 146.27,187.65 146.08,187.45 v2(145.7,187.45)
DBC_EN: length 168.6
  TOP w0.102: UE1.25 192.79,39.41 v2(192.73,39.47) ; RX19.1 222.25,178.93 223.69,178.93 224.27,178.35 224.27,177.75 v2(224.06,177.53)
  IN2 w0.127: v2(224.06,177.53) 223.49,176.96 223.49,176.44 222.27,175.23 222.27,173.38 221.77,172.88 221.77,164.57 222.27,164.07 222.27,151.47 225.59,148.15 225.59,123.71 224.44,122.56 224.44,92.64 221.09,89.29 221.09,81.5 222.66,79.93 222.66,61.54 217.61,56.49 217.61,54.93 217.2,54.52 v2(217.19,54.52)
  BOTTOM w0.102: v2(217.19,54.52) 217.21,54.52 217.5,54.23 v1(217.5,52.96) 217.5,52.26 212.07,46.83 210.86,46.83 208.6,44.57 196.63,44.57 192.73,40.67 v2(192.73,39.47)
DBC_EN_R: length 5.8
  TOP w0.102: v1(222.6,176.02) 222.55,176.08 222.55,177.08 222.22,177.41 v2(222,177.41) 222,177.92 RX19.2 222.18,178.12 RX23.1
  BOTTOM w0.102: v2(222,177.41) 222.06,177.41 222.19,177.28 222.26,177.28 222.54,176.99 222.54,176.59 222.51,176.57 JLVDS.21
DC_TEST_A3_B3: length 0.7
  BOTTOM w0.089: UC1.A3 129.14,127.04 UC1.B3
DC_TEST_A4: length 8.6
  BOTTOM w0.102: T168.1 135.61,130.38 133.93,130.38 133.48,129.94 132.1,129.94 130.36,128.2 129.01,128.2 UC1.A4
DC_TEST_A60: length 6.8
  BOTTOM w0.102: T169.1 89.64,131.49 89.64,130.31 90.04,129.91 90.71,129.91
  BOTTOM w0.109: 90.71,129.91 92.37,128.25 93.09,128.25 93.55,127.78 UC1.A60
DC_TEST_A61_B61: length 0.7
  BOTTOM w0.076: UC1.B61 92.89,126.98 UC1.A61
DC_TEST_A62: length 4.5
  BOTTOM w0.089: 89.25,128.97 89.7,128.51 90.52,128.51 91.05,127.98 91.84,127.98 UC1.A62
  BOTTOM w0.102: T170.1 89.25,128.97
DC_TEST_AV1: length 4
  BOTTOM w0.076: UC1.AV1 130.34,106.25 130.69,105.91 133.04,105.91
  BOTTOM w0.089: T171.1 133.79,106.66 133.04,105.91
DC_TEST_AW1: length 3.5
  BOTTOM w0.089: T172.1 132.89,104.78 131.02,104.78 UC1.AW1
DC_TEST_AW63: length 10.5
  BOTTOM w0.102: T173.1 89.32,97.24 89.32,99.62 89.03,99.91 89.03,102.16 89.32,102.45 89.32,103.96 90.87,105.51 UC1.AW63
DC_TEST_AY2_AW2: length 5.5
  BOTTOM w0.076: UC1.AW2 129.62,105.06 UC1.AY2
  BOTTOM w0.089: v1(134.23,104.24) 133.93,104.55 130.58,104.55 130.18,104.94 UC1.AY2
DC_TEST_AY3_AW3: length 7.8
  BOTTOM w0.076: UC1.AY3 129.01,105.55 UC1.AW3
  BOTTOM w0.089: v1(135.42,103.64) 132.9,103.64 132.4,104.14 130.79,104.14 130.72,104.07 130.47,104.07 130.17,104.36 129.35,104.36 129.01,104.71 UC1.AY3
DC_TEST_AY60: length 4
  BOTTOM w0.102: T166.1 92.24,103.02 92.24,103.66 UC1.AY60
DC_TEST_AY61_AW61: length 6.3
  BOTTOM w0.076: UC1.AY61 92.87,105.51 UC1.AW61
  BOTTOM w0.089: v1(90.53,100.28) 90.49,100.32 90.49,102.16 92.87,104.54 UC1.AY61
DC_TEST_AY62_AW62: length 5.1
  BOTTOM w0.076: UC1.AW62 92.22,105.51 UC1.AY62
  BOTTOM w0.089: UC1.AY62 92.22,104.41 v1(89.48,101.67)
DC_TEST_B62_B63: length 4.3
  BOTTOM w0.089: 88.91,127.64 88.94,127.61 89.61,127.61 89.84,127.39 90.93,127.39 91.33,126.98 UC1.B63
  BOTTOM w0.102: 88.91,127.64 v1(88.47,128.08)
  BOTTOM w0.254: UC1.B62 91.78,126.85 UC1.B63
DC_TEST_C1_C2: length 4.7
  BOTTOM w0.076: UC1.C1 130.16,126.31 UC1.C2
  BOTTOM w0.089: UC1.C1 130.66,126.43 131.19,126.96 131.74,126.96 v1(133.38,128.6)
DDBIA0_0: length 12.2
  TOP w0.102: 167.81,137.4 168.3,136.9 v1(168.3,136.02) v2(168.3,135.43)
  TOP w0.127: 167.81,137.4 164.29,140.91 164.29,144.86 UV5.P13
  BOTTOM w0.102: v2(168.3,135.43) 167.97,135.1 UV1.A34
DDBIA0_1: length 34.8
  BOTTOM w0.127: UV1.E30 171.38,133.82 171.38,135.23 171.07,135.55 171.07,136.29 170.3,137.05 166.55,137.05 163.13,140.47 v1(162.06,140.47) 161.04,140.47 160.2,141.32 160.2,153.95 160.62,154.37 160.62,154.38 161.88,155.64 163.02,155.64 163.48,155.18 163.48,154.67 163.69,154.46 164.08,154.46 164.47,154.06 UV4.D2
DDBIA0_2: length 29.8
  TOP w0.127: v2(174.72,137.78) 175.1,137.78 178.42,141.1 v1(178.42,153.06) 178.42,153.73 176.48,155.67 174.45,155.67 173.91,155.13 173.91,154.69 173.73,154.51 173.41,154.51 172.96,154.06 UV5.D2
  BOTTOM w0.102: UV1.E26 174.26,133.87 174.57,134.17 174.57,134.48 174.55,134.49 174.55,134.99 174.58,135.02 174.58,135.22 174.46,135.33 174.46,135.71 174.45,135.72 174.45,135.75
  BOTTOM w0.127: 174.45,135.75 174.45,137.51 v2(174.72,137.78)
DDBIA0_3: length 14.1
  BOTTOM w0.102: 177.58,137.24 178.78,136.05 178.78,135.53 178.55,135.31 178.55,134.83 179.06,134.33 UV1.C20
  BOTTOM w0.127: 177.58,137.24 177.32,137.5 177.32,139.35 v1(177,139.67) 173.9,142.77 173.9,144.54 173.54,144.9 173.26,144.9 172.9,145.26 UV4.P13
DDBIA1_0: length 12.1
  TOP w0.102: 184.26,137.4 184.26,136.97 182.58,135.3 v2(182.58,134.73)
  TOP w0.127: 184.26,137.4 v1(184.26,139.56) 184.37,139.67 184.37,141.91 184.8,142.34 184.8,144.8 UV3.P13
  BOTTOM w0.102: v2(182.58,134.73) 182.58,134.62 UV1.C16
DDBIA1_1: length 29.7
  BOTTOM w0.102: UV1.C12 185.35,134.18 185.35,134 185.45,133.9 185.55,133.9 185.81,134.16 185.81,134.41 185.75,134.46 185.75,134.93 185.77,134.95 185.77,135.32 185.51,135.59 185.51,136.14 185.32,136.32 185.32,137.4
  BOTTOM w0.127: 185.32,137.4 185.32,137.4 179.75,142.97 v1(179.75,146.6) 179.75,152.93 181.13,154.31 181.13,154.31 182.39,155.58 183.53,155.58 183.99,155.12 183.99,154.61 184.21,154.39 184.59,154.39 184.99,154 UV6.D2
DDBIA1_2: length 39.2
  TOP w0.102: 188.24,132.25 187.28,131.28 187.28,130.31 v2(186.86,129.89)
  TOP w0.127: UV3.D2 193.47,154 193.93,154.45 194.24,154.45 194.42,154.63 194.42,155.07 194.96,155.6 195.5,155.6 195.77,155.34 197.07,155.34 199.31,153.1 v1(199.31,151.7) 199.31,142.89 193.21,136.79 189.79,136.79 188.73,135.73 188.73,132.73 188.24,132.25
  BOTTOM w0.102: UV1.J11 186.45,130.3 v2(186.86,129.89)
DDBIA1_3: length 16.2
  BOTTOM w0.102: 189.92,135.78 189.92,135.75 189.94,135.74 189.94,135.49 189.75,135.31 189.75,134.82 189.77,134.81 189.77,134.47 189.53,134.24 189.32,134.24 189.16,134.08 189.16,133.79 189.17,133.77 189.17,133.29 188.86,132.98 UV1.F8
  BOTTOM w0.127: 189.92,135.78 189.92,136.13 191.57,137.78 192.38,137.78 v1(194.41,139.81) 194.41,144.47 194.05,144.83 193.77,144.83 193.41,145.19 UV6.P13
DDBIB0_0: length 20.3
  TOP w0.102: v2(190.8,132.27) 191.38,132.27 192.26,133.15 192.26,133.15 192.3,133.18 192.7,133.18 193.43,132.45 193.89,132.45 194.23,132.12 194.39,132.12
  TOP w0.127: UV7.P13 205.17,139.51 203.94,139.51 203.77,139.34 203.77,139.05 202.69,137.97 201.69,137.97 v1(198.61,134.89) 195.84,132.12 194.39,132.12
  BOTTOM w0.102: UV1.G7 190.03,132.27 v2(190.8,132.27)
DDBIB0_1: length 35.2
  BOTTOM w0.102: 194.39,129.73 194.13,129.73 193.74,129.34 193.22,129.34 193.17,129.3 UV1.K1
  BOTTOM w0.127: UV8.D2 214.02,139.45 214.02,140.07 214.27,140.31 214.48,140.31 214.72,140.56 214.72,142.59 214.09,143.23 207.88,143.23 207.55,143.56 203.51,143.56 199.89,139.94 199.89,138.84 197.86,136.81 197.86,132.76 v1(196.06,130.97) 194.83,129.73 194.39,129.73
