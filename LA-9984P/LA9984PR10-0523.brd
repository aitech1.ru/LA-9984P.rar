# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D44: length 72.8
  IN1 w0.084: 90.17,98.58 90.39,98.79 91.47,98.79 92.83,100.15 v2(92.83,100.91)
  IN1 w0.127: v2(52.9,71.45) 52.9,72.64 53.02,72.76 53.81,72.76 53.91,72.86 53.91,73.19 53.81,73.28 52.99,73.28 52.86,73.41 52.86,73.68 52.99,73.81 53.81,73.81 53.91,73.9 53.91,79.97 61.74,87.8 66.36,92.42 72.84,92.42 72.96,92.55 72.96,92.89 73.09,93.01 73.34,93.01 73.47,92.89 73.47,92.55 73.6,92.42 73.85,92.42 73.98,92.55 73.98,92.89 74.11,93.01 74.36,93.01 74.49,92.89 74.49,92.55 74.61,92.42 74.87,92.42 74.99,92.55 74.99,92.89 75.12,93.01 75.38,93.01 75.5,92.89 75.5,92.55 75.63,92.42 75.88,92.42 76.01,92.55 76.01,92.89 76.14,93.01 76.39,93.01 76.52,92.89 76.52,92.55 76.65,92.42 84.01,92.42 90.17,98.58
  BOTTOM w0.076: UC1.AV54 97.38,106.11 96.81,105.55 96.81,104.68 96.67,104.54 96.67,103.55 94.03,100.91 v2(92.83,100.91)
  BOTTOM w0.102: v2(52.9,71.45) 53.2,71.76 JDIMM1.39
DDR_A_D45: length 73.1
  IN1 w0.084: 90.17,98.08 90.58,98.48 91.46,98.48 96.35,103.37 v2(97.72,103.37)
  IN1 w0.127: v2(52.9,66.88) 53.37,67.36 53.37,71.64 54.25,72.52 54.25,72.54 54.25,72.55 54.25,79.83 62.08,87.65 66.49,92.07 67.71,92.07 84.16,92.07 90.17,98.08
  BOTTOM w0.076: UC1.AU54 98.03,106.89 98.24,106.69 98.24,105.85 98.23,105.84 98.19,105.75 98.16,105.7 98.16,105.49 98.24,105.33 98.24,105.2 98.19,105.1 98.19,105.1 98.16,105.05 98.16,104.53 98.14,104.51 98.14,103.79 v2(97.72,103.37)
  BOTTOM w0.102: v2(52.9,66.88) 53.5,66.28 JDIMM1.40
DDR_A_D46: length 72.7
  IN1 w0.084: 90.17,95.82 92.43,98.09 92.43,98.62 94.55,100.73 v2(95.45,100.73)
  IN1 w0.127: 90.17,95.82 84.89,90.54 68.34,90.54 64.12,86.32 62.9,86.32 55.78,79.2 55.78,71.92 55.77,71.91 55.77,70.23 55.78,70.23 55.78,68.05 55.9,67.92 56.21,67.92 56.34,67.8 56.34,67.53 56.21,67.4 55.59,67.4 55.46,67.28 55.46,67.01 55.59,66.88 v2(56.87,66.88)
  BOTTOM w0.076: v2(95.45,100.73) 96.12,100.73 98.31,102.92 98.31,104.38 98.33,104.4 98.33,105.01 98.38,105.11 98.4,105.17 98.4,105.37 98.38,105.42 98.38,105.42 98.34,105.51 98.33,105.53 98.33,105.66 98.35,105.71 98.38,105.76 98.52,105.9 UC1.AV52
  BOTTOM w0.102: v2(56.87,66.88) 57.1,66.66 JDIMM1.52
DDR_A_D47: length 73.8
  IN1 w0.084: 91.02,95.67 93.61,98.26 v2(93.61,98.89)
  IN1 w0.127: 91.02,95.67 85.19,89.83 68.6,89.83 64.4,85.63 63.18,85.63 60.1,82.55 60.1,82.35 60.26,82.18 60.26,82 60.02,81.76 59.84,81.76 59.67,81.94 59.49,81.94 59.31,81.76 59.31,81.58 59.73,81.16 59.73,80.98 59.55,80.8 59.37,80.8 58.95,81.22 58.77,81.22 58.59,81.04 58.59,80.86 59.01,80.44 59.01,80.26 58.83,80.08 58.65,80.08 58.23,80.5 58.05,80.5 57.87,80.32 57.87,80.14 58.29,79.72 58.29,79.54 56.46,77.71 56.46,71.63 56.46,71.63 56.46,71.28 56.46,71.27 56.46,70.87 56.46,70.87 56.46,70.52 56.46,70.51 56.46,70.34 v2(56.87,69.93)
  BOTTOM w0.076: UC1.AU52 99.01,106.51 99.01,105.2 99.05,105.1 99.08,105.04 99.08,104.75 98.83,104.5 98.83,104.2 98.8,104.18 98.8,102.64
  BOTTOM w0.089: v2(93.61,98.89) 95.06,98.89 98.8,102.64
  BOTTOM w0.102: JDIMM1.53 57.4,70.46 v2(56.87,69.93)
DDR_A_D48: length 85.7
  IN1 w0.084: 96.3,95.67 96.3,95.9 102.77,102.38 102.77,106.38 103.37,106.98 106.14,106.98 106.47,107.31 106.47,109.76 105.76,110.48 v2(105.76,110.98)
  IN1 w0.127: 96.3,95.67 96.3,94.37 87.11,85.19 71.34,85.19 64.92,78.77 64.92,77.41 63.57,76.06 63.57,74.47 63.18,74.08 63.18,68.63 63.31,68.5 63.85,68.5 63.97,68.37 63.97,68.12 63.85,67.99 63.31,67.99 63.18,67.86 63.18,67.61 63.31,67.48 63.85,67.48 63.97,67.36 63.97,67.1 63.85,66.97 63.31,66.97 63.18,66.85 63.18,66.22 63.06,66.09 62.45,66.09 62.32,66.22 62.32,69.49 v2(61.88,69.93)
  BOTTOM w0.076: v2(105.76,110.98) 106.08,111.31 UC1.AK40
  BOTTOM w0.102: JDIMM1.69 62.2,71.99 62.45,71.74 62.45,70.5 v2(61.88,69.93)
DDR_A_D49: length 85.4
  IN1 w0.084: 95.94,95.67 95.94,95.84 96.1,96 96.15,96 102.6,102.45 102.6,106.45 103.3,107.15 106.07,107.15 106.3,107.38 106.3,109.69 105.83,110.16 105.71,110.16 v2(104.84,111.03)
  IN1 w0.127: 95.94,95.67 95.94,94.52 86.95,85.53 71.18,85.53 64.04,78.39 64.04,78.22 64.55,77.71 64.55,77.53 64.32,77.29 64.14,77.29 63.65,77.78 63.47,77.78 63.29,77.6 63.29,77.42 63.78,76.93 63.78,76.76 63.55,76.53 63.44,76.53 62.92,77.05 62.74,77.05 62.58,76.88 62.58,76.7 62.45,76.57 62.2,76.57 62.07,76.44 62.07,76.1 62.2,75.97 63.1,75.97 63.22,75.84 63.22,75.59 63.1,75.46 62.36,75.46 62.23,75.33 62.23,75.08 62.36,74.95 63.06,74.95 63.19,74.83 63.19,74.57 63.06,74.45 61.97,74.45 61.84,74.32 61.84,74.06 61.97,73.94 62.7,73.94 62.83,73.81 62.83,73.56 62.7,73.43 61.93,73.43 61.8,73.3 61.8,73.05 61.93,72.92 62.7,72.92 62.83,72.79 62.83,72.54 62.7,72.41 62.39,72.41 62.26,72.29 62.26,72.03 62.39,71.91 62.7,71.91 62.83,71.78 62.83,70.54 62.7,70.41 62.42,70.41 62.3,70.54 62.3,71.04 v2(61.88,71.45)
  BOTTOM w0.076: v2(104.84,111.03) 105.12,111.31 UC1.AK42
  BOTTOM w0.102: v2(61.88,71.45) 61.6,71.73 JDIMM1.67
DDR_A_D50: length 82.9
  IN1 w0.084: 93.65,95.67 93.65,95.75 95.72,97.83 95.72,98.65 99.22,102.15 99.22,102.73 99.93,103.44 99.93,106.67 100.64,107.38 100.64,108.34 101.07,108.77 101.5,108.77 101.64,108.91 102.3,108.91 102.7,109.31 103.14,109.31 103.39,109.56 103.64,109.56 v2(103.89,109.81)
  IN1 w0.127: 93.65,95.67 93.65,95.38 86.01,87.74 70.23,87.74 69.86,87.37 65.9,83.41 65.76,83.41 65.46,83.71 65.31,83.71 65.09,83.48 65.09,83.34 65.39,83.04 65.39,82.9 65.02,82.53 64.87,82.53 64.59,82.82 64.42,82.82 64.22,82.61 64.22,82.45 64.51,82.16 64.51,82.02 64.28,81.79 64.14,81.79 63.85,82.08 63.71,82.08 63.48,81.86 63.48,81.71 63.77,81.42 63.77,81.28 63.54,81.05 63.4,81.05 63.11,81.34 62.93,81.34 62.74,81.15 62.74,80.98 63.03,80.69 63.03,80.54 62.81,80.32 62.66,80.32 62.38,80.61 62.2,80.61 62.01,80.42 62.01,80.24 62.3,79.95 62.3,79.81 62.07,79.58 61.93,79.58 61.64,79.87 61.46,79.87 61.34,79.75 61.27,79.68 61.27,79.5 61.56,79.21 61.56,79.07 61.34,78.85 61.19,78.85 60.9,79.13 60.72,79.13 60.54,78.94 60.54,78.77 60.82,78.48 60.82,78.33 60.6,78.11 60.46,78.11 60.17,78.4 60,78.4 59.8,78.19 59.8,78.03 60.09,77.74 60.09,77.6 59.59,77.1 59.59,76.63 59.46,76.51 59.08,76.51 58.96,76.38 58.96,76.03 59.08,75.9 59.47,75.9 59.59,75.78 59.59,75.51 59.47,75.38 59.06,75.38 58.94,75.26 58.94,74.56 59.06,74.44 59.47,74.44 59.59,74.31 59.59,74.09 59.47,73.97 59.06,73.97 58.94,73.84 58.94,73.59 59.06,73.46 59.47,73.46 59.59,73.33 59.59,73.08 59.47,72.95 59.06,72.95 58.94,72.82 58.94,72.57 59.06,72.44 59.47,72.44 59.59,72.32 59.59,72.06 59.47,71.93 59.06,71.93 58.94,71.81 58.94,71.39 59.06,71.27 59.34,71.27 59.46,71.39 v2(59.46,71.45)
  BOTTOM w0.076: UC1.AM43 104.18,109.81 v2(103.89,109.81)
  BOTTOM w0.102: v2(59.46,71.45) 59.2,71.72 JDIMM1.59
DDR_A_D51: length 82.4
  IN1 w0.084: 93.3,95.67 93.3,95.87 95.47,98.03 95.47,98.64 98.96,102.14 98.96,102.86 99.65,103.54 99.65,106.63 100.46,107.45 100.46,108.78 100.63,108.95 101.43,108.95 101.57,109.08 102.23,109.08 102.53,109.38 102.53,109.65 102.62,109.74 v2(102.94,109.74)
  IN1 w0.127: 93.3,95.67 93.3,95.54 85.85,88.09 70.09,88.09 69.72,87.72 69.58,87.72 69.3,88 69.12,88 68.93,87.81 68.93,87.63 69.21,87.35 69.21,87.21 68.99,86.98 68.84,86.98 68.56,87.26 68.38,87.26 68.19,87.07 68.19,86.89 68.47,86.61 68.47,86.47 68.25,86.24 68.11,86.24 67.81,86.54 67.66,86.54 67.44,86.32 67.44,86.17 67.74,85.88 67.74,85.73 67.51,85.51 67.37,85.51 67.07,85.81 66.93,85.81 66.7,85.58 66.7,85.44 67,85.14 67,85 66.78,84.77 66.63,84.77 66.34,85.07 66.19,85.07 65.97,84.84 65.97,84.7 66.28,84.39 66.28,84.27 66.03,84.02 65.91,84.02 65.6,84.33 65.46,84.33 63.48,82.35 63.46,82.35 59.34,78.23 59.34,78 59.58,77.76 59.58,77.58 59.4,77.39 59.22,77.39 58.96,77.65 58.78,77.65 58.6,77.46 58.6,77.28 58.92,76.95 58.92,76.83 58.6,76.5 58.6,71.08 58.71,70.97 58.89,70.97 59.01,70.85 59.01,70.56 58.89,70.45 58.71,70.45 58.6,70.33 58.6,69.39 58.72,69.27 58.94,69.27 59.07,69.39 59.07,69.8 59.2,69.93 v2(59.46,69.93)
  BOTTOM w0.076: UC1.AM45 103.14,109.74 v2(102.94,109.74)
  BOTTOM w0.102: JDIMM1.57 58.6,70.8 v2(59.46,69.93)
DDR_A_D52: length 83.1
  IN1 w0.084: v2(102.95,111.04) 102.36,110.45 102.36,109.47 102.14,109.26 101.49,109.26 101.36,109.12 100.27,109.12 99.69,108.54 99.69,107.1 98.66,106.07 98.66,102.12 95.15,98.6 95.15,98.1 92.93,95.87 92.93,95.67
  IN1 w0.127: 92.93,95.67 85.69,88.43 69.07,88.43 64.05,83.41 63.3,82.66 63.28,82.66 59.23,78.61 58.25,77.63 58.25,68.45 59.4,67.3 59.4,62.58 v2(58.77,61.95)
  BOTTOM w0.076: UC1.AK45 103.22,111.31 v2(102.95,111.04)
  BOTTOM w0.102: v2(58.77,61.95) 58.3,62.41 JDIMM1.56
DDR_A_D53: length 84.3
  IN1 w0.084: 92.42,95.67 94.83,98.08 94.83,98.53 98.39,102.08 98.39,106.08 99.52,107.21 99.52,108.62 100.19,109.29 101.17,109.29 101.56,109.69 101.56,111.04 101.88,111.35 102.5,111.35 102.56,111.41 103.59,111.41 v2(103.89,111.11)
  IN1 w0.127: 92.42,95.67 85.97,89.21 85.53,88.77 68.92,88.77 63.78,83.62 63.16,83 63.14,83 58.89,78.76 57.91,77.77 57.91,66.54 58.04,66.41 58.64,66.41 58.77,66.28 58.77,65.88 58.64,65.76 58.07,65.76 57.94,65.63 57.94,65.37 58.07,65.25 58.64,65.25 58.77,65.12 58.77,64.87 58.64,64.74 58.07,64.74 57.94,64.61 57.94,64.36 58.07,64.23 58.64,64.23 58.77,64.1 v2(58.77,63.47)
  BOTTOM w0.076: UC1.AK43 104.18,111.11 v2(103.89,111.11)
  BOTTOM w0.102: v2(58.77,63.47) 58.9,63.6 JDIMM1.58
DDR_A_D54: length 84.3
  IN1 w0.084: 95.59,95.67 95.59,95.86 95.91,96.19 96.1,96.19 102.43,102.52 102.43,106.52 103.23,107.33 106,107.33 106.13,107.45 106.13,109.31 v2(105.76,109.68)
  IN1 w0.127: 95.59,95.67 95.59,94.67 86.79,85.87 71.02,85.87 61.46,76.31 61.46,65.26 61.58,65.14 63.4,65.14 63.54,65 63.54,62.79 63.41,62.66 63.08,62.66 62.96,62.79 62.96,63.7 62.83,63.83 62.56,63.83 62.43,63.7 62.43,63.23 62.32,63.11 62,63.11 61.88,63.23 v2(61.88,63.47)
  BOTTOM w0.076: v2(105.76,109.68) 106.08,110 UC1.AM40
  BOTTOM w0.102: v2(61.88,63.47) 61.9,63.49 JDIMM1.68
DDR_A_D55: length 84
  IN1 w0.084: 95.23,95.67 95.23,96.21 95.56,96.54 96.2,96.54 101.57,101.9 101.57,106.7 101.91,107.05 102.71,107.05 103.46,107.8 103.46,108.49 103.89,108.93 104.15,108.93 104.84,109.61 v2(104.84,109.73)
  IN1 w0.127: 95.23,95.67 95.23,94.82 87.04,86.63 86.63,86.22 70.86,86.22 61.12,76.47 61.12,65.12 61.45,64.78 63.07,64.78 63.2,64.66 63.2,64.39 63.07,64.26 61.62,64.26 61.46,64.1 61.46,62.06 61.57,61.95 v2(61.88,61.95)
  BOTTOM w0.076: v2(104.84,109.73) 105.12,110 UC1.AM42
  BOTTOM w0.102: v2(61.88,61.95) 62.5,62.57 JDIMM1.70
DDR_A_D56: length 66.8
  IN3 w0.084: 95.3,95.67 95.3,96.53 96.93,98.16 96.93,99.17 98.79,101.03 98.79,106.59 101.58,109.38 101.58,109.87 v2(101.98,110.28)
  IN3 w0.127: 95.3,95.67 95.3,94.74 94.62,94.06 94.62,93.21 94.45,93.03 94.45,91.65 93.82,91.02 93.82,88.27 104.44,77.65 104.44,72.99 104.31,72.86 102.22,72.86 102.1,72.73 102.1,71.36 102.22,71.24 103.33,71.24 103.46,71.11 103.46,70.74 103.33,70.61 102.22,70.61 102.1,70.49 102.1,70.18 102.22,70.05 103.03,70.05 103.15,69.93 103.15,69.56 103.03,69.44 102.07,69.44 101.94,69.31 101.94,68.72 101.81,68.6 101.04,68.6 100.93,68.48 100.93,68.17 101.04,68.05 101.83,68.05 101.96,67.93 101.96,67.64 101.83,67.51 101.26,67.51 101.13,67.39 101.13,67.1 101.26,66.97 101.85,66.97 101.98,66.85 v2(101.98,63.47)
  BOTTOM w0.076: v2(101.98,110.28) 102.26,110 UC1.AM46
  BOTTOM w0.102: v2(101.98,63.47) 101.5,63.95 JDIMM1.192
DDR_A_D57: length 66.8
  IN3 w0.084: v2(101.98,110.93) 102.36,110.56 102.36,109.47 102.08,109.2 101.65,109.2 98.97,106.52 98.97,104.41 99.57,103.81 99.57,103.4 99.14,102.97 99.14,101.14 97.24,99.24 97.24,98.16 95.66,96.57 95.66,95.67
  IN3 w0.127: v2(101.98,61.95) 102.52,61.95 102.64,62.07 102.64,65.52 102.77,65.65 104.11,65.65 104.23,65.77 104.23,68.05 104.11,68.18 102.61,68.18 102.48,68.3 102.48,68.59 102.61,68.72 103.98,68.72 104.8,69.54 104.8,77.8 94.98,87.62 94.98,92.62 95.15,92.79 95.15,94.08 95.66,94.59 95.66,95.67
  BOTTOM w0.076: UC1.AK46 102.36,111.31 v2(101.98,110.93)
  BOTTOM w0.102: v2(101.98,61.95) 102.52,62.49 102.52,63.68 102.1,64.1 JDIMM1.194
DDR_A_D58: length 64.3
  IN3 w0.084: v2(100.03,109.74) 99.72,109.74 99.28,109.31 98.43,109.31 97.84,108.72 97.84,105.99 97.12,105.27 97.12,103.37 97.66,102.83 97.66,102.19 93.06,97.59 93.06,95.87 92.85,95.67
  IN3 w0.127: v2(99.41,71.47) 98.98,71.89 98.98,75.43 99.19,75.63 99.19,79.74 97.42,81.5 97.23,81.5 96.8,81.07 96.62,81.07 96.42,81.27 96.42,81.45 96.85,81.88 96.85,82.07 96.66,82.27 96.47,82.27 95.81,81.61 95.62,81.61 95.43,81.81 95.43,82 96.08,82.65 96.08,82.84 95.72,83.21 95.53,83.21 94.87,82.55 94.69,82.55 94.49,82.75 94.49,82.93 95.15,83.59 95.15,83.78 94.95,83.97 94.76,83.97 94.14,83.35 93.96,83.35 93.76,83.55 93.76,83.73 94.38,84.35 94.38,84.54 94.19,84.74 94,84.74 93.34,84.08 93.16,84.08 92.96,84.28 92.96,84.46 93.62,85.12 93.62,85.31 93.42,85.5 93.23,85.5 92.57,84.84 92.4,84.84 92.19,85.05 92.19,85.23 92.85,85.88 92.85,86.07 92.66,86.27 92.47,86.27 91.81,85.61 91.63,85.61 91.43,85.81 91.43,85.99 92.09,86.66 92.09,86.83 91.83,87.09 91.65,87.09 91.42,86.86 91.24,86.86 91,87.1 91,87.28 91.28,87.56 91.28,87.64 91,87.92 91,93.82 92.85,95.67
  BOTTOM w0.076: UC1.AM49 100.29,110 v2(100.03,109.74)
  BOTTOM w0.102: v2(99.41,71.47) 98.8,72.08 JDIMM1.183
DDR_A_D59: length 63.2
  IN3 w0.084: 91.31,95.67 91.97,96.33 91.97,98.5 95.88,102.41 95.88,111.14 96.42,111.69 99.4,111.69 v2(100.08,111.01)
  IN3 w0.127: 91.31,95.67 89.91,94.27 89.91,85.78 97.43,78.27 97.43,73.46 97.87,73.02 97.87,68.51 98.01,68.38 98.66,68.38 98.8,68.24 98.8,67.97 98.66,67.84 97.95,67.84 97.82,67.71 97.82,65.84 97.95,65.71 98.67,65.71 98.8,65.58 98.8,63.7 v2(99.03,63.47)
  BOTTOM w0.076: UC1.AK49 100.38,111.31 v2(100.08,111.01)
  BOTTOM w0.102: JDIMM1.182 98.5,64 v2(99.03,63.47)
DDR_A_D60: length 65.9
  IN3 w0.084: 94.57,95.67 94.57,96.75 95.72,97.91 95.72,98.77 98.45,101.5 98.45,108.59 98.64,108.79 99.66,108.79 99.84,108.97 100.32,108.97 v2(101.03,109.68)
  IN3 w0.127: v2(101.31,71.47) 101.31,71.74 100.95,72.1 100.93,72.1 100.7,72.32 100.7,74.16 100.83,74.29 101.55,74.29 101.68,74.41 101.68,74.7 101.55,74.83 100.83,74.83 100.7,74.95 100.7,75.79 100.83,75.91 102.9,75.91 103.03,76.04 103.03,76.32 102.9,76.45 100.83,76.45 100.7,76.57 100.7,76.87 100.83,76.99 102.9,76.99 103.03,77.12 103.03,77.41 102.9,77.53 100.83,77.53 100.7,77.66 100.7,77.97 100.83,78.09 102.43,78.09 102.56,78.22 102.56,78.5 102.43,78.63 100.83,78.63 100.7,78.75 100.7,79.05 100.83,79.17 101.35,79.17 101.48,79.3 101.48,79.59 101.35,79.71 100.83,79.71 100.7,79.84 100.7,80.37 93.1,87.98 93.1,88.55 92.96,88.68 92.64,88.68 92.52,88.8 92.52,89.1 92.64,89.22 92.96,89.22 93.1,89.36 93.1,89.63 92.96,89.76 92.64,89.76 92.52,89.88 92.52,90.19 92.64,90.31 92.96,90.31 93.1,90.44 93.1,90.71 92.96,90.85 92.64,90.85 92.52,90.97 92.52,91.27 92.64,91.39 92.96,91.39 93.1,91.52 93.1,92.71 93.76,93.38 93.76,94.43 94.57,95.24 94.57,95.67
  BOTTOM w0.076: UC1.AM48 101.36,110 v2(101.03,109.68)
  BOTTOM w0.102: v2(101.31,71.47) 101.2,71.58 JDIMM1.191
DDR_A_D61: length 65.5
  IN3 w0.084: 94.93,95.67 94.93,96.54 96.68,98.29 96.68,99.16 98.62,101.11 98.62,106.67 99.68,107.73 99.68,108.57 99.92,108.8 100.71,108.8 101.4,109.49 101.4,109.94 101.53,110.07 101.53,110.83 101.38,110.98 v2(101.03,110.98)
  IN3 w0.127: 94.93,95.67 94.93,95.1 94.13,94.29 94.13,93.23 93.46,92.56 93.46,88.12 103.39,78.18 103.39,77.63 103.53,77.5 103.78,77.5 103.9,77.37 103.9,77.08 103.78,76.96 103.53,76.96 103.39,76.82 103.39,75.67 103.27,75.55 101.89,75.55 101.76,75.42 101.76,75.13 101.89,75.01 103.95,75.01 104.08,74.88 104.08,74.59 103.95,74.46 102.16,74.46 102.04,74.34 102.04,74.05 102.16,73.92 103.95,73.92 104.08,73.8 104.08,73.35 103.95,73.22 101.19,73.22 101.06,73.1 101.06,72.63 101.19,72.51 101.61,72.51 101.73,72.38 101.73,70.07 101.61,69.95 v2(101.31,69.95)
  BOTTOM w0.076: v2(101.03,110.98) 101.36,111.31 UC1.AK48
  BOTTOM w0.102: JDIMM1.193 101.8,70.44 v2(101.31,69.95)
DDR_A_D62: length 63.5
  IN3 w0.084: v2(99.13,109.68) 98.68,109.68 98.58,109.78 98.58,110.67 98.48,110.77 97.77,110.77 97.67,110.67 97.67,106.44 96.55,105.32 96.55,102.39 92.7,98.54 92.7,96.03 92.34,95.67
  IN3 w0.127: 92.34,95.67 90.64,93.97 90.64,86.09 96.23,80.5 96.42,80.5 96.62,80.71 96.8,80.71 97.01,80.5 97.01,80.32 96.8,80.11 96.8,79.92 96.99,79.73 97.18,79.73 97.84,80.39 98.02,80.39 98.22,80.19 98.22,80.01 97.57,79.35 97.57,79.16 97.76,78.97 97.95,78.97 98.44,79.46 98.62,79.46 98.82,79.25 98.82,79.08 98.68,78.93 98.68,78.75 98.55,78.63 98.35,78.63 98.23,78.5 98.23,78.16 98.35,78.03 98.7,78.03 98.82,77.9 98.82,77.54 98.7,77.42 98.29,77.42 98.15,77.28 98.15,77.01 98.29,76.88 98.7,76.88 98.82,76.75 98.82,76.46 98.7,76.33 98.29,76.33 98.15,76.2 98.15,75.93 98.29,75.79 98.49,75.79 98.62,75.67 98.62,75.38 98.49,75.25 98.29,75.25 98.15,75.12 98.15,74.85 98.29,74.71 98.49,74.71 98.62,74.58 98.62,74.31 98.49,74.17 98.29,74.17 98.15,74.04 98.15,73.76 98.29,73.63 98.49,73.63 98.62,73.5 98.62,69.72 98.75,69.59 99.28,69.59 99.41,69.72 v2(99.41,69.95)
  BOTTOM w0.076: v2(99.13,109.68) 99.46,109.68 99.52,109.74 UC1.AM51
  BOTTOM w0.102: JDIMM1.181 98.2,71.15 v2(99.41,69.95)
DDR_A_D63: length 62.8
  IN3 w0.084: v2(99.13,110.98) 98.59,111.51 97.23,111.51 96.85,111.13 96.85,106.71 96.37,106.22 96.37,102.66 92.33,98.62 92.33,96.18 91.83,95.67
  IN3 w0.127: v2(99.03,61.95) 99.45,62.37 99.45,64.05 99.23,64.26 99.23,68.59 98.26,69.57 98.26,73.14 97.79,73.61 97.79,78.42 90.28,85.94 90.28,94.12 91.83,95.67
  BOTTOM w0.076: UC1.AK51 99.45,111.31 v2(99.13,110.98)
  BOTTOM w0.102: v2(99.03,61.95) 97.9,63.07 JDIMM1.180
DDR_A_DQS0: length 73.4
  IN3 w0.084: v2(87.4,110.63) 87.58,110.63 87.8,110.41 87.78,110.38 87.78,110.1 86.64,108.95 86.12,108.95 86.1,108.98 86.08,108.98
  IN3 w0.127: v2(84.74,69.57) 84.54,69.76 84.35,69.76 84.07,70.04 84.07,71.73 80.92,74.88 80.92,75.37 75.45,80.84 75.45,81.58 75.32,81.7 74.99,81.7 74.72,81.98 74.72,82.55 74.99,82.83 75.32,82.83 75.45,82.95 75.45,83.31 75.32,83.44 74.99,83.44 74.72,83.71 74.72,84.29 74.99,84.56 75.32,84.56 75.45,84.69 75.45,85.05 75.32,85.18 74.99,85.18 74.72,85.45 74.72,86.03 74.99,86.3 75.32,86.3 75.45,86.43 75.45,86.79 75.32,86.91 74.99,86.91 74.72,87.19 74.72,87.76 74.99,88.04 75.32,88.04 75.45,88.16 75.45,88.53 75.32,88.65 74.99,88.65 74.72,88.93 74.72,89.5 74.99,89.78 75.32,89.78 75.45,89.9 75.45,90.26 75.32,90.39 74.99,90.39 74.72,90.66 74.72,91.24 74.99,91.51 75.32,91.51 75.45,91.64 75.45,92 75.32,92.13 74.99,92.13 74.72,92.4 74.72,92.98 74.99,93.25 75.32,93.25 75.45,93.38 75.45,93.74 75.32,93.86 75.12,93.86 74.85,94.13 74.85,94.72 75.12,94.99 75.32,94.99 75.45,95.11 75.45,99.24 77.52,101.3 77.52,106.96 79.53,108.98 86.08,108.98
  BOTTOM w0.076: v2(87.4,110.63) 87.7,110.63 87.79,110.54 88.11,110.54 88.66,111.08 89.99,111.08 90.61,111.7 91.06,111.7 91.19,111.83 91.75,111.83 91.8,111.86 91.91,111.91 92.04,111.91 92.06,111.9 92.14,111.86 92.2,111.84 92.4,111.84 92.56,111.91 92.69,111.91 92.8,111.86 92.8,111.69 92.73,111.62 UC1.AJ62
  BOTTOM w0.102: JDIMM1.137 85,72.26 84.8,72.06 84.8,71.96 85.47,71.29 85.47,70.05 85.29,69.87 85.04,69.87 v2(84.74,69.57)
DDR_A_DQS1: length 89.5
  IN1 w0.084: 87.13,106.34 87.39,106.34 87.54,106.5 88.46,106.5 89.86,107.9 89.86,108.1 89.8,108.16 v2(89.55,108.16)
  IN1 w0.127: 87.13,106.34 82.25,101.46 77.16,101.46 76.53,102.1 75.56,102.1 75.04,101.58 74.66,101.21 62.47,101.21 52.31,91.05 51.83,91.05 45.51,84.73 45.51,83.37 44.97,82.83 44.97,80.84 43.45,79.32 43.45,76.74 42.88,76.17 42.88,69.33 43.97,68.24 43.97,62.22 44.47,61.72 44.71,61.72 v2(44.86,61.57)
  BOTTOM w0.076: v2(89.55,108.16) 89.53,108.18 89.53,109.03 90.02,109.52 90.86,109.52 90.92,109.57 91.44,109.57 91.44,109.57 91.71,109.57 91.87,109.64 92.08,109.64 92.23,109.57 92.7,109.57 92.86,109.41 93.05,109.41 UC1.AN61
  BOTTOM w0.102: JDIMM1.12 45.1,64.04 45.03,63.97 45.03,63.77 45.5,63.3 45.5,62.02 45.24,61.77 45.06,61.77 v2(44.86,61.57)
DDR_A_DQS2: length 64.7
  IN3 w0.084: v2(94.42,108.94) 94.26,109.1 93.44,109.1 92.1,107.76 92.1,107.3 88.05,103.25 88.05,102.82
  IN3 w0.127: 88.05,102.82 88.09,102.77 88.09,101.93 81.01,94.85 81.01,81.95 87.19,75.77 87.19,75.08 89.95,72.32 89.95,68.84 90.02,68.77 90.29,68.77 90.55,68.5 90.55,67.84 90.29,67.58 89.86,67.58 89.74,67.46 89.74,67.05 89.86,66.93 90.19,66.93 90.46,66.66 90.46,62.14 89.88,61.57 v2(89.15,61.57)
  BOTTOM w0.089: UC1.AN58 94.84,109.35 v2(94.42,108.94)
  BOTTOM w0.102: JDIMM1.154 90.1,64.12 89.9,63.92 89.9,62.09 89.65,61.83 89.42,61.83 v2(89.15,61.57)
DDR_A_DQS3: length 84.8
  IN1 w0.084: v2(96.32,109.03) 96.49,109.19 96.59,109.19 96.7,109.08 96.7,107.56 95.38,106.24 94.05,106.24 93.48,105.67 92.04,105.67 90.14,103.76 90.14,103.28 88.85,101.99 88.85,101.96 88.8,101.91 88.77,101.91 88.7,101.84
  IN1 w0.127: 88.7,101.84 83.16,96.3 65.66,96.3 62.76,93.4 61.51,93.4 50.68,82.56 50.68,80.39 50.47,80.18 49.45,80.18 49.18,79.91 49.18,79.32 49.45,79.05 50.55,79.05 50.68,78.92 50.68,78.54 50.55,78.41 48.82,78.41 48.37,77.96 48.37,74.16 48.64,73.88 49.34,73.88 49.42,73.8 49.42,73.5 49.29,73.37 48.64,73.37 48.37,73.1 48.37,72.52 48.64,72.25 49.29,72.25 49.42,72.12 49.42,71.87 49.29,71.74 48.64,71.74 48.37,71.47 48.37,69.98 48.64,69.71 48.87,69.71 v2(49.04,69.55)
  BOTTOM w0.076: UC1.AN55 96.65,109.35 v2(96.32,109.03)
  BOTTOM w0.102: v2(49.04,69.55) 49.32,69.83 49.48,69.83 49.7,70.05 49.7,71.87 49.95,72.12 49.95,72.26 50.2,72.51 JDIMM1.29
DDR_A_DQS4: length 56.4
  IN3 w0.084: v2(91.86,101.96) 92.09,101.96 92.53,101.52 92.53,101.42 92.27,101.16 92.15,101.16 92.07,101.24 91.81,101.24 91.53,100.96 91.53,100.7 91.61,100.62 91.61,100.5 90.8,99.69 90.8,98.8 90.22,98.22 90.17,98.22
  IN3 w0.127: v2(94.87,69.57) 94.73,69.71 94.43,69.71 94.21,69.93 94.21,71.82 94.5,72.11 94.5,73.7 94.02,74.18 94.02,74.73 94.49,75.2 94.49,75.3 94.04,75.76 93.92,75.76 93.33,75.16 92.96,75.16 92.51,75.61 92.51,76.01 93,76.5 93,76.83 92.63,77.21 92.45,77.21 92.25,77.01 91.87,77.01 91.43,77.45 91.43,77.83 91.64,78.03 91.64,78.2 91.35,78.48 91.18,78.48 90.98,78.28 90.6,78.28 90.16,78.72 90.16,79.1 90.36,79.3 90.36,79.47 90.08,79.75 89.91,79.75 89.71,79.55 89.33,79.55 88.89,79.99 88.89,80.37 89.09,80.57 89.09,80.75 88.81,81.02 88.64,81.02 88.43,80.82 88.06,80.82 87.61,81.27 87.61,81.64 87.82,81.84 87.82,82.02 87.3,82.53 87.3,95.35 90.17,98.22
  BOTTOM w0.076: UC1.AW57 95.52,106.06 95.49,106.09 95.27,106.09 95.22,105.98 95.22,105.85 95.3,105.7 95.3,105.49 95.27,105.44 95.23,105.35 95.22,105.33 95.22,105.2 95.25,105.15 95.3,105.04 95.3,104.75 95.05,104.51 95.05,104 94.95,103.9 92.74,101.69 92.38,101.69 92.12,101.96 v2(91.86,101.96)
  BOTTOM w0.102: v2(94.87,69.57) 95.1,69.79 95.31,69.79 95.6,70.09 95.6,71.23 94.97,71.86 94.97,72.02 95.2,72.25 JDIMM1.171
DDR_A_DQS5: length 71.9
  IN1 w0.084: v2(96.83,102.11) 96.83,102.13 96.34,102.62 95.84,102.62 95.37,102.15 95.37,101.68 94.9,101.21 94.43,101.21 90.85,97.63 90.7,97.63 90.21,97.13
  IN1 w0.127: 90.21,97.13 90.13,97.13 84.8,91.8 84.42,91.43 67.98,91.43 63.84,87.3 62.62,87.3 54.89,79.57 54.89,72.25 54.01,71.37 54.01,70.03 54.33,69.7 54.55,69.7 v2(54.7,69.55)
  BOTTOM w0.076: UC1.AW53 97.77,105.92 97.73,105.88 97.73,105.49 97.7,105.44 97.66,105.35 97.65,105.33 97.65,105.2 97.68,105.15 97.71,105.09 97.71,105.09 97.73,105.04 97.73,104.73 97.47,104.48 97.47,104.35 97.33,104.2 97.33,103.21 96.55,102.44 96.55,102.15 96.59,102.11 v2(96.83,102.11)
  BOTTOM w0.102: v2(54.7,69.55) 54.91,69.75 55.13,69.75 55.4,70.02 55.4,72.05 55.6,72.25 JDIMM1.47
DDR_A_DQS6: length 84.1
  IN1 w0.084: v2(104.84,110.38) 104.64,110.38 104.45,110.19 104.45,109.55 104.08,109.17 103.78,109.17 103.48,108.87 102.77,108.87 102.53,108.63 102.53,107.49 102.31,107.27 101.63,107.27 101.17,106.82 101.17,104.31 100.72,103.86 100.72,101.9 100.01,101.2 99.03,101.2 97.56,99.73 97.56,98.84 94.6,95.88 94.6,95.67
  IN1 w0.127: 94.6,95.67 94.6,95.09 94.53,95.03 94.53,95.02 86.37,86.86 70.6,86.86 60.48,76.74 60.48,65.99 60.29,65.8 60.29,64.48 60.36,64.41 60.55,64.41 60.82,64.14 60.82,61.99 60.59,61.75 60.34,61.75 60.34,61.75 v2(60.15,61.57)
  BOTTOM w0.076: v2(104.84,110.38) 105.12,110.65 UC1.AL42
  BOTTOM w0.102: JDIMM1.64 60.7,64.18 60.54,64.02 60.54,63.74 61.06,63.23 61.06,62.11 60.84,61.89 60.48,61.89 v2(60.15,61.57)
DDR_A_DQS7: length 64.4
  IN3 w0.084: v2(100.08,110.36) 100.29,110.36 100.42,110.23 100.42,109.58 100.2,109.35 99.59,109.35 99.37,109.13 98.5,109.13 98.1,108.73 98.1,101.86 95.1,98.86 95.1,98.04 93.69,96.63 93.69,96.06
  IN3 w0.127: v2(100.58,62.33) 100.58,62.07 100.67,61.98 100.84,61.98 101.02,62.16 101.02,64.13 100.89,64.26 100.14,64.26 99.88,64.53 99.88,65.12 100.14,65.39 100.94,65.39 101.07,65.51 101.07,65.95 100.94,66.08 100.3,66.08 100.05,66.33 100.05,71.74 99.83,71.96 99.83,80.01 91.65,88.19 91.65,93.55 93.69,95.6 93.69,96.06
  BOTTOM w0.076: v2(100.08,110.36) 100.38,110.65 UC1.AL49
  BOTTOM w0.102: v2(100.58,62.33) 100.28,62.03 100.18,62.03 99.99,62.23 99.99,63.88 100.3,64.19 JDIMM1.188
DDR_A_DQS#0: length 73.6
  IN3 w0.084: 86.08,108.73 86.18,108.73 86.2,108.76 86.72,108.76 87.98,110.01 87.98,110.3 88.08,110.41 87.79,110.7 87.79,111.01 v2(87.82,111.04)
  IN3 w0.127: v2(84.74,70.33) 84.74,70.05 84.69,70 84.45,70 84.31,70.14 84.31,71.83 81.16,74.98 81.16,75.27 81.16,75.47 75.69,80.94 75.69,81.68 75.43,81.94 75.09,81.94 74.96,82.08 74.96,82.45 75.09,82.59 75.43,82.59 75.69,82.85 75.69,83.41 75.43,83.68 75.09,83.68 74.96,83.81 74.96,84.19 75.09,84.32 75.43,84.32 75.69,84.59 75.69,85.15 75.43,85.42 75.09,85.42 74.96,85.55 74.96,85.93 75.09,86.06 75.43,86.06 75.69,86.33 75.69,86.89 75.43,87.16 75.09,87.16 74.96,87.29 74.96,87.66 75.09,87.8 75.43,87.8 75.69,88.06 75.69,88.63 75.43,88.89 75.09,88.89 74.96,89.03 74.96,89.4 75.09,89.54 75.43,89.54 75.69,89.8 75.69,90.36 75.43,90.63 75.09,90.63 74.96,90.76 74.96,91.14 75.09,91.27 75.43,91.27 75.69,91.54 75.69,92.1 75.43,92.37 75.09,92.37 74.96,92.5 74.96,92.88 75.09,93.01 75.43,93.01 75.69,93.28 75.69,93.84 75.43,94.1 75.22,94.1 75.09,94.23 75.09,94.62 75.22,94.75 75.43,94.75 75.69,95.01 75.69,99.14 77.76,101.2 77.76,106.86 79.63,108.73 86.08,108.73
  BOTTOM w0.076: v2(87.82,111.04) 87.72,110.95 87.72,110.84 87.86,110.7 88.04,110.7 88.59,111.25 89.93,111.25 90.54,111.86 90.99,111.86 91.13,112 91.71,112 91.8,112.04 91.87,112.07 92.08,112.07 92.23,112 92.37,112 92.47,112.05 92.52,112.07 92.75,112.07 92.78,112.05 92.89,112 92.97,111.92 92.97,111.57 93.02,111.52 93.17,111.52 UC1.AJ61
  BOTTOM w0.102: JDIMM1.135 84.4,72.34 84.61,72.13 84.61,71.88 85.27,71.21 85.27,70.13 85.2,70.07 85,70.07 v2(84.74,70.33)
DDR_A_DQS#1: length 89.7
  IN1 w0.084: 87.25,106.11 87.28,106.13 87.47,106.13 87.63,106.29 88.55,106.29 90.07,107.81 90.07,108.23 89.79,108.51 89.79,108.64 89.94,108.78 v2(90.13,108.78)
  IN1 w0.127: v2(44.86,62.33) 44.86,62.09 44.74,61.97 44.58,61.97 44.22,62.32 44.22,68.34 43.13,69.43 43.13,76.07 43.7,76.63 43.7,79.22 45.22,80.74 45.22,82.72 45.76,83.27 45.76,84.63 51.93,90.79 52.41,90.79 62.57,100.95 74.77,100.95 75.29,101.47 75.66,101.85 76.42,101.85 77.06,101.21 82.35,101.21 87.25,106.11
  BOTTOM w0.076: UC1.AN62 92.67,109.24 92.67,109.34 92.61,109.41 92.2,109.41 92.14,109.43 92.06,109.47 92.04,109.48 91.91,109.48 91.85,109.45 91.75,109.4 90.98,109.4 90.93,109.35 90.09,109.35 89.7,108.96 89.7,108.58 89.87,108.41 89.98,108.41 90.13,108.55 v2(90.13,108.78)
  BOTTOM w0.102: v2(44.86,62.33) 44.81,62.28 44.81,62.09 44.94,61.96 45.16,61.96 45.3,62.11 45.3,63.22 44.83,63.69 44.83,63.97 44.78,64.02 44.61,64.02 44.5,64.13 JDIMM1.10
DDR_A_DQS#2: length 64.9
  IN3 w0.084: v2(94.42,109.59) 94.42,109.46 94.22,109.27 93.37,109.27 91.93,107.83 91.93,107.38 87.85,103.3 87.85,102.67
  IN3 w0.127: 87.85,102.67 87.85,102.03 80.77,94.95 80.77,81.85 86.95,75.67 86.95,74.98 89.71,72.22 89.71,68.74 89.92,68.53 90.19,68.53 90.31,68.4 90.31,67.94 90.19,67.82 89.76,67.82 89.5,67.56 89.5,66.95 89.76,66.69 90.09,66.69 90.22,66.56 90.22,62.24 89.78,61.81 89.51,61.81 89.15,62.16 v2(89.15,62.33)
  BOTTOM w0.076: UC1.AM58 94.87,109.77 94.69,109.59 v2(94.42,109.59)
  BOTTOM w0.102: v2(89.15,62.33) 89.45,62.03 89.56,62.03 89.7,62.17 89.7,63.92 89.5,64.12 JDIMM1.152
DDR_A_DQS#3: length 85
  IN1 w0.084: v2(96.32,109.68) 96.32,109.44 96.37,109.4 96.68,109.4 96.91,109.17 96.91,107.47 95.47,106.03 94.14,106.03 93.57,105.46 92.13,105.46 90.34,103.67 90.34,103.19 89.05,101.9 89.05,101.87 88.88,101.7 88.88,101.67 88.87,101.66
  IN1 w0.127: 88.87,101.66 83.26,96.05 65.77,96.05 62.87,93.15 61.62,93.15 50.93,82.46 50.93,80.29 50.57,79.93 49.56,79.93 49.43,79.8 49.43,79.42 49.56,79.3 50.65,79.3 50.93,79.02 50.93,78.43 50.65,78.16 48.93,78.16 48.62,77.85 48.62,74.26 48.75,74.14 49.44,74.14 49.67,73.91 49.67,73.4 49.4,73.12 48.75,73.12 48.62,73 48.62,72.63 48.75,72.5 49.4,72.5 49.67,72.23 49.67,71.77 49.4,71.49 48.75,71.49 48.62,71.37 48.62,70.09 48.74,69.97 48.92,69.97 49.04,70.09 v2(49.04,70.31)
  BOTTOM w0.076: v2(96.32,109.68) 96.37,109.63 96.63,109.63 96.72,109.72 UC1.AM55
  BOTTOM w0.102: JDIMM1.27 49.6,72.46 49.75,72.32 49.75,72.2 49.5,71.95 49.5,70.13 49.4,70.03 49.18,70.03 49.04,70.17 v2(49.04,70.31)
DDR_A_DQS#4: length 56.5
  IN3 w0.084: v2(92.32,102.42) 92.22,102.31 92.22,102.07 92.7,101.59 92.7,101.34 92.34,100.99 92.08,100.99 92,101.06 91.88,101.06 91.7,100.89 91.7,100.77 91.78,100.69 91.78,100.43 90.97,99.62 90.97,98.72 90.2,97.95 90.2,97.91 90.17,97.88
  IN3 w0.127: 90.17,97.88 87.55,95.25 87.55,82.63 88.06,82.12 88.06,81.74 87.86,81.54 87.86,81.37 88.16,81.06 88.33,81.06 88.54,81.26 88.91,81.26 89.33,80.85 89.33,80.47 89.13,80.27 89.13,80.09 89.43,79.79 89.61,79.79 89.81,79.99 90.18,79.99 90.6,79.57 90.6,79.2 90.4,79 90.4,78.82 90.7,78.52 90.88,78.52 91.08,78.73 91.45,78.73 91.88,78.3 91.88,77.93 91.68,77.73 91.68,77.55 91.97,77.25 92.15,77.25 92.35,77.45 92.73,77.45 93.24,76.93 93.24,76.4 92.75,75.91 92.75,75.71 93.06,75.4 93.23,75.4 93.82,76 94.14,76 94.73,75.4 94.73,75.1 94.26,74.63 94.26,74.28 94.74,73.8 94.74,72.01 94.45,71.72 94.45,70.03 94.53,69.95 94.69,69.95 94.87,70.13 v2(94.87,70.33)
  BOTTOM w0.076: UC1.AV57 95.63,106.46 95.63,106.3 95.58,106.25 95.2,106.25 95.14,106.19 95.06,106.02 95.06,105.82 95.08,105.76 95.13,105.66 95.13,105.53 95.06,105.37 95.06,105.17 95.08,105.11 95.08,105.11 95.13,105.01 95.13,104.82 94.89,104.58 94.89,104.07 94.88,104.06 92.67,101.86 92.45,101.86 92.2,102.11 92.2,102.3 v2(92.32,102.42)
  BOTTOM w0.102: v2(94.87,70.33) 94.87,70.14 95.02,69.99 95.23,69.99 95.41,70.17 95.41,71.15 94.77,71.78 94.77,72.09 94.6,72.26 JDIMM1.169
DDR_A_DQS#5: length 72.2
  IN1 w0.084: v2(96.37,101.65) 96.46,101.74 96.46,102.21 96.25,102.41 95.93,102.41 95.58,102.06 95.58,101.59 94.98,101 94.52,101 90.94,97.42 90.79,97.42 90.46,97.09 90.46,97.03 90.31,96.88 90.23,96.88
  IN1 w0.127: v2(54.7,70.31) 54.7,70.07 54.59,69.95 54.44,69.95 54.26,70.13 54.26,71.26 55.14,72.14 55.14,79.46 62.73,87.05 63.95,87.05 68.08,91.18 84.53,91.18 85.05,91.7 90.23,96.88
  BOTTOM w0.076: UC1.AV53 97.67,106.29 97.67,106.12 97.56,106.02 97.56,105.53 97.49,105.37 97.49,105.17 97.51,105.11 97.53,105.09 97.56,105.01 97.56,104.8 97.31,104.54 97.31,104.42 97.16,104.27 97.16,103.28 96.39,102.51 96.39,101.67 v2(96.37,101.65)
  BOTTOM w0.102: v2(54.7,70.31) 54.7,70.02 54.77,69.95 55.05,69.95 55.21,70.11 55.21,72.05 55,72.26 JDIMM1.45
DDR_A_DQS#6: length 84.2
  IN1 w0.084: v2(103.89,110.46) 103.89,110.64 104,110.75 104.2,110.75 104.28,110.67 104.28,109.62 104.01,109.34 103.7,109.34 103.41,109.04 102.7,109.04 102.36,108.7 102.36,107.57 102.24,107.45 101.56,107.45 101,106.89 101,104.39 100.54,103.93 100.54,101.97 99.94,101.37 98.96,101.37 97.39,99.8 97.39,98.91 94.39,95.91 94.39,95.79 94.37,95.77 94.37,95.7 94.35,95.68 94.35,95.67
  IN1 w0.127: 94.35,95.67 94.35,95.19 94.28,95.13 94.28,95.12 86.27,87.11 70.5,87.11 60.23,76.84 60.23,66.09 60.04,65.9 60.04,64.38 60.26,64.16 60.45,64.16 60.57,64.03 60.57,62.09 60.49,62 60.23,62 60.15,62.09 v2(60.15,62.33)
  BOTTOM w0.076: v2(103.89,110.46) 104.18,110.46 UC1.AL43
  BOTTOM w0.102: v2(60.15,62.33) 60.39,62.09 60.76,62.09 60.86,62.19 60.86,63.14 60.35,63.66 60.35,63.94 60.1,64.19 JDIMM1.62
DDR_A_DQS#7: length 64.9
  IN3 w0.084: v2(101.03,110.33) 100.74,110.33 100.59,110.18 100.59,109.5 100.27,109.18 99.66,109.18 99.44,108.96 98.57,108.96 98.27,108.66 98.27,101.78 95.28,98.79 95.28,97.97 93.87,96.56 93.87,96.2 93.94,96.13
  IN3 w0.127: v2(100.58,61.57) 100.75,61.74 100.94,61.74 101.26,62.06 101.26,64.23 100.99,64.5 100.24,64.5 100.12,64.63 100.12,65.02 100.24,65.14 101.04,65.14 101.31,65.41 101.31,66.05 101.04,66.32 100.4,66.32 100.29,66.43 100.29,71.84 100.07,72.06 100.07,80.11 91.89,88.29 91.89,93.45 93.94,95.5 93.94,96.13
  BOTTOM w0.076: v2(101.03,110.33) 101.36,110.65 UC1.AL48
  BOTTOM w0.102: v2(100.58,61.57) 100.31,61.83 100.1,61.83 99.79,62.14 99.79,64.12 99.7,64.2 JDIMM1.186
DDR_A_MA0: length 72.6
  IN1 w0.084: 103.99,95.77 103.99,95.82 104.3,96.13
  IN1 w0.089: 104.3,96.13 104.3,97.13 107.39,100.23 107.39,100.83 107.73,101.17 107.73,104.28 107.66,104.34 107.66,106.22 108.19,106.75 v2(108.27,106.75)
  IN1 w0.183: 103.99,95.77 103.99,88.35 92.21,76.57 77.92,76.57 74.23,72.88 73.92,72.88 72.84,71.8 72.84,67.96 73.1,67.7 73.1,66.03 73.28,65.85 73.95,65.85 74.13,65.66 74.13,65.3 73.95,65.11 73.28,65.11 73.1,64.93 73.1,63.17 v2(73.56,62.71)
  BOTTOM w0.076: UC1.AU36 108.59,106.75 v2(108.27,106.75)
  BOTTOM w0.165: JDIMM1.98 73.3,63.99 73.12,63.81 73.12,63.15 v2(73.56,62.71)
DDR_A_MA1: length 74.2
  IN1 w0.084: 104.91,95.67 104.91,95.73 105.29,96.1 105.29,97.57
  IN1 w0.089: v2(108.29,104.06) 108.08,103.86 108.08,101.02 107.8,100.74 107.8,100.08 105.29,97.57
  IN1 w0.183: 104.91,95.67 104.91,86.85 104.3,86.23 104.3,85.94 104.91,85.32 104.91,84.41 104.35,83.85 104.09,83.85 102.5,85.44 102.32,85.44 101.98,85.1 101.98,84.92 103.61,83.29 103.61,83.11 103.27,82.78 103.09,82.78 101.46,84.41 101.28,84.41 100.95,84.07 100.95,83.89 102.58,82.26 102.58,82.08 102.24,81.74 102.06,81.74 100.43,83.37 100.25,83.37 92.57,75.7 78.28,75.7 74.68,72.1 74.68,71.62 v2(73.77,70.71)
  BOTTOM w0.076: UC1.AY37 107.85,104.45 108.25,104.06 v2(108.29,104.06)
  BOTTOM w0.165: JDIMM1.97 73,71.98 72.82,71.81 72.82,71.02 73.14,70.71 v2(73.77,70.71)
DDR_A_MA2: length 75.8
  IN1 w0.084: 103.53,95.67 103.53,95.84 104.07,96.38
  IN1 w0.089: 104.07,96.38 104.07,97.16 107.13,100.21 107.13,100.82 107.55,101.24 107.55,104.2 107.48,104.27 107.48,107.47 v2(107.25,107.7)
  IN1 w0.183: 103.53,95.67 103.53,88.5 92.03,77.01 77.62,77.01 77.24,76.64 76.04,76.64 74.28,74.87 74.28,73.85 72.38,71.95 72.38,67.76 72.61,67.53 72.61,62.13 v2(73.56,61.18)
  BOTTOM w0.076: UC1.AR38 107.6,108.05 v2(107.25,107.7)
  BOTTOM w0.165: v2(73.56,61.18) 72.7,62.05 72.7,64.21 72.7,64.21 JDIMM1.96
DDR_A_MA3: length 75.8
  IN1 w0.084: 104.45,95.67 104.45,95.94 104.51,96 104.87,96 105.11,96.25 105.11,97.65 107.6,100.13
  IN1 w0.089: v2(108.21,108.53) 108.3,108.53 108.42,108.66 108.42,108.87 108.53,108.98 108.66,108.98 108.78,108.85 108.78,108.33 108.59,108.13 108.59,107.51 108.75,107.34 108.75,106.55 108.55,106.35 108.11,106.35 107.89,106.14 107.89,104.46 107.91,104.45 107.91,101.1 107.6,100.79 107.6,100.13
  IN1 w0.183: v2(73.77,69.19) 73.43,69.19 73.3,69.31 73.3,71.64 74.1,72.44 74.41,72.44 78.1,76.13 92.39,76.13 102.29,86.03 102.55,86.03 103.96,84.62 104.14,84.62 104.48,84.96 104.48,85.14 103.07,86.55 103.07,86.81 103.33,87.07 103.58,87.07 103.96,86.69 104.14,86.69 104.48,87.03 104.48,87.21 104.1,87.58 104.1,87.84 104.45,88.19 104.45,95.67
  BOTTOM w0.076: v2(108.21,108.53) 108.38,108.7 UC1.AP36
  BOTTOM w0.165: v2(73.77,69.19) 72.4,70.55 JDIMM1.95
DDR_A_MA4: length 76.9
  IN1 w0.084: v2(106.71,106.59) 106.06,105.95 106.06,100.69 103.95,98.58 103.11,98.58 100.74,96.2 100.74,95.67
  IN1 w0.183: 100.74,95.67 100.74,90.44 90.63,80.33 74.29,80.33 69.6,75.65 69.6,71.87 68.76,71.03 68.76,66.17 69.36,65.57 69.36,62.78 v2(70.95,61.18)
  BOTTOM w0.076: v2(106.71,106.59) 106.85,106.59 UC1.AU39
  BOTTOM w0.165: v2(70.95,61.18) 71.5,61.73 JDIMM1.92
DDR_A_MA5: length 75.4
  IN1 w0.084: 107.31,106.84 106.88,107.27 106.88,107.94 107.02,108.08 107.6,108.08 107.72,107.95 107.72,107.25 107.85,107.12 108.27,107.12 108.36,107.22 108.36,107.75 108.23,107.88 v2(108.21,107.88)
  IN1 w0.089: 103.06,95.69 103.85,96.47 103.85,97.18 106.95,100.29 106.95,100.9 107.37,101.32 107.37,104.13 107.31,104.2 107.31,106.84
  IN1 w0.183: v2(71.92,70.71) 71.92,72.11 73.84,74.04 73.84,75.05 75.87,77.08 77.07,77.08 77.27,77.28 77.27,77.84 77.45,78.02 78.14,78.02 78.32,77.84 78.32,77.63 78.51,77.44 78.87,77.44 79.05,77.63 79.05,77.84 79.24,78.02 79.6,78.02 79.79,77.84 79.79,77.63 79.97,77.44 80.33,77.44 80.52,77.63 80.52,77.84 80.7,78.02 81.07,78.02 81.25,77.84 81.25,77.63 81.43,77.44 81.8,77.44 81.98,77.63 81.98,77.84 82.16,78.02 82.53,78.02 82.71,77.84 82.71,77.63 82.89,77.44 83.26,77.44 83.44,77.63 83.44,77.84 83.63,78.02 83.99,78.02 84.18,77.84 84.18,77.63 84.36,77.44 84.72,77.44 84.91,77.63 84.91,77.84 85.09,78.02 85.46,78.02 85.64,77.84 85.64,77.63 85.82,77.44 86.19,77.44 86.37,77.63 86.37,77.84 86.55,78.02 86.92,78.02 87.1,77.84 87.1,77.63 87.28,77.44 87.65,77.44 87.83,77.63 87.83,77.84 88.02,78.02 88.38,78.02 88.56,77.84 88.56,77.63 88.75,77.44 89.11,77.44 89.3,77.63 89.3,77.84 89.48,78.02 89.84,78.02 90.03,77.84 90.03,77.63 90.21,77.44 90.58,77.44 90.76,77.63 90.76,77.84 90.94,78.02 92.43,78.02 103.06,88.66 103.06,95.69
  BOTTOM w0.076: v2(108.21,107.88) 108.38,108.05 UC1.AR36
  BOTTOM w0.165: JDIMM1.91 71.2,72.37 71.02,72.19 71.02,70.85 71.17,70.71 v2(71.92,70.71)
DDR_A_MA6: length 76.1
  IN1 w0.084: 101.66,95.67 101.66,96.63 101.84,96.8
  IN1 w0.089: v2(106.67,103.09) 106.42,102.84 106.42,100.51 103.91,98 103.04,98 101.84,96.8
  IN1 w0.183: 101.66,95.67 101.66,90.1 101.39,89.82 101.39,89.56 101.62,89.33 101.62,89.07 101.36,88.81 101.1,88.81 100.87,89.04 100.61,89.04 100.35,88.78 100.35,88.53 100.58,88.29 100.58,88.03 100.33,87.78 100.07,87.78 99.84,88.01 99.58,88.01 99.32,87.75 99.32,87.49 99.55,87.26 99.55,87 99.29,86.74 99.03,86.74 98.8,86.97 98.54,86.97 98.28,86.71 98.28,86.46 98.52,86.22 98.52,85.97 98.26,85.71 98,85.71 97.77,85.94 97.51,85.94 97.25,85.68 97.25,85.42 97.48,85.19 97.48,84.93 97.22,84.67 96.96,84.67 96.73,84.9 96.47,84.9 96.21,84.64 96.21,84.39 96.45,84.15 96.45,83.9 96.19,83.64 95.93,83.64 95.7,83.87 95.44,83.87 95.18,83.61 95.18,83.35 95.41,83.12 95.41,82.86 95.15,82.6 94.89,82.6 94.66,82.83 94.4,82.83 94.14,82.58 94.14,82.32 94.38,82.08 94.38,81.83 94.12,81.57 93.86,81.57 93.63,81.8 93.37,81.8 93.11,81.54 93.11,81.28 93.34,81.05 93.34,80.79 93.08,80.53 92.82,80.53 92.59,80.76 92.33,80.76 90.98,79.41 74.67,79.41 70.53,75.27 70.53,71.49 69.69,70.65 69.69,68.24 v2(70.27,67.66)
  BOTTOM w0.076: UC1.AV40 105.99,105.95 105.99,103.77 v2(106.67,103.09)
  BOTTOM w0.165: JDIMM1.90 70.9,67.29 70.53,67.66 v2(70.27,67.66)
DDR_A_MA7: length 74.6
  IN1 w0.084: 101.2,95.67 101.2,96.41 101.59,96.8
  IN1 w0.089: 101.59,96.8 103.04,98.26 103.92,98.26 106.24,100.58 106.24,104.84 v2(106.69,105.29)
  IN1 w0.183: 101.2,95.67 101.2,90.25 90.82,79.87 74.48,79.87 70.07,75.46 70.07,71.68 69.23,70.84 69.23,66.32 69.79,65.76 69.79,65.02 69.98,64.84 70.65,64.84 70.83,64.66 70.83,64.29 70.65,64.11 69.98,64.11 69.79,63.93 69.79,62.96 70.05,62.71 v2(70.95,62.71)
  BOTTOM w0.076: v2(106.69,105.29) 106.71,105.29 107.01,105.59 UC1.AW39
  BOTTOM w0.165: v2(70.95,62.71) 69.7,63.96 JDIMM1.86
DDR_A_MA8: length 75.2
  IN1 w0.084: 102.6,95.67 102.6,97.07 103.18,97.64 104.06,97.64
  IN1 w0.089: v2(106.7,104.34) 107.2,103.84 107.2,101.39 106.77,100.97 106.77,100.36 104.06,97.64
  IN1 w0.183: 102.6,95.67 102.6,88.82 92.27,78.48 76.96,78.48 76.83,78.36 76.83,77.64 76.7,77.51 76.17,77.51 76.04,77.64 76.04,78.38 75.91,78.51 75.34,78.51 75.21,78.38 75.21,77.4 75.08,77.27 74.85,77.27 74.41,77.7 74.23,77.7 73.9,77.36 73.9,77.18 74.54,76.54 74.54,76.37 74.2,76.03 74.02,76.03 73.38,76.67 73.2,76.67 72.86,76.33 72.86,76.15 73.5,75.51 73.5,75.33 73.17,74.99 72.99,74.99 72.67,75.31 72.49,75.31 72.15,74.97 72.15,74.79 72.98,73.97 72.98,73.79 72.64,73.45 72.46,73.45 71.79,74.11 71.55,74.11 71.43,73.99 71.43,73.44 71.91,72.96 71.91,72.72 71.45,72.26 71.45,69.74 71.92,69.27 v2(71.92,69.19)
  BOTTOM w0.076: UC1.AY39 107.1,104.74 v2(106.7,104.34)
  BOTTOM w0.165: JDIMM1.89 70.6,70.5 v2(71.92,69.19)
DDR_A_MA9: length 77.3
  IN1 w0.084: 102.14,95.67 102.14,96.85 103.11,97.82 103.35,97.82
  IN1 w0.089: v2(106.82,101.74) 106.6,101.51 106.6,100.44 103.98,97.82 103.35,97.82
  IN1 w0.183: v2(70.27,69.19) 70.71,68.74 70.71,65.36 70.84,65.23 71.34,65.23 71.47,65.36 71.47,69.07 70.99,69.54 70.99,75.08 74.86,78.95 92.11,78.95 102.14,88.97 102.14,95.67
  BOTTOM w0.076: v2(106.82,101.74) 105.82,102.56 105.82,106.42 106.09,106.68 106.09,106.75 UC1.AU40
  BOTTOM w0.165: v2(70.27,69.19) 69.4,70.05 JDIMM1.85
DDR_A_MA10: length 76.4
  IN1 w0.084: 108.18,97.35 108.47,97.64
  IN1 w0.089: v2(109.16,108.38) 109.09,108.38 108.78,108.07 108.78,107.57 108.93,107.42 108.93,105.14 109.25,104.82 109.25,103.67 109.48,103.44 109.48,102.05 109.61,101.92 110.05,101.92 110.24,101.73 110.24,100.04 110.13,99.93 109.72,99.93 109.56,99.77 109.56,98.72 108.47,97.64
  IN1 w0.183: v2(77.59,69.19) 78.05,69.65 78.05,71.04 78.61,71.59 79.38,71.59 80.33,72.55 97.31,72.55 97.44,72.42 97.44,71.17 97.57,71.05 98.04,71.05 98.17,71.17 98.17,74.24 98.3,74.37 98.83,74.37 98.96,74.24 98.96,73.32 99.09,73.19 99.6,73.19 99.72,73.32 99.72,74.24 99.85,74.37 100.4,74.37 100.52,74.49 100.52,75.86 107.88,83.21 107.88,97.05 108.18,97.35
  BOTTOM w0.076: v2(109.16,108.38) 109.48,108.7 UC1.AP35
  BOTTOM w0.165: v2(77.59,69.19) 76.99,69.78 76.99,70.98 76,71.97 JDIMM1.107
DDR_A_MA11: length 75.9
  IN1 w0.084: v2(105.12,105.29) 105.42,105.29 105.88,104.83 105.88,100.78 103.98,98.88 103.17,98.88 100.28,95.98 100.28,95.67
  IN1 w0.183: 100.28,95.67 100.28,90.63 90.44,80.8 74.1,80.8 69.14,75.84 69.14,72.06 68.3,71.22 68.3,66.01 68.92,65.39 68.92,62.13 v2(67.97,61.18)
  BOTTOM w0.076: UC1.AW41 105.43,105.59 105.13,105.29 v2(105.12,105.29)
  BOTTOM w0.165: v2(67.97,61.18) 69.1,62.31 JDIMM1.84
DDR_A_MA12: length 74.6
  IN1 w0.084: v2(105.13,106.59) 104.32,106.59 104.21,106.48 104.21,101.22 101.13,98.14 100.02,98.14 98.38,96.5 98.38,95.67
  IN1 w0.183: v2(66.75,69.17) 66.08,68.5 65.9,68.5 65.58,68.83 65.58,69.46 65.71,69.58 66.18,69.58 66.3,69.71 66.3,70.16 66.18,70.29 65.97,70.29 65.84,70.42 65.84,75.39 66.16,75.71 67.12,75.71 67.34,75.93 67.34,76.59 70.41,79.65 70.41,79.83 69.87,80.38 69.87,80.63 71.88,82.65 89.67,82.65 98.38,91.35 98.38,95.67
  BOTTOM w0.076: v2(105.13,106.59) 105.28,106.59 UC1.AU41
  BOTTOM w0.165: v2(66.75,69.17) 68.29,70.73 68.8,71.93 JDIMM1.83
DDR_A_MA13: length 75.1
  IN1 w0.084: 109.89,97.91 110.65,98.67 110.65,102.66 109.44,103.86 109.44,104.89 109.16,105.17 v2(109.16,107.73)
  IN1 w0.183: 109.89,97.91 108.8,96.83 108.8,82.62 102.71,76.53 102.71,75.08 100.17,72.54 100.17,69.31 99.22,68.36 92.06,68.36 91.87,68.55 91.87,71.44 91.74,71.56 91.27,71.56 91.14,71.44 91.14,68.7 90.8,68.36 82.6,68.36 82.32,68.63 82.32,70.58 82.2,70.71 v2(80.51,70.71)
  BOTTOM w0.089: v2(109.16,107.73) 109.48,108.05 UC1.AR35
  BOTTOM w0.165: JDIMM1.119 79.6,71.62 v2(80.51,70.71)
DDR_A_MA14: length 74.7
  IN1 w0.084: 99.81,95.67 99.81,95.77 103.13,99.09 103.94,99.09 105.71,100.86 105.71,102.72 v2(105.13,103.29)
  IN1 w0.183: v2(67.97,62.71) 68.35,62.71 68.48,62.84 68.48,63.79 68.35,63.92 67.97,63.92 67.84,64.04 67.84,64.54 67.97,64.66 68.3,64.66 68.48,64.85 68.48,65.21 68.3,65.4 67.97,65.4 67.84,65.52 67.84,71.41 68.68,72.26 68.68,76.03 73.9,81.26 90.25,81.26 99.81,90.83 99.81,95.67
  BOTTOM w0.076: v2(105.13,103.29) 104.73,103.7 104.73,104.28 104.41,104.59 104.41,105.95 UC1.AV42
  BOTTOM w0.165: JDIMM1.80 67.9,64.26 68.41,63.75 68.41,63.15 v2(67.97,62.71)
DDR_A_MA15: length 76.9
  IN1 w0.084: 99.35,95.67 99.35,96.01 99.53,96.19 99.89,96.19 104.85,101.16 104.85,102.36 v2(105.13,102.64)
  IN1 w0.183: v2(66.45,61.18) 67.29,61.18 67.38,61.27 67.38,71.61 68.22,72.45 68.22,76.23 73.71,81.72 90.06,81.72 99.35,91.02 99.35,95.67
  BOTTOM w0.076: UC1.AU42 104.51,106.75 104.51,106.68 104.25,106.42 104.25,104.45 104.56,104.14 104.56,103.21 v2(105.13,102.64)
  BOTTOM w0.165: JDIMM1.78 67.3,62.03 v2(66.45,61.18)
DDR_A_RAS#: length 75.3
  IN1 w0.084: 111.11,96.58 111.11,97.41 111.37,97.67 111.37,103.6 111.01,103.95
  IN1 w0.089: 111.01,103.95 v2(110.66,103.95)
  IN1 w0.183: v2(77.63,61.18) 76.94,61.88 76.94,63.41 78.13,64.61 98.67,64.61 102.68,68.62 102.68,71.7 105.41,74.44 105.41,76.04 111.11,81.74 111.11,96.58
  BOTTOM w0.076: UC1.AY34 110.25,104.35 v2(110.66,103.95)
  BOTTOM w0.165: v2(77.63,61.18) 76.9,61.91 JDIMM1.110
DDR_A_WE#: length 75.1
  IN1 w0.084: v2(109.86,105.29) 109.79,105.22 109.79,104.01 111.02,102.78 111.02,97.95 110.19,97.12 110.19,96.58
  IN1 w0.183: 110.19,96.58 110.19,82.05 104.54,76.4 104.54,74.8 101.8,72.07 101.8,68.98 98.77,65.95 88.58,65.95 88.4,66.13 88.4,66.73 88.22,66.92 87.85,66.92 87.67,66.73 87.67,66.13 87.49,65.95 84.86,65.95 84.67,66.13 84.67,66.73 84.49,66.92 84.12,66.92 83.94,66.73 83.94,66.13 83.76,65.95 81.13,65.95 80.93,66.16 80.93,67.32 79.86,68.38 79.86,68.87 79.59,69.14 79.59,70.09 v2(78.98,70.71)
  BOTTOM w0.089: v2(109.86,105.29) 110.15,105.29 110.25,105.39 UC1.AW34
  BOTTOM w0.165: v2(78.98,70.71) 77.8,71.89 JDIMM1.113
DDR_B_BS0: length 95.8
  IN3 w0.084: v2(109.16,110.33) 108.87,110.33 108.78,110.24 108.78,107.05 109.09,106.73 109.09,101.69 108.61,101.21 108.61,99.51 108.22,99.11 108.22,98.41
  IN3 w0.208: v2(155.87,70.73) 155.87,74.89 155.3,75.45 155.04,75.45 154.22,76.27 154.22,76.58 154.4,76.76 154.4,77.05 153.52,77.93 153.06,77.93 152.86,78.13 152.86,78.59 152.65,78.79 152.25,78.79 152.05,78.59 152.05,78.25 151.84,78.04 151.44,78.04 151.29,78.19 151.29,78.67 151.16,78.79 133.95,78.79 133.74,79 133.74,80.6 133.54,80.81 133.08,80.81 132.88,80.6 132.88,79 132.68,78.79 132.22,78.79 132.01,79 132.01,80.6 131.81,80.81 131.35,80.81 131.15,80.6 131.15,79 130.95,78.79 130.49,78.79 130.29,79 130.29,80.6 130.08,80.81 129.63,80.81 129.42,80.6 129.42,79 129.22,78.79 128.76,78.79 128.56,79 128.56,80.6 128.36,80.81 119.52,80.81 108.22,92.12 108.22,98.41
  BOTTOM w0.076: UC1.AL35 109.48,110.65 v2(109.16,110.33)
  BOTTOM w0.165: JDIMM2.109 155.15,72.32 155.54,71.93 155.54,71.68 155.15,71.29 155.15,70.93 155.35,70.73 v2(155.87,70.73)
DDR_B_BS1: length 97.9
  IN3 w0.084: 107.28,96.58 107.28,98.6 107.28,98.6 107.28,100.98 107.83,101.53 107.83,109.46 v2(108.21,109.83)
  IN3 w0.208: v2(156.04,61.22) 155.65,61.22 155.45,61.43 155.45,63.92 155.65,64.12 156.48,64.12 156.68,64.33 156.68,64.78 156.48,64.99 154.57,64.99 154.44,65.12 154.44,65.72 154.57,65.85 154.96,65.85 155.16,66.05 155.16,66.51 154.96,66.72 154.29,66.72 154.08,66.92 154.08,67.54 154.29,67.74 154.72,67.74 154.94,67.96 154.94,73.38 153.4,74.92 153.4,75.76 153.05,76.11 152.06,76.11 150.31,77.86 124.41,77.86 124.17,78.09 124.17,79.66 123.96,79.88 119.14,79.88 107.28,91.73 107.28,96.58
  BOTTOM w0.076: UC1.AM36 108.38,110 v2(108.21,109.83)
  BOTTOM w0.165: v2(156.04,61.22) 154.85,62.41 JDIMM2.108
DDR_B_BS2: length 92.6
  IN3 w0.084: 98.95,95.67 98.95,97.24 100.72,99.01 100.72,103.8 100.94,104.02 100.94,106.04 v2(100.41,106.57)
  IN3 w0.208: 98.95,95.67 98.95,88.49 108.82,78.62 108.82,78.31 108.09,77.58 108.09,77.29 108.41,76.97 108.7,76.97 109.44,77.71 109.73,77.71 110.05,77.39 110.05,77.1 108.93,75.98 108.93,75.69 109.25,75.37 109.54,75.37 110.66,76.49 110.95,76.49 111.37,76.07 111.37,75.78 110.26,74.68 110.26,74.35 119.23,65.38 144.55,65.38 144.81,65.65 144.81,67.11 145.38,67.68 145.38,68.67 v2(144.84,69.21)
  BOTTOM w0.076: UC1.AU49 100.53,106.57 v2(100.41,106.57)
  BOTTOM w0.165: JDIMM2.79 146.15,72.12 145.28,71.26 145.28,69.65 v2(144.84,69.21)
DDR_B_CAS#: length 96.2
  IN3 w0.084: 109.63,98.35 109.63,100.44 109.76,100.57 110.39,100.57 110.52,100.7 110.52,103.3 110.39,103.43 110.01,103.43 109.88,103.56 109.88,103.87 110.25,104.24 110.25,105.74 110.48,105.97 110.48,109.16 110.01,109.63 v2(110.01,109.72)
  IN3 w0.208: v2(157.43,70.73) 158.01,70.16 158.27,70.16 158.49,70.37 158.49,70.93 158.62,71.06 158.62,74.21 158.15,74.67 158.15,75.29 153.24,80.2 142.26,80.2 142.06,80.4 142.06,82.01 141.86,82.22 141.4,82.22 141.2,82.01 141.2,80.4 140.99,80.2 140.54,80.2 140.33,80.4 140.33,82.01 140.13,82.22 139.67,82.22 139.47,82.01 139.47,80.4 139.27,80.2 138.81,80.2 138.61,80.4 138.61,82.01 138.4,82.22 137.95,82.22 137.74,82.01 137.74,80.4 137.54,80.2 137.08,80.2 136.88,80.4 136.88,82.01 136.68,82.22 120.11,82.22 109.63,92.7 109.63,98.35
  BOTTOM w0.076: v2(110.01,109.72) 110.08,109.72 110.37,110 UC1.AM33
  BOTTOM w0.165: v2(157.43,70.73) 156.95,71.21 JDIMM2.115
DDR_B_D0: length 80.9
  IN3 w0.084: v2(111.96,99.73) 112.56,99.73 112.69,99.61 112.69,97.38 112.95,97.12 112.95,96.58
  IN3 w0.127: v2(161.24,68.72) 161.89,68.72 162.03,68.85 162.03,71.49 162.45,71.91 162.45,75.78 154.7,83.53 151.53,83.53 150.42,84.63 149.6,84.63 148.69,85.54 121.86,85.54 116.81,90.6 116.44,90.6 112.95,94.08 112.95,96.58
  BOTTOM w0.076: v2(111.96,99.73) 111.19,100.5 111.19,103.31 111.38,103.49 111.38,104.82 UC1.AY31
  BOTTOM w0.102: v2(161.24,68.72) 162.05,67.91 JDIMM2.132
DDR_B_D1: length 82
  IN3 w0.084: v2(111.96,99.08) 111.96,99.26 112.08,99.38 112.39,99.38 112.52,99.26 112.52,97.15 112.59,97.08 112.59,96.58
  IN3 w0.127: v2(161.24,70.24) 161.56,70.24 161.66,70.35 161.66,71.64 162.09,72.06 162.09,74.16 161.96,74.29 161.73,74.29 161.61,74.41 161.61,74.67 161.73,74.8 161.96,74.8 162.09,74.93 162.09,75.24 161.96,75.36 161.73,75.36 161.61,75.49 161.61,76.12 154.56,83.17 151.38,83.17 150.27,84.27 149.45,84.27 148.54,85.18 121.71,85.18 116.66,90.23 116.28,90.23 112.59,93.93 112.59,96.58
  BOTTOM w0.076: v2(111.96,99.08) 111.37,99.08 111.02,99.43 111.02,103.38 111.21,103.56 111.21,105.01 111.3,105.19 111.5,105.39 UC1.AW31
  BOTTOM w0.102: v2(161.24,70.24) 161.24,69.99 161.37,69.86 161.73,69.86 161.83,69.97 161.83,70.09 161.74,70.18 161.74,71.89 161.57,72.06 161.57,72.12 161.75,72.3 JDIMM2.131
DDR_B_D2: length 81.4
  IN3 w0.084: 115.19,95.95 115.19,96.18 114,97.38 114,98.67 v2(113.58,99.08)
  IN3 w0.127: v2(165.47,68.72) 164.39,68.72 164.26,68.84 164.26,69.35 164.69,69.78 164.69,77.01 155.93,85.77 152.45,85.77 151.35,86.87 150.53,86.87 149.62,87.78 122.79,87.78 117.74,92.84 117.4,92.84 115.19,95.04 115.19,95.95
  BOTTOM w0.076: v2(113.58,99.08) 112.74,99.93 112.74,103.82 112.85,103.94 UC1.AY29
  BOTTOM w0.102: v2(165.47,68.72) 164.45,67.69 JDIMM2.140
