# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML0DATA: length 10
  BOTTOM w0.076: UC1.AK1 130.79,111.36 131.16,111.72 133.81,111.72 133.93,111.6 133.93,110.6 134.12,110.42
  BOTTOM w0.089: 137.92,111.75 137.87,111.75 136.54,110.42 v1(136.16,110.42) 134.12,110.42
  BOTTOM w0.102: RP49.2 137.92,111.75
SML1_SMBCLK: length 32.2
  IN3 w0.084: v2(127.88,107.36) 126.78,107.36 126.33,107.82 126.33,110.41 126.19,110.55 126.19,111.66 126.33,111.8 126.33,112.47 126.46,112.6 127.88,112.6 128.81,113.53 129.35,113.53 129.82,114 129.82,114.18 131.51,115.87 132.5,115.87 133.2,115.17 137.45,115.17 v2(137.57,115.05) 137.71,115.19 137.92,115.19
  IN3 w0.127: v2(145,116.75) 144.95,116.75 143.39,115.19 137.92,115.19
  BOTTOM w0.089: UC1.AU3 128.87,106.92 128.52,107.28 127.96,107.28 v2(127.88,107.36)
  BOTTOM w0.102: v2(145,116.75) 145,115.97 145.25,115.71 145.74,115.71 145.92,115.89 QH1.1 ; RP40.3 137.57,115.05 v2(137.57,115.05)
SML1_SMBDATA: length 29.6
  IN3 w0.084: 137.92,114.68 137.16,114.68 v2(137.11,114.74)
  IN3 w0.127: 137.92,114.68 143.6,114.68 144.71,115.79 149.15,115.79 v2(149.32,115.95)
  BOTTOM w0.076: 136.68,112.45 136.68,111.25 136.47,111.03 135.02,111.03 134.72,111.33 134.72,111.77 134.22,112.27 130.53,112.27 130.4,112.4 130.16,112.4 129.99,112.23 129.99,112.05 129.75,111.82 129.23,111.82 UC1.AH3
  BOTTOM w0.102: 136.68,112.45 v1(136.68,113.45) 136.68,114.31 v2(137.11,114.74) 137.11,115.18 137.48,115.55 RP40.4 ; v2(149.32,115.95) 149.32,116.88 149,117.19 QH1.4
SNB_1.05V: length 1.5
  BOTTOM w0.102: PC301.1 138.21,152.51 v1(137.89,152.83)
SNB_VDDCI: length 1.2
  TOP w0.102: PC1212.1 187.75,189.93 v1(187.53,190.15)
SNUB_PCIE: length 1.9
  TOP w0.102: PR1303.2 v1(198.57,68.25)
SPK_L1-_CONN: length 5.4
  TOP w0.508: JSPK.3 v1(64.82,35.92) 63.61,35.92 CA30.1 62.78,35.94 LA5.2
SPK_L2+_CONN: length 5.4
  TOP w0.508: JSPK.4 v1(66.18,36.92) 63.71,36.92 CA29.1 62.72,36.81 LA6.2
SPK_R1-_CONN: length 4.8
  TOP w0.508: LA3.2 63.67,32.89 CA32.1 v1(65.95,32.89) 66.98,33.92 JSPK.1
SPK_R2+_CONN: length 4.9
  TOP w0.508: LA4.2 63.73,33.76 CA31.1 65.59,33.76 v1(66.37,34.55) 66.75,34.92 JSPK.2
SRTCRST#: length 159.8
  TOP w0.089: 128.55,95.95 128.17,96.33 128.17,97.51 128.5,97.84 129.29,97.84 CC3.2 RC5.2 130.56,97.9 130.56,102.98 127.6,105.94 v2(126.53,105.94)
  TOP w0.102: 128.55,95.95 130.74,93.75 143.46,93.75 143.54,93.67 159.09,93.67 v1(171.99,80.77) 172.04,80.72 172.04,72.5 172.2,72.34 172.2,66.26 173.59,64.87 173.59,60.75 172.04,59.21 171.43,59.21 168.74,56.52 166.4,56.52 162.39,52.5 162.39,43.49 163.06,42.81 v2(163.06,41.89)
  BOTTOM w0.076: UC1.AV6 126.83,106.24 v2(126.53,105.94)
  BOTTOM w0.102: ME1.2 114.92,41.17 115.47,41.72 162.9,41.72 v2(163.06,41.89)
SUS_STAT#/LPCPD#: length 26.1
  TOP w0.102: v2(149.19,112.65) 149.19,112.96 v1(149.56,113.32)
  IN3 w0.084: 137.82,114.3 135.4,114.3 134.77,114.93 131.28,114.93 129.44,113.09 129.16,113.09 128.58,112.51 v2(128.58,112.48)
  IN3 w0.127: v2(149.19,112.65) 148.68,113.16 146.35,113.16 145.57,112.38 144.62,112.38 142.7,114.3 137.82,114.3
  BOTTOM w0.076: v2(128.58,112.48) 128.58,112.48 128.33,112.74 UC1.AG4
  BOTTOM w0.102: v2(149.19,112.65) 148.65,113.19 RC29.2
SUSACK#: length 144.8
  TOP w0.102: UE1.97 182.31,51.72 182.62,52.02 v2(182.62,52.46) ; v2(163.1,93.33) v1(162.21,94.22) 161.31,95.12 144.14,95.12 141.86,97.4 135.08,97.4 RC35.2
  IN1 w0.127: v2(149.99,110.86) 150.08,110.86 151.37,109.56 151.37,107.49 151.84,107.02 152.65,107.02 153.7,105.98 153.7,103.94 163.1,94.54 v2(163.1,93.33) 163.1,92.07 167.33,87.83 171.99,87.83 172.63,87.19 174.68,87.19 178.36,83.51 182.38,83.51 188.54,77.35 188.54,67.32 189.58,66.27 189.58,59.24 190.48,58.33 190.48,56.54 191.21,55.81 191.21,52.54 191.65,52.1 191.65,51.77 v2(191.23,51.35)
  IN3 w0.084: v2(133.49,110.66) 134.08,111.24 134.54,111.24 134.93,110.85 135.68,110.85 136.35,110.17 137.92,110.17
  IN3 w0.127: v2(191.23,51.35) 189.58,51.35 188.12,52.8 182.95,52.8 v2(182.62,52.46) ; v2(149.99,110.86) 149.86,110.99 146.79,110.99 146.07,110.27 138.11,110.27 138.01,110.17 137.92,110.17
  BOTTOM w0.089: v2(133.49,110.66) 133.37,110.78 RC37.1
  BOTTOM w0.102: v2(149.99,110.86) 149.86,110.99 RC28.2
SUSACK#_R: length 3.2
  BOTTOM w0.089: RC37.2 132.07,110.92 130.08,110.92 129.64,111.36 UC1.AK2
SUSCLK: length 1.1
  TOP w0.089: T102.1 126.98,113.73 v2(127.3,114.05)
  BOTTOM w0.076: UC1.AE6 126.99,113.75 v2(127.3,114.05)
SUSP: length 230.4
  TOP w0.102: Q2308.2 148.59,122.21 v2(148.42,122.05) ; R10.2 87.34,24.73 88.02,24.06 88.67,24.06 88.87,24.25 Q8.1 88.87,36.58 v4(91.56,39.27) v2(93.31,41.02) ; v2(186.97,65.34) 185.88,64.25 185.88,63.88 185.39,63.39 185.39,59.55 184.47,58.64 182.59,58.64 182.01,59.22 Q2307.2
  IN2 w0.127: v2(148.42,122.05) 148.42,120.43 151.83,117.02 151.83,114.03 152.63,113.23 152.63,111.52 153.67,110.48 153.67,108.14 158.31,103.49 161.74,103.49 162.36,102.87 162.36,102.02 182.54,81.84 182.95,81.84 187.28,77.51 187.28,65.65 v2(186.97,65.34) 188.05,64.26 188.05,57.22 187.16,56.33 187.16,48.06 188.55,46.67 v2(188.55,41.45)
  IN3 w0.127: v2(188.55,41.45) 183.29,41.45 182.85,41.01 93.32,41.01 v2(93.31,41.02)
SUSP#: length 320.7
  TOP w0.102: UE1.116 180.37,44.12 v2(180.11,43.87) ; PR401.2 103.18,20.17 98.77,24.58 94.52,24.58 90.01,20.07 88.17,20.07 87.79,20.45 87.79,21.15 R16.1 87.84,21.96 87.9,22.02 Q8.2 86.56,22.95 81.56,27.94 v4(81.56,41.38) v2(81.56,43.5)
  TOP w0.254: v2(187.14,21.88) R2313.1 185.96,21.02 185.64,20.7 185.64,17.97 185.96,17.66 R2318.1
  IN1 w0.127: v2(187.62,45.07) 187.74,45.19 187.74,49.41 186.96,50.19 186.96,50.74 186.49,51.2 186.49,56.21 186.36,56.33 186.36,59.31 185.84,59.84 185.84,60.18 186.09,60.43 186.61,60.43 186.83,60.64 186.83,64.43 185.01,66.25 185.01,67.84 184.24,68.6 184.24,71.34 184.93,72.02 v2(184.93,73.66)
  IN2 w0.127: v2(187.14,21.88) 187.62,22.37 v2(187.62,45.07)
  IN3 w0.127: v2(187.62,45.07) 187.62,45.06 187.06,44.5 185.46,44.5 184.82,43.87 v2(180.11,43.87) 178.97,43.87 178.38,43.28 81.78,43.28 v2(81.56,43.5) ; v2(151.87,131.88) 152.45,131.3 154.91,131.3 159.74,126.47 159.74,119.79 156.88,116.94 156.88,115.54 159.03,113.4 159.41,113.4 161.2,111.6 161.2,109.25 162.25,108.2 163.46,108.2 166.47,105.19 166.47,101.83 169.32,98.99 173.35,98.99 182.7,89.64 182.7,84.58 187.15,80.13 187.15,75.88 v2(184.93,73.66)
  BOTTOM w0.254: v2(151.87,131.88) 151.65,131.88 149.57,133.96 149.57,138.16 148.1,139.63 148.1,148.65 149.08,149.64 PR300.2
SW_1.35V: length 7
  TOP w1.016: 154.21,18.47 155.8,20.06 155.8,24.51 155.99,24.7
  vias: v1(154.51,13.15) v3(153.83,17.46) v3(154.47,17.46) v3(156.5,25.53) v3(157.13,25.53)
SW_+1.2VSP: length 2.7
  IN1 w0.762: 180.62,172.65 182.21,172.65 182.97,173.41
  vias: v1(175.62,171.67) v2(179.29,173.09) v2(179.29,172.51) v2(183.91,174.23) v2(184.5,174.23) v3(176.05,170.68) v3(176.05,170.04) v3(176.69,170.68) v3(176.69,170.04) v3(177.32,170.68) v3(177.32,170.04) v3(177.96,170.68) v3(177.96,170.04) v3(178.59,170.68) v3(178.59,170.04)
SW_CPU2: length 1.8
  TOP w0.102: v2(106.44,144.82) 105.94,144.82 v1(105.57,145.19)
  TOP w0.508: PC520.1 v2(106.44,144.82)
SW_VGA_CORE: length 31.3
  IN1 w1.016: 205.2,64.5 205.64,64.95 205.64,68.25
  BOTTOM w0.254: PL802.1 210.72,80.46 210.4,80.77 208.04,80.77 206.31,79.05 204.44,79.05 201.2,75.81 201.2,66.06 198.78,63.65 198.78,63.37 PR829.1
  vias: v1(202.63,67.12) v2(204.31,62.87) v2(204.31,62.28) v3(202.28,75.05) v3(202.28,74.28) v3(202.28,73.52) v3(203.04,75.81) v3(203.04,75.05) v3(203.04,74.28) v3(203.04,73.52) v3(203.1,70.92) v3(203.1,70.16) v3(203.1,69.39) v3(203.1,68.63) v3(203.1,67.87) v3(203.74,70.92) v3(203.74,70.16) v3(203.74,69.39) v3(203.74,68.63) v3(203.74,67.87) v3(203.8,76.57) v3(203.8,75.81) v3(203.8,75.05) v3(203.8,74.28) v3(203.8,73.52) v3(204.44,76.57) v3(204.5,70.92) v3(204.5,70.16) v3(204.5,69.39) v3(204.5,68.63) v3(204.5,67.87) v3(204.56,75.81) v3(204.56,75.05) v3(204.56,74.28) v3(204.56,73.52) v3(204.75,77.46) v3(205.51,77.9) v3(205.51,77.14) v3(206.28,77.9) v3(206.28,77.14)
SYS_PWROK: length 273.2
  TOP w0.089: v2(136.3,111.47) 136.28,111.47 134.94,112.8 v1(134.93,112.8) 134.74,112.8 134.19,112.26 CC31.1 133,112.77 133,113.1 132.75,113.35 RP50.1
  TOP w0.102: CE32.1 188.14,57.06 187.77,56.7 187.77,56.15 v2(188.18,55.74) 188.14,55.74 187.76,55.36 187.76,55 187.19,54.43 UE1.86 ; v2(63.34,59.42) 62.64,60.12 62.64,76.25 61.9,76.99 v2(61.9,91.37)
  IN1 w0.084: 137.92,111.45 137.74,111.45 137.65,111.35 136.41,111.35 v2(136.3,111.47)
  IN1 w0.127: 137.92,111.45 138.12,111.45 138.3,111.63 141.5,111.63 142.1,112.23 143.5,112.23 143.85,111.89 147.41,111.89 149.27,110.03 149.27,108.52 151.83,105.95 v2(152.24,105.95)
  IN3 w0.127: v2(114.33,52.55) 114.74,52.13 174.72,52.13 176.4,53.82 178.54,53.82 179.58,54.86 183.56,54.86 184.44,55.74 v2(188.18,55.74)
  BOTTOM w0.102: v2(63.34,59.42) 69.08,53.69 96.1,53.69 97.37,52.42 114.2,52.42 v2(114.33,52.55) 115.4,53.62 115.4,81.84 125.5,91.94 144.9,91.94 151.79,98.83 151.79,105.51 v2(152.24,105.95) ; v2(61.9,91.37) 61.89,91.38 RC52.1
SYS_PWROK_R: length 5.3
  TOP w0.089: v4(129.72,111.71) 129.91,111.9 129.91,112.6 130.66,113.35 RP50.8 131.33,113.35 131.41,113.27 131.41,112.9 v2(131.37,112.86)
  BOTTOM w0.076: v2(131.37,112.86) 130.93,113.29 130.61,113.29 130.47,113.15 130.16,113.15 129.86,112.86 UC1.AG2
SYS_PWROK_XDP: length 7.4
  BOTTOM w0.102: JXDP1.47 61.7,93.64 61.89,93.45 RC52.2 61.89,92.96 61.31,92.38 61.31,91.28 CC16.1 RC64.1 63.63,90.7 v1(63.86,90.46)
SYS_RESET#: length 76.1
  IN1 w0.084: 87.33,112.82 88.35,112.82 88.72,112.46 93.74,112.46 93.94,112.26 96.23,112.26 97.63,113.65 114.27,113.65 114.57,113.96 116.69,113.96 117.12,113.53 119.39,113.53 119.6,113.31 124.52,113.31 125,113.79 125,115.05 125.57,115.62 128.52,115.62 v2(128.66,115.48)
  IN1 w0.127: v2(60.67,106.8) 63.11,106.8 65.38,109.07 69.56,109.07 70.46,109.97 74.01,109.97 75.82,111.78 81.63,111.78 82.67,112.82 87.33,112.82
  BOTTOM w0.089: v2(128.66,115.48) 128.98,115.17 UC1.AC3
  BOTTOM w0.102: v1(58.68,107.08) RC26.2 60.39,107.08 v2(60.67,106.8)
SYSON: length 49.4
  TOP w0.102: v2(166.65,54.66) 165.19,53.2 v4(165.19,34.29) 165.19,32.02 v2(164.22,31.05) ; UE1.95 183.59,54.62 183.59,54.92 183.61,54.94 CE26.1 183.09,55.35 v2(182.64,55.79)
  IN3 w0.127: v2(166.65,54.66) 171.2,54.66 171.53,54.33 177.73,54.33 179.19,55.79 v2(182.64,55.79)
  BOTTOM w0.254: v2(164.22,31.05) 164.22,27.68 163.77,27.23 PR201.1
TDI_IREF: length 5.9
  BOTTOM w0.254: RC133.2 v1(122.27,131.49) 122.27,131.04 122.71,130.6 122.71,127.03 UC1.B12
TDI_XDP: length 21.5
  TOP w0.102: v2(72.81,105.44) v1(73.49,105.44)
  IN1 w0.127: v2(58.84,103.75) 60.17,103.75 60.46,104.05 63.33,104.05 63.79,104.51 64.25,104.51 65.71,105.97 71.43,105.97 71.95,105.44 v2(72.81,105.44)
  BOTTOM w0.102: JXDP1.56 59.7,102.51 58.84,103.37 v2(58.84,103.75) ; v2(72.81,105.44) 73.35,105.44 73.62,105.71 RC44.2 73.63,106.22 RC45.1
TDI_XDP_R: length 23.3
  TOP w0.089: RC63.1 89.64,114.03 89.18,114.49 88.91,114.49
  TOP w0.102: 88.91,114.49 88.72,114.49 87.87,115.34 81.35,115.34 v1(79.14,113.13) v2(77.12,111.11)
  BOTTOM w0.102: v2(77.12,111.11) 76.29,111.11 75.47,110.29 75.47,108.07 75.02,107.62 74.11,107.62 RC45.2 73.58,107.13 73.35,106.9 73.35,106.74 73.11,106.5 72.65,106.5 72.59,106.57 UC4.5
TDO_XDP: length 63.9
  TOP w0.102: v2(72.13,110.48) 72.07,110.53 72.07,116.41 76.63,120.97 79.14,120.97 79.73,121.57 80.83,121.57 81.55,122.29 82.78,122.29 83.3,122.81 84.85,122.81 85.67,123.62 v2(85.93,123.62)
  IN1 w0.114: v2(72.13,110.48) 70.26,110.48 69.36,109.57 65.17,109.57 62.96,107.36 59.82,107.36 v2(59.08,106.62)
  BOTTOM w0.102: RP44.4 86.27,124.21 85.93,123.87 v2(85.93,123.62) ; RC62.1 82.95,114.35 v1(77.05,114.35) 76.51,113.81 75.45,113.81 v2(72.13,110.48) 72.67,109.93 73.7,109.93 74.07,109.57 RC43.2 73.93,108.46 73.63,108.77 73.22,108.77 72.52,108.07 UC4.2 ; JXDP1.52 60.7,102.32 60.4,102.62 60.23,102.62 60.16,102.69 60.16,102.7 59.48,103.38 59.48,104.02 59.31,104.18 59.31,106.39 v2(59.08,106.62)
TESTEN: length 3.9
  TOP w0.102: v1(171.59,116.75) 171.59,117.46 171.96,117.83 v2(171.96,118.25) 171.54,117.84 RV133.2
  BOTTOM w0.102: v2(171.96,118.25) 172.46,117.75 UV1.AD28
THERM_CPU: length 30.3
  TOP w0.102: v2(111.08,146.8) v1(110.04,146.8)
  TOP w0.254: PR512.2 PC509.1 90.26,142.23 v2(89.88,142.61)
  IN3 w0.127: v2(89.88,142.61) 90.96,143.69 90.96,145.82 92.96,147.82 110.74,147.82 111.28,147.28 111.28,147 v2(111.08,146.8)
  BOTTOM w0.203: v2(89.88,142.61) 89.82,142.55 PU501.14
  BOTTOM w0.254: PH502.2 111.08,146.23 v2(111.08,146.8)
THM_ALERT#: length 25.2
  TOP w0.102: v2(174.61,98.36) v1(174.05,98.36)
  IN3 w0.102: v2(170.44,113.63) 170.44,113.17 172.82,110.79 172.82,109.06 173.99,107.89 174.6,107.89 175.01,107.49 175.01,106.87 175.36,106.52 175.36,105.7
  IN3 w0.127: 175.36,105.7 175.36,104.71 174.19,103.54 174.19,98.78 v2(174.61,98.36)
  BOTTOM w0.102: v2(170.44,113.63) 170.44,114.53 170.86,114.95 UV1.AG30 ; v2(174.61,98.36) RV96.1 176.54,98.36 177.25,99.06 UV14.6
TL_BKOFF#: length 7.8
  TOP w0.102: DX1.2 215.87,165.27 215.29,164.7 v2(214.01,164.7)
  BOTTOM w0.102: UX2.4 212.92,164.55 213.07,164.7 v2(214.01,164.7) 214.49,164.21 RX50.2 v4(216.07,164.01)
TL_BKOFF#_R: length 26.1
  TOP w0.102: RX33.1 204.64,179.38 203.79,180.22 v1(203.05,180.22) 202.91,180.08 v2(202.91,177.93) 202.91,177.3 203.72,176.49 UX4.44
  IN3 w0.127: v2(202.91,177.93) 204.24,177.93 208.02,174.15 208.02,170.2 211.17,167.06 v2(211.17,163.88)
  BOTTOM w0.102: UX2.2 211.15,163.9 v2(211.17,163.88)
TL_ENVDD: length 16.1
  TOP w0.102: v1(214.01,171.45) v2(214.72,171.45) 214.98,171.71 RX7.2 ; v2(205.64,167.95) 205.33,167.95 204.97,168.3 204.97,168.64 204.92,168.7 UX4.20
  IN1 w0.127: v2(214.72,171.45) 211.22,167.95 v2(205.64,167.95)
  BOTTOM w0.102: v2(205.64,167.95) 206.9,167.95 RX51.2
TL_INVT_PWM: length 36.9
  TOP w0.102: v2(204.57,168.32) 204.52,168.36 UX4.19
  IN1 w0.127: v2(204.57,168.32) 205.34,169.09 209.96,169.09 214.93,174.06 222.87,174.06 224.33,175.52 228.88,175.52 230.01,176.65 v2(230.01,177.68)
  BOTTOM w0.102: JLVDS.36 v2(230.01,177.68) ; v2(204.57,168.32) 204.48,168.4 204.11,168.4 v1(203.99,168.29) RX26.1 203.99,167.07 204.19,166.87 205.29,166.87 RX49.2
TMDS_L_TX0N: length 17.2
  BOTTOM w0.102: JHDMI.9 8.13,104.8 8.32,104.8 8.47,104.96 8.47,109.96 9.25,110.73 10.82,110.73 11.65,109.91 11.65,106.64 12.28,106.01 v3(13.14,106.01) 13.8,106.01 CX25.1 14.43,106.03 14.57,106.03 14.84,106.31 LX3.2
TMDS_L_TX0P: length 17.3
  BOTTOM w0.102: LX3.3 14.91,105.51 14.6,105.82 14.47,105.82 CX26.1 13.8,105.8 13.51,105.8 13.5,105.79 12.87,105.79 12.86,105.8 12.19,105.8 11.43,106.55 11.43,109.82 10.73,110.52 9.34,110.52 8.69,109.87 8.69,104.87 8.41,104.59 8.22,104.59 JHDMI.7
TMDS_L_TX1N: length 7.4
  BOTTOM w0.102: JHDMI.6 9.71,103.26 10.99,103.26 11.46,102.8 11.46,101.27 11.97,100.76 12.55,100.76 12.56,100.74 12.79,100.74 CX27.1 13.41,100.76 13.55,100.76 13.83,101.04 LX4.2
TMDS_L_TX1P: length 7.4
  BOTTOM w0.102: LX4.3 13.93,100.24 13.62,100.55 13.45,100.55 CX28.1 12.79,100.53 v3(12.14,100.53) 11.9,100.53 11.24,101.18 11.24,102.71 10.9,103.05 9.73,103.05 JHDMI.4
TMDS_L_TX2N: length 9.9
  BOTTOM w0.102: JHDMI.3 8.09,101.84 8.49,101.84 8.69,101.64 8.69,100.8 11.37,98.12 v3(12.94,98.12) 13.72,98.12 CX29.1 14.34,98.06 14.41,98.06 14.65,98.31 LX5.2
TMDS_L_TX2P: length 10
  BOTTOM w0.102: JHDMI.1 8.26,101.63 8.4,101.63 8.47,101.55 8.47,100.71 11.28,97.91 12.67,97.91 12.68,97.89 13.21,97.89 13.22,97.91 13.63,97.91 CX30.1 14.3,97.84 14.38,97.84 14.72,97.51 LX5.3
TMDS_L_TXCN: length 8.6
  BOTTOM w0.102: JHDMI.12 9.69,106.29 10.32,106.29 12.25,104.36 12.26,104.36 12.69,103.93 12.69,103.91 13.26,103.35 v3(13.73,103.35) 14.69,103.35 CX23.1 15.33,103.35 15.51,103.35 15.8,103.64 LX2.2
TMDS_L_TXCP: length 8.6
  BOTTOM w0.102: LX2.3 15.73,102.84 15.43,103.14 15.35,103.14 CX24.1 14.69,103.13 14.16,103.13 14.15,103.12 13.47,103.12 13.45,103.13 13.17,103.13 v3(12.3,104) 10.23,106.07 9.75,106.07 JHDMI.10
TMDS_TX0N: length 4.7
  TOP w0.102: RP59.4 17.08,105.45 17.23,105.31 17.33,105.31 17.43,105.41 17.43,105.64 17.78,106 17.91,106 v2(18.11,106.2)
  BOTTOM w0.102: CX14.1 18.79,106.01 18.3,106.01 v2(18.11,106.2) 17.93,106.01 17.66,106.01 17.37,106.31 LX3.1
TMDS_TX0P: length 4.7
  TOP w0.102: v2(18.11,105.61) 17.95,105.78 17.87,105.78 17.65,105.55 17.65,105.32 17.42,105.09 17.23,105.09 17.08,104.95 RP59.3
  BOTTOM w0.102: LX3.4 17.36,105.51 17.65,105.8 17.93,105.8 v2(18.11,105.61) 18.3,105.8 18.79,105.8 CX15.1
TMDS_TX1N: length 5.1
  TOP w0.102: v2(17.16,100.86) 17.02,100.73 16.93,100.73 16.84,100.73 16.84,100.72 16.77,100.72 15.89,99.85 15.71,99.85 15.57,99.99 RP58.4
  BOTTOM w0.102: CX16.1 17.84,100.68 17.34,100.68 v2(17.16,100.86) 17.04,100.74 16.81,100.74 16.52,101.04 LX4.1
TMDS_TX1P: length 5.2
  TOP w0.102: RP58.3 15.51,99.49 15.65,99.63 15.98,99.63 16.86,100.51 16.93,100.51 v2(17.16,100.28)
  BOTTOM w0.102: LX4.4 16.52,100.24 16.81,100.53 16.91,100.53 v2(17.16,100.28) 17.34,100.46 17.84,100.46 CX17.1
TMDS_TX2N: length 6
  TOP w0.102: RP58.2 15.51,98.99 15.65,98.85 16.02,98.85 16.84,98.03 17.89,98.03 v2(18.05,98.2)
  BOTTOM w0.102: CX18.1 18.73,98.01 18.24,98.01 v2(18.05,98.2) 17.87,98.01 17.7,98.01 17.41,98.31 LX5.1
TMDS_TX2P: length 6
  TOP w0.102: RP58.1 15.51,98.49 15.65,98.63 15.93,98.63 16.75,97.82 17.85,97.82 v2(18.05,97.61)
  BOTTOM w0.102: LX5.4 17.41,97.51 17.7,97.8 17.87,97.8 18.05,97.61 v2(18.05,97.61) 18.24,97.8 18.73,97.8 CX19.1
TMDS_TXCN: length 5.8
  TOP w0.102: v2(19.03,103.53) 18.86,103.37 18.16,103.37 17.94,103.6 17.94,104.05 17.68,104.31 17.23,104.31 17.08,104.45 RP59.2
  BOTTOM w0.102: LX2.1 18.08,103.39 18.89,103.39 v2(19.03,103.53) 19.21,103.35 19.68,103.35 CX12.1
TMDS_TXCP: length 5.9
  TOP w0.102: v2(19.03,102.95) 18.82,103.15 18.07,103.15 17.72,103.51 17.72,103.96 17.59,104.09 17.23,104.09 17.08,103.95 RP59.1
  BOTTOM w0.102: CX13.1 19.68,103.13 19.21,103.13 v2(19.03,102.95) 19,102.95 18.78,103.18 18.17,103.18 LX2.4
TMS_XDP: length 19.7
  TOP w0.102: v2(67.83,106.57) 67.83,106.49 68.25,106.07 68.65,106.07 69.83,107.25 v1(69.83,107.47)
  IN1 w0.114: v2(58.26,103.76) 58.79,104.29 63.23,104.29 63.69,104.76 64.15,104.76 65.96,106.57 v2(67.83,106.57)
  BOTTOM w0.102: RC46.2 67.05,106.57 v2(67.83,106.57) 68.34,106.07 UC4.9 ; JXDP1.58 59.2,102.49 58.26,103.43 v2(58.26,103.76)
TON_1.35V: length 3.5
  BOTTOM w0.102: v1(162.55,24.53) 162,25.07 PR208.2
  BOTTOM w0.203: 161.01,26.1 160.67,26.44 PU200.9
  BOTTOM w0.254: 161.01,26.1 161.66,25.45 PR208.2
TOUCH_PANEL_INTR#: length 18.2
  IN1 w0.084: 137.92,122.35 137.5,122.35 135.69,120.54 v2(132.88,120.54)
  IN1 w0.127: v2(142.59,121.96) 142.2,122.35 137.92,122.35
  BOTTOM w0.076: v2(132.88,120.54) 132.5,120.15 131.95,120.15 131.69,119.89 130.16,119.89 129.99,119.72 129.99,119.55 129.75,119.31 129.23,119.31 UC1.P3
  BOTTOM w0.102: v2(142.59,121.96) 142.19,121.96 141.45,122.7 141.45,122.73 141.44,122.73 141.44,123.69 141.58,123.83 RP43.7
TOUCH_RST_N_GYRO_INT1: length 6.9
  BOTTOM w0.089: RC76.2 134.99,121.69 134.99,122.52 134.65,122.86 134,122.86 133.74,122.6 132.71,122.6 132.16,122.05 131.82,122.05 130.87,121.1 UC1.L1
TOUCHPAD_INTR#: length 1.7
  TOP w0.089: RC74.2 125.54,119.13 v2(125.83,118.84)
  BOTTOM w0.089: UC1.U7 126.29,118.38 v2(125.83,118.84)
TP_CLK: length 190.3
  TOP w0.102: v2(187.1,59.17) 187.19,59.08 v1(187.19,58.63) 187.51,58.31 187.51,55.83 187.04,55.36 RE9.2 186.79,55.03 UE1.87 ; JTP.2 59.3,109.9 60.42,108.78 v2(62.51,108.78)
  IN3 w0.127: v2(62.51,108.78) 63.19,108.1 63.19,101.52 64.61,100.1 64.61,98.95 63.64,97.98 63.64,94.36 62.78,93.5 62.78,81.35 69.08,75.05 69.08,58.1 73.45,53.72 105.14,53.72 106.46,55.04 138.81,55.04 139.51,54.33 143.03,54.33 143.04,54.32 146.95,54.32 147.82,55.2 171.03,55.2 171.64,54.59 177.62,54.59 179.18,56.15 181.02,56.15 182.02,57.15 183.25,57.15 185.26,59.17 v2(187.1,59.17)
TP_DATA: length 190.2
  TOP w0.102: v2(62.51,109.41) 61.56,109.41 60.3,110.68 JTP.3 ; v2(187.1,59.75) 186.93,59.75 185.58,58.39 v1(185.58,57.94) 185.58,55.87 186.15,55.3 RE10.2 186.39,55.05 UE1.88
  IN3 w0.127: v2(187.1,59.75) 186.87,59.52 185.26,59.52 183.14,57.41 181.89,57.41 180.9,56.41 179.07,56.41 177.51,54.86 171.74,54.86 171.14,55.46 147.72,55.46 146.84,54.58 143.14,54.58 143.14,54.59 139.62,54.59 138.91,55.29 106.35,55.29 105.04,53.98 73.57,53.98 69.34,58.2 69.34,75.16 63.04,81.46 63.04,93.39 63.9,94.25 63.9,97.87 64.87,98.84 64.87,100.2 63.44,101.63 63.44,108.48 v2(62.51,109.41)
TP_DC_TEST_B2: length 5.5
  BOTTOM w0.102: UC1.B2 131.31,128.6 132.78,128.6 T167.1
TRIP_+1.2VSP: length 2.7
  TOP w0.102: v1(189.37,173.17) 189.39,173.17 189.13,173.42 v2(189.13,173.71)
  TOP w0.254: PU1100.2 189.05,173.8 v2(189.13,173.71)
  BOTTOM w0.254: v2(189.13,173.71) 188.57,173.15 PR1102.2
TRST#_XDP: length 16.4
  IN1 w0.114: v2(67.83,107.41) 67.24,106.81 65.86,106.81 64.05,105 63.59,105 63.13,104.54 59.26,104.54 v2(58.89,104.9)
  BOTTOM w0.102: v2(67.83,107.41) 67.99,107.57 UC4.12 ; JXDP1.54 60.2,102.33 59.93,102.6 59.93,102.6 59.25,103.28 59.25,103.92 58.89,104.28 v1(58.89,104.38) v2(58.89,104.9)
TS_FDO: length 14.3
  TOP w0.102: v2(174.91,104.88) v1(174.91,104.13)
  IN3 w0.102: v2(169.7,113.58) 169.7,113.44 171.87,111.27 171.87,110.28 172.62,109.53 172.62,108.97 173.9,107.69 174.52,107.69 174.8,107.4 174.8,106.79 174.91,106.69 174.91,105.7
  IN3 w0.127: v2(174.91,104.88) 174.91,105.7
  BOTTOM w0.102: RV235.2 RV236.1 v2(174.91,104.88) ; v2(169.7,113.58) 169.26,113.15 UV1.AK32
UG_3V: length 8.7
  TOP w0.102: v2(216.44,14.75) v1(217.02,14.75)
  IN1 w0.762: 215.74,14.42 211.88,14.42 210.42,15.88 210.42,16.67 209.44,17.66
  vias: v2(216.44,14.16) v3(208.52,18.81) v3(208.9,18.28)
UG_5V: length 13.5
  TOP w0.102: v2(219.87,27.26) v1(219.87,28.09)
  IN1 w0.762: 208.55,22.99 208.55,23.62 211.15,26.23 216.14,26.23 216.9,26.99 219.17,26.99
  vias: v2(219.87,26.67) v3(208.52,22.23) v3(208.52,21.59)
UG_+1.2VSP: length 7.3
  TOP w0.102: v2(178.02,174.23) v1(178.87,174.23)
  IN1 w0.762: 178.02,172.84 178.02,172.52 178.84,171.69 182.85,171.69 183.54,172.39
  vias: v2(178.02,173.65) v2(184.04,173.34) v2(184.55,173.64)
UG_VGA_CORE:
  vias: v1(203.97,64.65) v2(203.67,62.73) v2(203.67,62.14) v2(203.8,65.2) v2(204.05,72.32) v2(204.38,65.2) v2(204.64,72.32)
USB3RN1_JUSB2: length 156.7
  IN1 w0.084: v2(118.68,123.98) 118.77,123.89 119.09,123.89 119.28,123.69 119.28,122.92 119.22,122.86 119.22,121.73 118.55,121.06 116.04,121.06 115.7,120.72 115.7,115.49 114.97,114.76 97.06,114.76 96.43,114.13 95.61,114.13 94.97,113.5 94.34,113.5 94.08,113.24 92.57,113.24 91.95,113.87 90.09,113.87 89.15,114.81 88.95,114.81 88.93,114.79 88.91,114.79
  IN1 w0.127: 88.91,114.79 77.53,114.79 76.5,113.75 74.61,113.75 74.31,113.45 72.33,113.45 70.65,111.77 58.58,111.77 39.8,92.99 39.8,83.94 40.41,83.33 40.41,78.62 39.14,77.35 35.02,77.35 25.45,67.78 25.45,54.64 26.89,53.21 26.89,50.09 25.21,48.41 23.78,48.41 v2(23.64,48.27)
  BOTTOM w0.076: UC1.G20 119.01,123.65 v2(118.68,123.98)
  BOTTOM w0.102: v2(23.64,48.27) 23.54,48.38 23.08,48.38 22.87,48.17 LI4.1
USB3RN1_JUSB2_R: length 12.8
  BOTTOM w0.102: 14.55,48.01 14.12,47.59 13.83,47.3 13.83,46.9 12.49,45.56 12.25,45.56 11.57,44.88 11.33,44.88 10.87,44.42 JUSB2.5 ; 14.55,48.01 v3(14.55,48.01) ; 14.55,48.01 15.23,48.69 15.27,48.69 15.59,49.01 16.87,49.01 17.11,48.77 DI4.1 DI4.10 19.09,48.77 19.24,48.92 19.4,48.92 19.84,48.48 19.99,48.48 20.3,48.17 LI4.2
USB3RN2_JUSB1: length 144.3
  IN1 w0.084: v2(119.6,124.62) 119.6,124.46 119.71,124.35 119.91,124.35 120.01,124.45 120.01,125.42 119.7,125.73 117.13,125.73 116.81,125.41 116.81,123 115.07,121.26 115.07,115.97 114.36,115.27 96.68,115.27 96.31,114.89 92.06,114.89 91.33,115.62 88.95,115.62 88.93,115.6 88.91,115.6
  IN1 w0.127: v2(22.37,61.53) 22.56,61.72 22.96,61.72 23.4,62.16 23.4,69.22 28.03,73.85 29.94,73.85 35.46,79.38 35.46,88.14 38.45,91.13 38.45,94.29 56.71,112.55 70.29,112.55 72.64,114.91 76.19,114.91 76.88,115.6 88.91,115.6
  BOTTOM w0.089: UC1.E18 120.06,124.77 119.91,124.62 v2(119.6,124.62)
  BOTTOM w0.102: v2(22.37,61.53) 22.09,61.81 21.83,61.81 21.52,61.5 LI1.1
USB3RN2_JUSB1_R: length 10.3
  BOTTOM w0.102: LI1.2 19.1,61.5 18.68,61.92 DI1.10 DI1.1 16.22,61.92 16.11,62.03 v3(15.55,62.03) 14.95,62.03 14.35,62.63 14.33,62.63 13.95,63.01 13.95,63.03 13.71,63.27 12.37,63.27 11.57,62.47 11.4,62.47 10.87,61.95 JUSB1.5
USB3RP1_JUSB2: length 156.4
  IN1 w0.084: v2(118.71,123.33) 118.71,123.49 118.87,123.66 118.99,123.66 119.08,123.57 119.08,123.01 119.03,122.95 119.03,121.86 118.46,121.29 115.94,121.29 115.47,120.82 115.47,115.58 114.87,114.99 96.97,114.99 96.34,114.36 95.51,114.36 94.88,113.72 94.24,113.72 93.99,113.47 92.67,113.47 92.04,114.1 90.18,114.1 89.22,115.06 88.91,115.06
  IN1 w0.127: 88.91,115.06 77.42,115.06 76.38,114.02 74.5,114.02 74.19,113.72 72.21,113.72 70.54,112.04 58.46,112.04 39.53,93.1 39.53,83.83 40.14,83.21 40.14,78.73 39.03,77.62 34.9,77.62 25.18,67.9 25.18,54.53 26.62,53.09 26.62,50.2 25.1,48.69 23.81,48.69 v2(23.64,48.86)
  BOTTOM w0.076: UC1.H20 119.1,123.1 118.87,123.33 v2(118.71,123.33)
  BOTTOM w0.102: v2(23.64,48.86) 23.37,48.59 23.24,48.59 22.87,48.97 LI4.4
USB3RP1_JUSB2_R: length 12.7
  BOTTOM w0.102: LI4.3 20.3,48.97 20.03,48.69 19.93,48.69 19.49,49.14 19.18,49.14 19.04,49.27 DI4.9 DI4.2 17.18,49.27 17.14,49.23 15.47,49.23 v3(15.31,49.06) 15.3,49.06 14.6,48.36 14.56,48.36 14.19,48 14.19,47.96 13.6,47.37 13.6,46.97 12.4,45.77 12.16,45.77 11.48,45.1 11.37,45.1 10.87,45.6 JUSB2.6
USB3RP2_JUSB1: length 144.5
  IN1 w0.084: v2(119.66,123.98) 119.8,124.12 120.01,124.12 120.24,124.35 120.24,125.52 119.79,125.96 117.03,125.96 116.58,125.5 116.58,123.1 114.84,121.36 114.84,116.07 114.27,115.5 96.59,115.5 96.21,115.12 92.15,115.12 91.42,115.85 88.96,115.85 88.94,115.87 88.91,115.87
  IN1 w0.127: 88.91,115.87 76.77,115.87 76.08,115.18 72.53,115.18 70.17,112.82 56.59,112.82 38.17,94.4 38.17,91.24 35.19,88.25 35.19,79.49 29.82,74.12 27.91,74.12 23.13,69.34 23.13,62.27 22.85,61.99 22.49,61.99 v2(22.37,62.11)
  BOTTOM w0.089: v2(119.66,123.98) 119.98,124.3 UC1.F18
  BOTTOM w0.102: LI1.4 21.54,62.3 21.81,62.03 22.29,62.03 v2(22.37,62.11)
USB3RP2_JUSB1_R: length 10
  BOTTOM w0.102: LI1.3 19.1,62.3 18.95,62.15 18.63,62.15 18.36,62.42 DI1.9 DI1.2 16.29,62.42 16.12,62.24 15.83,62.24 15.82,62.26 15.03,62.26 v3(14.3,62.98) 13.8,63.49 12.28,63.49 11.9,63.11 11.11,63.11 10.87,63.35 JUSB1.6
USB3TN1_JUSB2: length 157.3
  IN1 w0.084: 88.91,127.18 89.11,127.18 89.12,127.17 106.52,127.17 108.45,129.11 109.85,129.11 111.1,130.35 111.27,130.35 v2(111.41,130.21)
  IN1 w0.127: 88.91,127.18 87.81,127.18 85.7,125.07 85.7,124.83 84.54,123.67 82.12,123.67 80.62,122.17 75.09,122.17 68.85,115.93 48.39,115.93 44.21,111.74 42.87,111.74 34.57,103.45 34.57,91.78 33.29,90.5 33.29,79.41 29.29,75.41 27.38,75.41 20.85,68.89 20.85,58.01 26,52.86 26,50.49 25.73,50.22 25.46,50.22 v2(25.29,50.05)
  BOTTOM w0.076: v2(111.41,130.21) 111.22,130.4 110.9,130.4 110.26,129.76 110.26,126.74 110.28,126.72 110.28,126.47 110.21,126.4 110.21,126.29 110.29,126.21 110.49,126.21 UC1.C33
  BOTTOM w0.102: CI10.2 24.94,50.22 25.12,50.22 v2(25.29,50.05)
USB3TN1_JUSB2_C: length 1.6
  BOTTOM w0.102: LI6.1 22.93,49.94 23.23,50.24 23.35,50.24 CI10.1
USB3TN1_JUSB2_R: length 10.9
  BOTTOM w0.102: LI6.2 20.24,49.94 19.95,50.24 19.69,50.24 19.51,50.41 19.35,50.41 19.21,50.27 DI4.7 DI4.4 17.09,50.27 16.98,50.38 16.64,50.38 16.63,50.37 16.08,50.37 15.96,50.24 v3(14.46,50.24) 12.21,50.24 11.6,50.85 11.4,50.85 10.87,50.33 JUSB2.8
USB3TN2_JUSB1: length 143.2
  IN1 w0.084: 88.91,126.17 89.62,126.17 89.93,126.48 106.71,126.48 108.89,128.66 111.19,128.66 111.43,128.42 v2(111.43,128.31)
  IN1 w0.127: v2(23.47,60.89) 23.71,60.65 23.71,60.46 23.49,60.24 22.62,60.24 21.63,61.23 21.63,68.56 27.7,74.63 29.61,74.63 34.06,79.08 34.06,90.17 36.41,92.52 36.41,104.19 43.08,110.86 44.59,110.86 48.87,115.14 69.21,115.14 75.09,121.02 80.8,121.02 82.2,122.42 83.35,122.42 83.68,122.75 86.07,122.75 86.66,123.34 86.66,124.92 87.91,126.17 88.91,126.17
  BOTTOM w0.076: v2(111.43,128.31) 111.43,128.49 111.33,128.59 111.12,128.59 110.84,128.31 110.84,127.45 110.51,127.12 110.51,126.96 UC1.B33
  BOTTOM w0.102: CI3.2 23.66,61.51 23.77,61.41 23.77,61.19 v2(23.47,60.89)
USB3TN2_JUSB1_C: length 3.7
  BOTTOM w0.102: CI3.1 23.65,62.74 23.65,63.25 23.2,63.7 v3(22.6,63.7) 22.15,63.7 21.85,63.41 LI3.1
USB3TN2_JUSB1_R: length 13
  BOTTOM w0.102: LI3.2 19.16,63.41 18.85,63.72 18.72,63.72 18.6,63.59 18.42,63.59 18.25,63.42 DI1.7 DI1.4 16.35,63.42 16.18,63.59 v3(15.5,63.59) 15.05,63.59 14.23,64.41 14.23,65.32 14.2,65.34 14.2,65.89 14.23,65.92 14.23,66.66 12.89,68 12.03,68 11.59,68.44 11.27,68.44 10.87,68.04 JUSB1.8
USB3TP1_JUSB2: length 156.9
  IN1 w0.084: 88.91,127.45 88.93,127.45 88.95,127.43 89.01,127.43 89.03,127.41 89.21,127.41 89.21,127.4 106.42,127.4 108.36,129.34 109.76,129.34 111,130.58 111.21,130.58 v2(111.41,130.79)
  IN1 w0.127: 88.91,127.45 87.7,127.45 85.43,125.18 85.43,124.94 84.43,123.94 82,123.94 80.51,122.44 74.98,122.44 68.74,116.2 48.28,116.2 44.09,112.02 42.76,112.02 34.3,103.56 34.3,91.9 33.01,90.61 33.01,79.52 29.18,75.68 27.27,75.68 20.58,69 20.58,57.9 25.73,52.75 25.73,50.6 25.61,50.49 25.43,50.49 v2(25.29,50.63)
  BOTTOM w0.076: v2(111.41,130.79) 111.22,130.59 110.82,130.59 110.07,129.84 110.07,126.68 UC1.B34
  BOTTOM w0.102: CI11.2 24.97,50.44 25.1,50.44 25.16,50.49 v2(25.29,50.63)
USB3TP1_JUSB2_C: length 1.6
  BOTTOM w0.102: LI6.4 22.93,50.74 23.23,50.45 23.37,50.45 CI11.1
USB3TP1_JUSB2_R: length 11
  BOTTOM w0.102: JUSB2.9 10.87,51.72 11.52,51.07 11.69,51.07 12.3,50.46 14.16,50.46 14.19,50.49 14.76,50.49 14.79,50.46 15.87,50.46 16.01,50.6 v3(16.36,50.6) 16.98,50.6 17.16,50.77 DI4.5 DI4.6 19.21,50.77 19.35,50.63 19.6,50.63 19.78,50.45 19.95,50.45 20.24,50.74 LI6.3
USB3TP2_JUSB1: length 143.3
  IN1 w0.084: 88.91,126.44 88.93,126.44 88.95,126.42 89.02,126.42 89.04,126.4 89.53,126.4 89.84,126.71 106.61,126.71 108.8,128.89 111.38,128.89 111.43,128.94 v2(111.43,128.94)
  IN1 w0.127: v2(24.05,60.89) 23.98,60.82 23.98,60.35 23.6,59.97 22.51,59.97 21.36,61.11 21.36,68.67 27.59,74.9 29.5,74.9 33.79,79.2 33.79,90.29 36.14,92.63 36.14,104.3 42.97,111.13 44.48,111.13 48.76,115.41 69.09,115.41 74.97,121.29 80.69,121.29 82.09,122.69 83.24,122.69 83.57,123.03 85.96,123.03 86.38,123.45 86.38,125.03 87.8,126.44 88.91,126.44
  BOTTOM w0.076: UC1.A33 110.65,127.67 110.65,128.39 111.04,128.78 111.27,128.78 v2(111.43,128.94)
  BOTTOM w0.102: CI4.2 23.98,61.27 23.98,60.96 v2(24.05,60.89)
USB3TP2_JUSB1_C: length 4
  BOTTOM w0.102: LI3.4 21.85,64.21 22.15,63.91 22.32,63.91 22.33,63.93 22.86,63.93 22.88,63.91 23.29,63.91 23.87,63.34 23.87,62.78 CI4.1
USB3TP2_JUSB1_R: length 12.9
  BOTTOM w0.102: LI3.3 19.16,64.21 18.89,63.93 18.63,63.93 18.51,63.81 18.36,63.81 18.25,63.92 DI1.6 DI1.5 16.28,63.92 16.17,63.81 15.78,63.81 15.76,63.82 15.23,63.82 15.22,63.81 15.14,63.81 14.44,64.5 v3(14.44,65.64) 14.44,66.75 12.98,68.21 12.12,68.21 11.68,68.66 11.43,68.66 10.87,69.22 JUSB1.9
USB20_CAM_N7: length 169.7
  TOP w0.102: v2(217.52,165.83) 217.7,165.64 218.91,165.64 219.31,166.05 219.31,166.21 219.02,166.51 LX6.1 219.02,167.06 RX21.1
  IN1 w0.127: v2(217.52,165.83) 217.35,165.66 216.69,165.66 216.25,165.22 216.25,162.51 212.76,159.02 165.96,159.02 165.35,158.42 157.46,158.42 155.46,156.42 155.46,154.94 158.87,151.53 158.87,141.89 152.84,135.87 138.88,135.87 137.6,134.59 129.21,134.59 128.11,135.69 117.82,135.69 117.14,135 117.14,134.69 v2(116.97,134.53)
  IN3 w0.084: v2(123.1,108.52) 123.1,108.64 122.76,108.98 122.58,108.98 122.46,108.86 122.46,107.92 122.9,107.49 123.64,107.49 124.06,107.91 124.06,111.66 124.61,112.21 124.61,112.68 124.28,113.02 123.41,113.02 122.88,113.55 122.88,117.15 121.14,118.89 120.93,118.89 119.03,120.8 119.03,120.81 118.82,121.02 117.96,121.02 117.42,121.56 117.42,122.41 116.87,122.96 116.87,124.13 115.85,125.15 115.85,128.51 116.68,129.34 116.68,132.21 117.15,132.68 117.15,133.02 117.15,133.02 117.15,133.09 117.12,133.11 117.12,133.12
  IN3 w0.127: 117.12,133.12 117.12,134.37 v2(116.97,134.53)
  BOTTOM w0.076: UC1.AR13 122.57,108.33 122.57,108.46 122.67,108.55 123.06,108.55 v2(123.1,108.52)
USB20_CAM_N7_R: length 14.8
  TOP w0.102: v2(226.9,173.27) 226.75,173.11 223.59,173.11 221.96,171.49 221.96,170.74 221.05,169.83 219.7,169.83 219.31,169.44 219.31,169.1 219.02,168.81 LX6.2 219.02,168.07 RX21.2
  BOTTOM w0.102: JLVDS.28 226.01,174.99 225.9,174.88 225.9,173.28 226.09,173.09 226.72,173.09 v2(226.9,173.27)
USB20_CAM_P7: length 170
  TOP w0.102: RX22.1 219.82,167.06 LX6.4 219.82,166.48 219.53,166.19 219.53,165.96 219,165.43 217.7,165.43 v2(217.52,165.24)
  IN1 w0.127: v2(217.52,165.24) 217.37,165.39 216.8,165.39 216.52,165.1 216.52,162.4 212.87,158.75 166.07,158.75 165.47,158.15 157.57,158.15 155.73,156.31 155.73,155.06 159.14,151.65 159.14,141.78 152.95,135.59 138.99,135.59 137.71,134.32 129.09,134.32 127.99,135.42 117.93,135.42 117.41,134.89 117.41,134.67 v2(117.55,134.53)
  IN3 w0.084: v2(123.1,109.17) 122.47,109.17 122.25,108.95 122.25,107.83 122.81,107.27 123.73,107.27 124.27,107.82 124.27,111.57 124.81,112.1 124.81,112.79 124.37,113.23 123.5,113.23 123.09,113.64 123.09,117.23 121.22,119.1 121.02,119.1 119.24,120.89 119.24,120.9 118.91,121.23 118.05,121.23 117.63,121.64 117.63,122.5 117.08,123.05 117.08,124.22 116.06,125.23 116.06,128.43 116.89,129.25 116.89,132.13 117.36,132.6 117.36,133.09 117.38,133.11 117.38,133.12
  IN3 w0.127: v2(117.55,134.53) 117.38,134.36 117.38,133.12
  BOTTOM w0.076: v2(123.1,109.17) 122.77,108.84 UC1.AP13
USB20_CAM_P7_R: length 14.9
  TOP w0.102: RX22.2 219.82,168.07 LX6.3 219.82,168.89 219.53,169.19 219.53,169.35 219.79,169.61 221.14,169.61 222.18,170.65 222.18,171.4 223.68,172.9 226.69,172.9 v2(226.9,172.69)
  BOTTOM w0.102: v2(226.9,172.69) 226.72,172.87 226,172.87 225.68,173.19 225.68,174.93 225.51,175.1 JLVDS.27
USB20_CR_N6: length 133.4
  IN1 w0.084: v2(123.57,108.19) 123.63,108.26 123.85,108.26 123.93,108.18 123.93,105.41 126.76,102.58 131.33,102.58 131.47,102.43 131.54,102.43 131.56,102.41 131.57,102.41
  IN1 w0.127: 131.57,102.41 133.36,102.41 136.75,99.03 140.72,99.03 148.96,90.79 150.52,90.79 161.4,79.92 172.42,79.92 177.92,74.42 177.92,66.79 180.01,64.7 180.01,64.2 181.7,62.51 181.7,60.07 181.9,59.87 181.9,51.39 182.58,50.71 182.58,44.75 186.07,41.26 186.07,40.24 185.17,39.34 185.17,38.76 184.46,38.06 178.86,38.06 177.78,39.14 176.74,39.14 v2(176.5,39.38)
  BOTTOM w0.076: UC1.AP11 123.83,108.52 123.57,108.26 v2(123.57,108.19)
  BOTTOM w0.102: v2(176.5,39.38) 176.2,39.08 175.82,39.08 174.95,38.2 174.95,28.29 174.8,28.14 174.48,28.14 174.34,28.29 174.34,28.58 174.19,28.72 LR2.1
USB20_CR_N6_R: length 18.2
  TOP w0.102: UR1.2 176.32,22.24 176.51,22.05 176.51,20.27 175.67,19.43 172.81,19.43 172.24,20.01 172.24,24.39 171.54,25.09 171.54,27.9 171.31,28.13 171.02,28.13 v2(170.65,28.5)
  BOTTOM w0.102: v2(170.65,28.5) 170.83,28.32 171.23,28.32 171.63,28.72 LR2.2
USB20_CR_P6: length 133.6
  IN1 w0.084: 131.57,102.68 131.56,102.68 131.44,102.8 126.86,102.8 124.16,105.5 124.16,108.28 123.66,108.77 v2(123.66,108.84)
  IN1 w0.127: 131.57,102.68 133.48,102.68 136.86,99.3 140.84,99.3 149.07,91.07 150.63,91.07 161.51,80.19 172.54,80.19 178.19,74.54 178.19,66.9 180.28,64.81 180.28,64.31 181.97,62.62 181.97,60.18 182.17,59.98 182.17,51.5 182.85,50.82 182.85,44.87 186.34,41.38 186.34,40.13 185.44,39.23 185.44,38.65 184.57,37.79 178.74,37.79 177.66,38.86 176.57,38.86 v2(176.5,38.79)
  BOTTOM w0.076: UC1.AN11 123.73,108.84 v2(123.66,108.84)
  BOTTOM w0.102: v2(176.5,38.79) 176.42,38.86 175.91,38.86 175.16,38.11 175.16,28.2 174.89,27.92 LR2.4
USB20_CR_P6_R: length 18.3
  TOP w0.102: v2(170.65,27.92) 171.22,27.92 171.33,27.81 171.33,25 172.03,24.3 172.03,19.92 172.72,19.22 175.76,19.22 176.72,20.18 176.72,22.12 176.82,22.22 UR1.3
  BOTTOM w0.102: LR2.3 171.56,27.92 171.38,28.11 170.85,28.11 v2(170.65,27.92)
USB20_JUSB1_N1: length 260.5
  IN1 w0.084: 136.32,106.15 136.29,106.15 136.1,106.34 134.32,106.34 133.18,107.48 129.98,107.48 128.83,106.34 127.72,106.34 127.5,106.55 127.5,107.59 127.35,107.74 127.35,108.07 126.93,108.48 v2(126.93,108.47)
  IN1 w0.127: v2(186.31,62.05) 186.21,61.95 186.2,61.96 185.96,61.96 185.82,62.09 185.82,64.3 183.4,66.72 183.4,76.87 179.1,81.18 177.32,81.18 174.45,84.05 163.7,84.05 151.29,96.46 148.26,96.46 142.09,102.63 140.01,102.63 136.49,106.15 136.32,106.15
  BOTTOM w0.076: UC1.AR7 126.65,108.19 126.93,108.48 v2(126.93,108.47)
  BOTTOM w0.102: v2(186.31,62.05) 186.13,61.86 184.87,61.86 184.62,62.11 164.75,62.11 159.6,56.96 135.03,56.96 129,50.93 38.76,50.93 28.79,60.9 25.31,60.9 24.45,60.03 24.05,60.03 23.76,60.33 LI2.1
USB20_JUSB1_N1_R: length 16.1
  IN3 w0.127: v2(18.26,59.29) 18.09,59.12 16.91,59.12 14.95,61.08 14.95,64.7 13.94,65.71 13.26,65.71 JUSB1.2
  BOTTOM w0.102: v2(18.26,59.29) 18.98,60.01 DI2.2 19.96,60.01 20.03,59.93 20.03,59.36 20.09,59.3 20.3,59.3 20.51,59.51 20.51,59.72 20.76,59.96 20.88,59.96 21.25,60.33 LI2.2
USB20_JUSB1_P1: length 260.2
  IN1 w0.084: v2(126.93,107.82) 126.94,107.82 127.27,107.49 127.27,106.46 127.62,106.11 128.92,106.11 130.07,107.25 133.08,107.25 134.23,106.11 136.01,106.11 136.22,105.9 136.29,105.9 136.31,105.88 136.32,105.88
  IN1 w0.127: 136.32,105.88 136.38,105.88 139.9,102.36 141.98,102.36 148.15,96.19 151.18,96.19 163.59,83.78 174.33,83.78 177.21,80.91 178.99,80.91 183.13,76.76 183.13,66.6 185.55,64.19 185.55,61.98 185.84,61.69 186.09,61.69 v2(186.31,61.46)
  BOTTOM w0.076: v2(126.93,107.82) 126.66,107.54 UC1.AT7
  BOTTOM w0.102: v2(186.31,61.46) 186.13,61.65 184.78,61.65 184.53,61.89 164.84,61.89 159.69,56.75 135.12,56.75 129.09,50.71 38.67,50.71 28.7,60.68 25.4,60.68 24.54,59.82 24.05,59.82 23.76,59.53 LI2.4
USB20_JUSB1_P1_R: length 16.2
  IN3 w0.127: v2(18.26,58.71) 18.1,58.87 16.8,58.87 14.7,60.97 14.7,64.59 13.83,65.46 13.11,65.46 12.37,64.72 JUSB1.3
  BOTTOM w0.102: LI2.3 21.33,59.53 21.11,59.74 20.85,59.74 20.73,59.63 20.73,59.42 20.09,58.79 20.09,58.22 19.96,58.08 DI2.3 18.89,58.08 v2(18.26,58.71)
USB20_JUSB2_N0: length 272.2
  IN1 w0.084: v2(125.58,109.46) 125.58,109.62 125.82,109.87 126.03,109.87 126.36,109.54 126.36,107.56 126.92,107 126.92,106.08 127.29,105.72 129.45,105.72 130.48,106.75 131.52,106.75 132.1,106.16 133.44,106.16 133.96,105.64 135.53,105.64 136.57,104.6 136.57,104.57 136.62,104.52 136.62,104.49 136.63,104.48
  IN1 w0.127: 136.63,104.48 139.55,101.56 141.65,101.56 148.13,95.07 150.78,95.07 162.98,82.88 174.1,82.88 177.06,79.92 178.76,79.92 181.9,76.77 181.9,66.73 184.77,63.86 184.77,61.03 185.03,60.77 185.03,59.48 185.46,59.05 185.46,55.99 185.71,55.74 185.71,51.09 185.53,50.91 185.53,48.19 186.72,47 186.72,45.79 186.58,45.65 186.39,45.65 v2(186.23,45.8)
  BOTTOM w0.089: v2(125.58,109.46) 125.68,109.46 UC1.AN8
  BOTTOM w0.102: v2(186.23,45.8) 185.87,45.44 185.56,45.44 185.29,45.16 136.99,45.16 135.25,46.9 52.19,46.9 51.32,46.03 23.77,46.03 23.59,46.22 23.59,46.47 23.44,46.62 LI5.1
USB20_JUSB2_N0_R: length 11.2
  IN3 w0.127: JUSB2.2 13.19,48.19 14.82,48.19 16.61,46.4 17.6,46.4 v2(17.77,46.57)
  BOTTOM w0.102: LI5.2 20.62,46.62 20.33,46.32 19.74,46.32 19.68,46.39 18.76,46.39 18.66,46.49 DI5.2 18.44,47.25 v2(17.77,46.57)
USB20_JUSB2_P0: length 272.4
  IN1 w0.084: 136.82,104.67 135.63,105.87 134.05,105.87 133.53,106.39 132.2,106.39 131.61,106.97 130.38,106.97 129.3,105.89 127.36,105.89 127.1,106.16 127.1,107.07 126.53,107.64 126.53,109.61 126.1,110.04 125.69,110.04 v2(125.57,110.16)
  IN1 w0.127: v2(186.23,45.22) 186.39,45.38 186.69,45.38 186.99,45.68 186.99,47.12 185.8,48.3 185.8,50.8 185.98,50.98 185.98,55.86 185.73,56.11 185.73,59.17 185.3,59.6 185.3,60.88 185.04,61.14 185.04,63.97 182.17,66.84 182.17,76.89 178.87,80.19 177.17,80.19 174.21,83.15 163.09,83.15 150.89,95.35 148.24,95.35 141.76,101.83 139.67,101.83 136.82,104.67
  BOTTOM w0.076: UC1.AM8 125.91,109.82 v2(125.57,110.16)
  BOTTOM w0.102: v2(186.23,45.22) 185.65,45.22 185.38,44.95 136.9,44.95 135.16,46.69 52.28,46.69 51.41,45.82 LI5.4
USB20_JUSB2_P0_R: length 11.2
  IN3 w0.127: JUSB2.3 13.3,47.93 14.72,47.93 16.5,46.15 17.61,46.15 v2(17.77,45.99)
  BOTTOM w0.102: v2(17.77,45.99) 18.44,45.31 DI5.3 18.66,46.07 18.76,46.17 19.59,46.17 19.65,46.11 20.39,46.11 20.69,45.82 LI5.3
USB20_JUSB3_N2: length 279.6
  IN1 w0.084: v2(125.76,107.44) 125.86,107.44 125.9,107.4 125.9,105.72 126.34,105.28 130.26,105.28 130.55,105.58 132.54,105.58 132.97,105.14 132.97,104.84 133.52,104.29 135.12,104.29 135.38,104.55 135.94,104.55 136.29,104.2 136.29,103.74 136.4,103.63 136.4,103.6 136.45,103.55 136.45,103.52 136.45,103.51
  IN1 w0.127: v2(186.27,43.42) 186.62,43.42 186.71,43.52 186.71,43.81 186.23,44.29 185.91,44.29 184.68,45.52 184.68,54.02 184.49,54.21 184.49,58.92 184.02,59.39 184.02,60.23 183.43,60.82 183.43,63.73 180.43,66.73 180.43,73.36 180.76,73.69 180.76,76.38 178.05,79.1 176.03,79.1 173.12,82.01 162.7,82.01 150.76,93.95 148.14,93.95 141.45,100.64 139.32,100.64 136.45,103.51
  BOTTOM w0.076: UC1.AR8 125.76,107.65 v2(125.76,107.44)
  BOTTOM w0.102: v2(186.27,43.42) 186.59,43.42 186.68,43.34 186.68,43.18 186.31,42.81 183.53,42.81 182.89,43.45 86.92,43.45 86.53,43.06 63.16,43.06 62.68,43.54 38.99,43.54 25.87,30.41 v3(22.91,30.41) 21.61,30.41 21.56,30.47 21.56,30.79 21.35,31 LI7.1
USB20_JUSB3_N2_R: length 11.8
  BOTTOM w0.102: JUSB3.2 10.85,30.52 12.78,30.52 12.91,30.65 12.91,30.67 13.28,31.04 13.3,31.04 13.91,31.65 15.68,31.65 16.57,30.76 16.98,30.76 17.26,31.04 DI7.2 17.86,31.57 18.06,31.37 18.06,30.99 18.35,30.7 18.7,30.7 18.99,31 LI7.2
USB20_JUSB3_P2: length 279.8
  IN1 w0.084: 136.65,103.71 136.52,103.84 136.52,104.29 136.03,104.78 135.28,104.78 135.03,104.52 133.61,104.52 133.2,104.93 133.2,105.24 132.64,105.8 130.46,105.8 130.16,105.51 126.43,105.51 126.13,105.82 126.13,107.65 v2(125.58,108.19)
  IN1 w0.127: v2(187.1,43.36) 186.98,43.48 186.98,43.92 186.34,44.57 186.02,44.57 184.95,45.63 184.95,54.13 184.76,54.32 184.76,59.03 184.29,59.5 184.29,60.34 183.7,60.93 183.7,63.84 180.7,66.84 180.7,73.24 181.03,73.57 181.03,76.49 178.16,79.37 176.15,79.37 173.23,82.28 162.81,82.28 150.87,94.22 148.25,94.22 141.56,100.92 139.44,100.92 136.65,103.71
  BOTTOM w0.076: v2(125.58,108.19) 125.9,108.52 UC1.AP8
  BOTTOM w0.102: LI7.4 22.64,30.2 22.65,30.18 23.18,30.18 23.19,30.2 25.96,30.2 39.08,43.32 62.59,43.32 63.07,42.84 86.62,42.84 87.01,43.23 182.8,43.23 183.44,42.6 186.4,42.6 186.91,43.11 186.91,43.17 v2(187.1,43.36)
USB20_JUSB3_P2_R: length 11.8
  BOTTOM w0.102: JUSB3.3 10.86,30.3 12.87,30.3 v3(13.26,30.69) 14,31.44 15.59,31.44 16.48,30.55 16.98,30.55 17.26,30.27 DI7.3 17.73,29.64 17.94,29.85 17.94,30.17 18.26,30.49 18.69,30.49 18.98,30.2 LI7.3
USB20_MINI1_N4: length 59.7
  IN3 w0.084: v2(121.76,109.49) 121.89,109.62 122.13,109.62 122.53,110.02 122.53,111.01 122.13,111.41 121.19,111.41 118.97,113.63 118.97,119.64 117.19,121.42 117.19,122.18 116.49,122.88 116.49,123.93 115.28,125.13 115.28,128.96 115.6,129.27 115.6,131.75 116.18,132.34 116.18,132.66 116.21,132.69
  IN3 w0.127: v2(118.24,148.95) 118.14,148.85 118.14,148.57 118.23,148.48 119.78,148.48 121.5,146.75 121.5,140.56 116.21,135.27 116.21,132.69
  BOTTOM w0.076: v2(121.76,109.49) 122.09,109.82 UC1.AM15
  BOTTOM w0.102: v2(118.24,148.95) 118.09,148.8 118.09,148.52 117.81,148.24 110.09,148.24 109.62,148.71 109.62,148.98 109.5,149.1 JMINI.36
USB20_MINI1_P4: length 59.3
  IN3 w0.084: 115.95,132.76 115.95,132.75 115.97,132.73 115.97,132.42 115.39,131.84 115.39,129.36 115.07,129.05 115.07,125.04 116.28,123.84 116.28,122.79 116.98,122.09 116.98,121.33 118.76,119.55 118.76,113.54 121.1,111.2 122.04,111.2 122.32,110.92 122.32,110.11 122.04,109.83 121.92,109.83 121.76,109.99 v2(121.76,110.14)
  IN3 w0.127: v2(117.65,148.95) 117.88,148.72 117.88,148.47 118.13,148.22 119.67,148.22 121.25,146.65 121.25,140.67 115.95,135.37 115.95,132.76
  BOTTOM w0.076: v2(121.76,110.14) 122,110.14 122.14,110.29 UC1.AL15
  BOTTOM w0.102: JMINI.38 110.3,149.18 110.2,149.08 109.9,149.08 109.84,149.01 109.84,148.8 110.18,148.45 117.72,148.45 117.88,148.61 117.88,148.76 117.69,148.95 v2(117.65,148.95)
USB20_USBDB_N3: length 136.4
  TOP w0.102: v2(206.47,38.34) 206.38,38.43 LI10.1
  IN1 w0.084: v2(125.01,107.82) 125.01,107.69 125.38,107.33 125.38,107.13 125.66,106.84 125.66,105.62 126.24,105.04 129.86,105.04 130.14,104.76 132.48,104.76 133.23,104.01 134.33,104.01 134.64,103.7 134.67,103.7 134.72,103.65 134.75,103.65 134.86,103.54 134.91,103.49 134.91,103.46 134.92,103.45
  IN1 w0.127: 134.92,103.45 135.44,102.93 136.25,102.93 139.07,100.12 141.26,100.12 148.76,92.61 151.21,92.61 162.67,81.15 172.97,81.15 175.84,78.28 177.11,78.28 179.48,75.91 179.48,66.88 182.92,63.44 182.92,60.5 183.49,59.93 183.49,54.32 183.63,54.18 183.63,50.84 184.15,50.33 184.15,44.75 187.14,41.76 187.14,39.8 186.64,39.3 186.64,36.92 187.49,36.08 187.49,35.68 189.71,33.47 196.18,33.47 199.55,36.83 205.45,36.83 206.66,38.04 206.66,38.15 v2(206.47,38.34)
  BOTTOM w0.076: UC1.AR10 124.62,107.98 124.78,107.82 v2(125.01,107.82)
USB20_USBDB_N3_R: length 5.6
  TOP w0.102: JDB.5 209.97,42.93 209.58,42.54 209.32,42.54 209.31,42.55 208.67,42.55 208.66,42.54 207.17,42.54 v3(206.82,42.19) 206.59,41.96 206.59,41.33 206.38,41.12 LI10.2
USB20_USBDB_P3: length 136.4
  TOP w0.102: LI10.4 207.19,38.43 v2(207.1,38.34)
  IN1 w0.084: v2(125.01,107.17) 125.43,106.75 125.43,105.53 126.15,104.81 129.77,104.81 130.05,104.53 132.38,104.53 133.14,103.78 134.24,103.78 134.57,103.45
  IN1 w0.127: 134.57,103.45 134.59,103.43 134.64,103.38 134.64,103.35 135.33,102.66 136.14,102.66 138.96,99.84 141.14,99.84 148.64,92.34 151.1,92.34 162.56,80.88 172.86,80.88 175.73,78.01 176.99,78.01 179.21,75.8 179.21,66.77 182.65,63.32 182.65,60.39 183.22,59.82 183.22,54.21 183.36,54.07 183.36,50.73 183.87,50.21 183.87,44.64 186.87,41.64 186.87,39.92 186.37,39.42 186.37,36.81 187.22,35.96 187.22,35.57 189.59,33.2 196.29,33.2 199.66,36.56 205.56,36.56 206.93,37.93 206.93,38.17 v2(207.1,38.34)
  BOTTOM w0.076: v2(125.01,107.17) 124.64,107.54 UC1.AT10
USB20_USBDB_P3_R: length 5.3
  TOP w0.102: LI10.3 207.19,41.14 206.81,41.51 206.81,41.85 207.28,42.32 v3(208.96,42.32) 209.61,42.32 210,41.93 JDB.4
USB_EN#: length 253.3
  TOP w0.102: UI2.4 29.44,49.95 29.67,49.72 30.3,49.72 30.62,49.41 v2(30.62,49.15) 30.62,48.52 30.43,48.33 CI26.1 ; v2(31.52,65.6) 31.41,65.71 CI13.1 30.69,65.73 30.26,65.3 29.59,65.3 29.37,65.51 UI3.4 ; v2(193.07,35.87) 193.19,35.98 UE1.26 ; CI16.1 21,36 v2(21.51,35.49) 20.96,34.94 UI4.4
  IN1 w0.127: v2(30.62,49.15) 34.52,53.05 64.99,53.05 v2(65.38,52.66) ; v2(207.8,38.48) 206.85,39.44 204.56,39.44 202.47,37.34 195.05,37.34 193.58,35.87 v2(193.07,35.87) 191.53,37.4 188.48,37.4 188.14,37.75 188.14,40.43 189.13,41.42 189.13,42.29 189.5,42.66 189.5,49.51 v2(187.58,51.42)
  IN3 w0.127: v2(65.38,52.66) 68.89,49.15 177.95,49.15 179.01,50.22 185.18,50.22 186.38,51.42 v2(187.58,51.42) ; v2(21.51,35.49) 30.62,44.6 v2(30.62,49.15) 30.25,49.52 30.25,64.33 v2(31.52,65.6)
  BOTTOM w0.102: UI5.4 214.25,38.84 213.4,37.99 CI25.1 212.83,36.96 208.56,36.96 v1(207.97,37.56) 207.8,37.72 v2(207.8,38.48)
USB_OC0#: length 162.2
  TOP w0.089: 135.59,103.45 135.03,104.02 135.03,105.65 v1(133.11,107.57) 132.77,107.91 v2(131.98,107.91)
  TOP w0.102: UI2.5 29.44,55.59 29.61,55.76 30.19,55.76 CI17.1 31.78,55.26 32.15,55.63 v2(32.15,71.03) 31.68,71.5 31.14,71.5 30.65,71.01 CI15.1 30.38,71.25 29.54,71.25 29.37,71.08 UI3.5 ; RP55.1 139.59,99.89 138.95,100.52 138.52,100.52 135.59,103.45
  IN2 w0.089: 132.62,103.45 132.62,104.13 131.92,104.83 131.92,107.11 131.98,107.18 v2(131.98,107.91) 131.98,109.27 v2(132.55,109.84)
  IN2 w0.127: 132.62,103.45 132.62,100.52 130.11,98.02 127.38,98.02 124.3,94.94 121.88,94.94 113.36,86.41 59.33,86.41 45.49,72.57 33.68,72.57 v2(32.15,71.03)
  BOTTOM w0.076: v2(132.55,109.84) 131.49,109.84 131.01,110.32 129.44,110.32 129.19,110.57 UC1.AL3
USB_OC1#: length 320.8
  TOP w0.089: 135.27,103.45 134.8,103.92 134.8,105.52 133.47,106.85 v2(132.86,106.85)
  TOP w0.102: v2(32.79,71.05) 32.79,71.04 33.19,70.63 v1(33.19,68.14) 33.19,46.5 24.08,37.39 18.81,37.39 17.6,36.18 CI24.1 16.04,35.86 UI4.5 ; 135.27,103.45 138.43,100.29 138.8,100.29 139.09,100.01 RP55.2
  IN2 w0.127: v2(32.79,71.05) 33.23,70.6 35.21,70.6 36.67,72.06 45.7,72.06 59.67,86.03 113.69,86.03 121.89,94.22 127.47,94.22 133.32,100.07 133.32,104.97 132.86,105.43 v2(132.86,106.85) 132.95,106.94 134.08,106.94 135.16,105.86 135.16,104.02 139.81,99.37 139.81,77.53 142.21,75.13 142.21,70.81 142.01,70.61 142.01,66.17 142.21,65.98 142.21,48.01 v2(142.78,47.44)
  IN3 w0.127: v2(142.78,47.44) 178.6,47.44 179.05,46.99 180.81,46.99 181.57,46.23 184.29,46.23 185.05,46.99 188.81,46.99 189.27,47.44 193.17,47.44 197.89,42.71 197.89,40.52 199.36,39.06 207.93,39.06 v2(208.44,38.55)
  BOTTOM w0.076: v2(132.86,106.85) 132.83,106.88 131.12,106.88 130.43,107.57 UC1.AT1
  BOTTOM w0.102: UI5.5 208.67,38.84 208.44,38.61 v2(208.44,38.55) 208.44,38.29 209.13,37.59 CI32.1
USB_OC2#: length 24.4
  TOP w0.089: 134.95,103.45 134.57,103.84 134.57,104.97 133.94,105.6 v1(132.88,105.6) 132.74,105.6 v2(132.3,105.16)
  TOP w0.102: 134.95,103.45 134.95,103.45 138.59,99.81 RP55.3
  IN2 w0.089: v2(135.71,111.47) 135.71,110.59 132.24,107.11 132.24,105.22 v2(132.3,105.16)
  BOTTOM w0.076: UC1.AH2 130.07,112.55 130.08,112.55 130.09,112.57 130.47,112.57 130.59,112.44 134.39,112.44 135,111.83 135.35,111.83 v2(135.71,111.47)
USB_OC3#: length 12.8
  TOP w0.089: v2(134.06,104.91) 134.06,104.91 v1(134.06,104.28) 134.06,104.01 134.62,103.45
  TOP w0.102: RP55.4 138.09,99.99 134.62,103.45
  BOTTOM w0.076: 133.19,105.53 130.84,105.53 130.44,105.92 130.14,105.92 130.13,105.93 129.48,105.93 129.15,106.26 UC1.AV3
  BOTTOM w0.089: v2(134.06,104.91) 134.06,104.91 134.06,104.92 133.46,105.53 133.19,105.53
USBRBIAS: length 6.4
  TOP w0.076: v2(123.66,110.16) 123.66,110.99 123.03,111.63 123.03,111.9 RC90.1
  TOP w0.089: v1(121.42,113.41) 121.75,113.08 121.91,113.08 122.51,112.49 RC90.1
  BOTTOM w0.076: UC1.AJ11 UC1.AJ10
  BOTTOM w0.089: UC1.AJ11 123.66,111.3 v2(123.66,110.16)
VCIN0_PH: length 133.9
  TOP w0.203: UE1.109 182.85,46.92 v2(183.42,47.49)
  TOP w0.254: v2(171.42,60.84) 171.67,61.09 171.67,64 170.83,64.83 170.83,79.89 160.69,90.03 120.71,90.03 116.57,94.17 116.57,97.54 116.17,97.94 116.17,103.16 115.16,104.18 115.16,106.1 v1(115.16,106.11) 115.16,106.4 114.89,106.68 114.89,109.22 114.87,109.23 114.87,111.14 114.75,111.27 114.75,111.91 115.12,112.29 115.12,112.75 113.33,114.54 107.08,114.54 106.52,115.1 106.52,115.42 PH1.1
  BOTTOM w0.254: v2(183.42,47.49) 182.96,47.03 PR24.1 181.05,47.93 181.05,49.8 179.92,50.93 178.65,50.93 178.46,51.12 175.58,51.12 171.48,55.22 171.48,60.77 v2(171.42,60.84)
