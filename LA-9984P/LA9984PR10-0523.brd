# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS0: length 81.9
  IN3 w0.084: 113.96,96.38 113.96,96.64 113.04,97.56 113.04,101.68 112.22,102.49 112.11,102.49 v2(111.96,102.33)
  IN3 w0.127: 113.96,96.38 113.96,94.53 116.88,91.6 117.23,91.6 122.28,86.55 149.11,86.55 150.02,85.64 150.84,85.64 151.94,84.53 155.1,84.53 163.46,76.18 163.46,70.45 163.35,70.35 163.16,70.35 163.03,70.47 v2(163.03,70.62)
  BOTTOM w0.076: UC1.AV30 112.18,106.41 112.1,106.33 111.95,106.33 111.86,106.24 111.79,106.17 111.79,106.16 111.72,106.02 111.72,105.82 111.75,105.76 111.79,105.66 111.79,105.53 111.72,105.37 111.72,105.17 111.75,105.11 111.75,105.11 111.79,105.01 111.79,104.82 111.55,104.58 111.55,103.44 111.37,103.25 111.37,102.77 111.66,102.48 111.81,102.48 v2(111.96,102.33)
  BOTTOM w0.102: JDIMM2.137 163.55,72.45 163.26,72.16 163.03,72.16 162.55,71.68 162.55,70.51 162.82,70.24 162.89,70.24 163.03,70.38 v2(163.03,70.62)
DDR_B_DQS1: length 56.2
  IN1 w0.084: 114.42,95.97 114.36,96.03 114.36,96.19 114.23,96.33 114.23,99.83 115.28,100.89 115.52,100.89 v2(115.67,101.03)
  IN1 w0.127: 114.42,95.97 114.44,95.95 114.44,80.88 121.86,73.46 121.86,69 122.46,68.4 122.46,66.22 122.33,66.09 121.97,66.09 121.7,65.82 121.7,65.23 121.97,64.95 122.29,64.95 122.51,64.73 122.51,62.1 122.9,61.71 123.3,61.71 v2(123.41,61.6)
  BOTTOM w0.076: v2(115.67,101.03) 115.51,100.87 114.95,100.87 114.64,101.19 114.64,103.33 114.02,103.94 114.02,104.27 114.1,104.35 114.39,104.64 114.39,105.04 114.37,105.1 114.32,105.2 114.32,105.33 114.33,105.35 114.37,105.44 114.39,105.49 114.39,105.88 114.43,105.92 UC1.AW26
  BOTTOM w0.102: JDIMM2.12 123.65,64.21 123.45,64.02 123.45,63.94 124.05,63.34 124.05,62.06 123.86,61.87 123.67,61.87 v2(123.41,61.6)
DDR_B_DQS2: length 89
  IN3 w0.084: v2(113.48,109.68) 113.28,109.48 113.09,109.48 112.93,109.32 112.93,107.14 115.18,104.88 115.18,104 116.04,103.14 116.04,97.98 117.22,96.8 117.62,96.4 117.81,96.4 118.14,96.07 118.87,96.07 119.32,95.62
  IN3 w0.127: 119.32,95.62 124.07,90.87 150.9,90.87 151.81,89.96 156.21,89.96 168.16,78.01 168.16,75.27 169.03,74.4 169.03,71.29 168.39,70.65 168.39,68.84 168.65,68.58 168.82,68.58 v2(169.07,68.34)
  BOTTOM w0.076: v2(113.48,109.68) 113.8,110 UC1.AM28
  BOTTOM w0.102: JDIMM2.154 168.65,66.25 168.38,66.53 168.38,66.66 168.66,66.95 168.66,68.51 168.72,68.58 168.83,68.58 v2(169.07,68.34)
DDR_B_DQS3: length 57.1
  IN1 w0.084: 118.8,95.95 118.8,96.45 116.91,98.33 116.91,103.24 116.43,103.73 116.43,104.24 116.79,104.6 116.79,104.8 116.69,104.9 116.56,104.9 116.49,104.83 116.16,104.83 115.77,105.22 115.77,105.57 116.24,106.04 116.24,106.22 116.07,106.39 115.89,106.39 115.22,105.72 114.92,105.72 114.52,106.12 114.52,106.48 115.07,107.03 115.07,107.15 114.81,107.42 114.81,109.38 115,109.58 115.21,109.58 v2(115.37,109.74)
  IN1 w0.127: v2(127.98,69.59) 127.81,69.76 127.42,69.76 127.16,70.03 127.16,76.29 119.49,83.96 119.49,86.65 119.37,86.77 119.06,86.77 118.79,87.05 118.79,87.64 119.06,87.91 119.37,87.91 119.49,88.04 119.49,88.42 119.37,88.55 119.06,88.55 118.79,88.82 118.79,89.41 119.06,89.69 119.37,89.69 119.49,89.81 119.49,90.19 119.37,90.32 119.06,90.32 118.79,90.59 118.79,91.18 119.06,91.46 119.4,91.46 119.47,91.53 119.47,91.94 119.32,92.09 119.07,92.09 118.8,92.37 118.8,95.95
  BOTTOM w0.076: UC1.AM25 115.63,110 v2(115.37,109.74)
  BOTTOM w0.102: JDIMM2.29 128.75,72.43 128.59,72.27 128.59,70.06 128.39,69.87 128.26,69.87 v2(127.98,69.59)
DDR_B_DQS4: length 86.7
  IN3 w0.084: v2(117.57,102.59) 117.57,102.71 117.68,102.82 117.99,102.82 118.59,102.22 118.59,98.24 118.94,97.89 120.13,97.89 120.98,97.03 126.72,97.03 127.61,96.15 127.64,96.11 127.64,96.08 127.77,95.95
  IN3 w0.127: v2(173.9,70.62) 173.9,70.45 174.03,70.31 174.22,70.31 174.32,70.4 174.32,71.6 173.93,71.98 173.93,78.96 157.9,95 155.92,95 155.62,95.3 139.73,95.3 139.39,95.64 128.08,95.64 127.77,95.95
  BOTTOM w0.076: UC1.AV22 117.31,106.41 117.23,106.33 117.08,106.33 116.99,106.24 116.92,106.17 116.92,106.16 116.85,106.02 116.85,105.82 116.88,105.76 116.93,105.66 116.93,105.53 116.85,105.37 116.85,105.17 116.88,105.11 116.88,105.11 116.93,105.01 116.93,104.82 116.81,104.71 116.81,104.09 117.05,103.85 117.05,103.11 v2(117.57,102.59)
  BOTTOM w0.102: v2(173.9,70.62) 173.9,70.48 173.76,70.35 173.53,70.35 173.45,70.43 173.45,71.8 173.52,71.87 173.52,72.2 173.75,72.43 JDIMM2.171
DDR_B_DQS5: length 54.4
  IN1 w0.084: 123.11,95.62 123.11,95.63 122.8,95.93 122.8,96.71 122.01,97.51 120.95,97.51 120.31,98.15 120.31,99.78 120.53,100 120.91,100 121.05,100.14 v2(121.05,100.31)
  IN1 w0.127: 123.11,95.62 123.11,94.32 123.78,93.64 123.78,90.62 124.06,90.35 124.36,90.35 124.49,90.22 124.49,89.84 124.36,89.71 124.06,89.71 123.78,89.44 123.78,88.83 124.04,88.57 124.91,88.57 125.04,88.45 125.04,88.07 124.91,87.94 124.19,87.94 123.92,87.66 123.92,87.07 124.19,86.8 124.89,86.8 125.04,86.65 125.04,85.94 133.51,77.47 133.51,75.64 133.78,75.37 133.89,75.37 134.01,75.24 134.01,74.86 133.89,74.73 133.76,74.73 133.48,74.46 133.48,73.87 133.76,73.6 133.89,73.6 134.01,73.47 134.01,73.09 133.89,72.96 133.76,72.96 133.48,72.69 133.48,72.1 133.76,71.82 133.89,71.82 134.01,71.7 134.01,70.25 133.9,70.13 133.72,70.13 133.6,70.26 v2(133.6,70.43)
  BOTTOM w0.076: v2(121.05,100.31) 121.05,100.18 120.78,99.9 120.62,99.9 120.18,100.34 120.18,103.27 119.28,104.17 119.28,104.49 119.52,104.73 119.52,105.04 119.5,105.1 119.45,105.2 119.45,105.33 119.46,105.35 119.5,105.44 119.52,105.49 119.52,105.89 119.6,105.97 119.69,105.97 UC1.AW18
  BOTTOM w0.102: v2(133.6,70.43) 133.63,70.39 133.63,70.18 133.52,70.07 133.15,70.07 133,70.22 133,71.17 133.83,72 133.83,72.19 134.15,72.51 JDIMM2.47
DDR_B_DQS6: length 94.7
  IN3 w0.084: v2(118.13,109.68) 117.95,109.49 117.82,109.49 117.58,109.26 117.58,107.51 118.43,106.66 119.29,106.66 122.72,103.23 122.72,100.86 123.54,100.04 129.16,100.04 129.86,100.74 131.47,100.74 131.51,100.7 131.57,100.7
  IN3 w0.127: v2(179.93,68.34) 179.78,68.49 179.54,68.49 179.25,68.78 179.25,80.26 159.89,99.62 144.96,99.62 144.08,100.5 137.42,100.5 137.22,100.7 131.57,100.7
  BOTTOM w0.076: UC1.AM21 118.52,109.78 118.42,109.68 v2(118.13,109.68)
  BOTTOM w0.102: v2(179.93,68.34) 179.93,68.56 179.82,68.67 179.6,68.67 179.42,68.5 179.42,66.86 178.85,66.29 JDIMM2.188
DDR_B_DQS7: length 63.4
  IN1 w0.084: v2(120.04,109.68) 119.85,109.5 119.69,109.5 119.48,109.28 119.48,106.48 121.57,104.39 121.57,104.12 122.65,103.05 122.65,100.64 126.39,96.89 127.34,96.89 128.11,96.13 128.11,95.98 128.09,95.96 128.09,95.95
  IN1 w0.127: v2(138.7,61.6) 138.53,61.77 138.33,61.77 137.95,62.15 137.95,63.74 138.33,64.12 138.83,64.12 139.1,64.39 139.1,79.17 130.9,87.36 130.9,91.98 128.09,94.8 128.09,95.95
  BOTTOM w0.076: v2(120.04,109.68) 120.1,109.68 UC1.AM18
  BOTTOM w0.102: v2(138.7,61.6) 138.74,61.65 139.35,61.65 139.61,61.91 139.61,63.08 139.18,63.51 139.18,64.13 139.25,64.2 JDIMM2.64
DDR_B_DQS#0: length 82.1
  IN3 w0.084: v2(111.96,102.98) 111.96,102.88 112.17,102.66 112.3,102.66 113.21,101.75 113.21,97.63 114.2,96.64 114.2,96.38
  IN3 w0.127: v2(163.03,69.86) 163.28,70.11 163.45,70.11 163.7,70.35 163.7,76.28 155.2,84.78 152.04,84.78 150.94,85.88 150.12,85.88 149.21,86.79 122.38,86.79 117.33,91.84 116.98,91.84 114.2,94.63 114.2,96.38
  BOTTOM w0.076: v2(111.96,102.98) 111.96,102.82 111.8,102.67 111.71,102.67 111.53,102.84 111.53,103.18 111.72,103.37 111.72,104.51 111.96,104.75 111.96,105.04 111.93,105.1 111.89,105.2 111.89,105.33 111.89,105.35 111.94,105.44 111.96,105.49 111.96,105.7 111.89,105.85 111.89,105.98 111.94,106.09 112.02,106.17 112.11,106.17 112.18,106.1 UC1.AW30
  BOTTOM w0.102: v2(163.03,69.86) 162.85,70.04 162.74,70.04 162.35,70.43 162.35,71.77 162.95,72.37 JDIMM2.135
DDR_B_DQS#1: length 56.5
  IN1 w0.084: 114.59,96.15 114.57,96.17 114.57,96.28 114.43,96.42 114.43,99.75 115.36,100.68 115.56,100.68 115.67,100.57 v2(115.67,100.38)
  IN1 w0.127: v2(123.41,62.37) 123.41,62.18 123.19,61.96 123.01,61.96 122.76,62.21 122.76,64.83 122.39,65.2 122.08,65.2 121.95,65.33 121.95,65.71 122.08,65.84 122.43,65.84 122.71,66.11 122.71,68.51 122.11,69.1 122.11,73.56 114.69,80.98 114.69,96.05 114.59,96.15
  BOTTOM w0.076: v2(115.67,100.38) 115.67,100.51 115.46,100.71 114.89,100.71 114.47,101.12 114.47,103.26 113.86,103.88 113.86,104.34 113.98,104.47 114.23,104.71 114.23,105.01 114.15,105.17 114.15,105.37 114.23,105.53 114.23,106.01 114.38,106.17 114.38,106.34 UC1.AV26
  BOTTOM w0.102: v2(123.41,62.37) 123.71,62.07 123.78,62.07 123.85,62.15 123.85,63.26 123.26,63.86 123.26,64 123.05,64.2 JDIMM2.10
DDR_B_DQS#2: length 89.1
  IN3 w0.084: 119.47,95.81 119.41,95.81 118.98,96.24 118.21,96.24 117.88,96.57 117.69,96.57 116.21,98.05 116.21,103.21 115.36,104.07 115.36,104.95 113.1,107.21 113.1,109.25 113.16,109.31 113.36,109.31 113.48,109.19 v2(113.48,109.03)
  IN3 w0.127: 119.47,95.81 124.17,91.11 151,91.11 151.91,90.2 156.31,90.2 168.4,78.11 168.4,75.37 169.27,74.5 169.27,71.19 168.63,70.55 168.63,68.94 168.75,68.82 168.97,68.82 169.07,68.92 v2(169.07,69.1)
  BOTTOM w0.076: UC1.AN28 113.87,109.09 113.81,109.03 v2(113.48,109.03)
  BOTTOM w0.102: v2(169.07,69.1) 169.07,68.94 168.9,68.77 168.64,68.77 168.46,68.6 168.46,67.03 168.18,66.75 168.18,66.47 168.05,66.35 JDIMM2.152
DDR_B_DQS#3: length 57.2
  IN1 w0.084: v2(115.37,108.96) 115.45,108.96 115.61,109.12 115.61,109.32 115.56,109.37 115.09,109.37 114.99,109.27 114.99,107.53 115.28,107.24 115.28,106.94 114.73,106.39 114.73,106.21 115.01,105.92 115.14,105.92 115.81,106.59 116.16,106.59 116.45,106.3 116.45,105.95 115.98,105.48 115.98,105.3 116.25,105.04 116.4,105.04 116.47,105.11 116.78,105.11 117,104.89 117,104.51 116.64,104.15 116.64,103.81 117.12,103.33 117.12,98.41 119,96.53 119,96.07 119.03,96.05 119.03,95.98 119.05,95.96 119.05,95.62
  IN1 w0.127: v2(127.98,70.35) 127.98,70.1 127.89,70.02 127.52,70.02 127.41,70.13 127.41,76.39 119.74,84.06 119.74,86.76 119.47,87.03 119.17,87.03 119.04,87.15 119.04,87.53 119.17,87.66 119.47,87.66 119.74,87.94 119.74,88.52 119.47,88.8 119.17,88.8 119.04,88.93 119.04,89.31 119.17,89.43 119.47,89.43 119.74,89.71 119.74,90.3 119.47,90.57 119.17,90.57 119.04,90.7 119.04,91.08 119.17,91.21 119.5,91.21 119.72,91.43 119.72,92.04 119.42,92.34 119.17,92.34 119.05,92.47 119.05,95.62
  BOTTOM w0.076: UC1.AN25 115.77,109.13 115.61,108.96 v2(115.37,108.96)
  BOTTOM w0.102: v2(127.98,70.35) 128.26,70.07 128.31,70.07 128.39,70.15 128.39,72.27 128.15,72.5 JDIMM2.27
DDR_B_DQS#4: length 86.8
  IN3 w0.084: 127.94,96.12 127.88,96.12 126.79,97.2 121.05,97.2 120.2,98.06 119.02,98.06 118.76,98.31 118.76,102.29 118.06,102.99 117.76,102.99 v2(117.57,103.17)
  IN3 w0.127: 127.94,96.12 128.18,95.88 139.49,95.88 139.83,95.54 155.72,95.54 156.02,95.24 158,95.24 174.18,79.06 174.18,72.08 174.56,71.7 174.56,70.3 174.32,70.07 174.04,70.07 173.9,69.92 v2(173.9,69.86)
  BOTTOM w0.076: v2(117.57,103.17) 117.28,103.17 117.22,103.24 117.22,103.92 116.98,104.16 116.98,104.64 117.09,104.75 117.09,105.04 117.07,105.1 117.02,105.2 117.02,105.33 117.03,105.35 117.07,105.44 117.09,105.49 117.09,105.7 117.02,105.85 117.02,105.98 117.07,106.09 117.15,106.17 117.24,106.17 117.31,106.1 UC1.AW22
  BOTTOM w0.102: v2(173.9,69.86) 173.9,70.02 173.76,70.15 173.44,70.15 173.25,70.34 173.25,71.88 173.32,71.95 173.32,72.25 173.15,72.42 JDIMM2.169
DDR_B_DQS#5: length 54.8
  IN1 w0.084: 123.36,95.62 123.36,95.63 123.34,95.66 123.34,95.72 123.2,95.85 123.18,95.85 123.01,96.02 123.01,96.8 122.09,97.72 121.03,97.72 120.51,98.24 120.51,99.69 120.61,99.79 120.92,99.79 v2(121.05,99.66)
  IN1 w0.127: 123.36,95.62 123.36,94.42 124.04,93.75 124.04,90.72 124.16,90.6 124.47,90.6 124.74,90.32 124.74,89.73 124.47,89.46 124.16,89.46 124.04,89.33 124.04,88.94 124.15,88.83 125.01,88.83 125.29,88.55 125.29,87.96 125.01,87.69 124.3,87.69 124.17,87.56 124.17,87.18 124.3,87.05 124.99,87.05 125.29,86.76 125.29,86.05 133.76,77.58 133.76,75.75 133.88,75.62 133.99,75.62 134.27,75.35 134.27,74.76 133.99,74.48 133.86,74.48 133.73,74.36 133.73,73.98 133.86,73.85 133.99,73.85 134.27,73.57 134.27,72.98 133.99,72.71 133.86,72.71 133.73,72.58 133.73,72.2 133.86,72.08 133.99,72.08 134.27,71.8 134.27,70.14 134,69.88 133.81,69.88 133.6,69.67 v2(133.6,69.67)
  BOTTOM w0.076: v2(121.05,99.66) 120.97,99.74 120.55,99.74 120.02,100.27 120.02,103.2 119.12,104.1 119.12,104.57 119.36,104.81 119.36,105.01 119.28,105.17 119.28,105.37 119.35,105.51 119.36,105.53 119.36,106.01 119.52,106.17 119.52,106.34 UC1.AV18
  BOTTOM w0.102: JDIMM2.45 133.55,72.52 133.63,72.44 133.63,72.09 132.8,71.25 132.8,70.14 133.07,69.87 133.39,69.87 v2(133.6,69.67)
DDR_B_DQS#6: length 94.9
  IN3 w0.084: 131.55,100.94 131.53,100.91 129.79,100.91 129.09,100.21 123.61,100.21 122.89,100.93 122.89,103.3 119.36,106.84 118.5,106.84 117.76,107.58 117.76,109.19 117.89,109.32 118.02,109.32 118.13,109.21 v2(118.13,109.03)
  IN3 w0.127: v2(179.93,69.1) 179.93,68.89 179.77,68.73 179.64,68.73 179.49,68.88 179.49,80.36 159.99,99.86 145.06,99.86 144.18,100.74 137.52,100.74 137.32,100.94 131.55,100.94
  BOTTOM w0.076: UC1.AN21 118.46,109.35 v2(118.13,109.03)
  BOTTOM w0.102: v2(179.93,69.1) 179.7,68.87 179.51,68.87 179.22,68.58 179.22,66.94 178.79,66.51 178.43,66.51 178.25,66.32 JDIMM2.186
DDR_B_DQS#7: length 63.6
  IN1 w0.084: v2(120.04,109.03) 120.04,109.21 119.97,109.29 119.73,109.29 119.67,109.23 119.67,106.53 121.78,104.42 121.78,104.21 122.86,103.13 122.86,100.72 126.48,97.1 127.42,97.1 128.34,96.19 128.34,95.95
  IN1 w0.127: 128.34,95.95 128.34,94.91 131.16,92.09 131.16,87.47 139.35,79.27 139.35,64.29 138.93,63.87 138.44,63.87 138.2,63.64 138.2,62.26 138.44,62.03 138.6,62.03 138.7,62.12 v2(138.7,62.37)
  BOTTOM w0.089: UC1.AN18 120.47,109.35 120.55,109.27 120.55,109.09 120.49,109.03 v2(120.04,109.03)
  BOTTOM w0.102: v2(138.7,62.37) 138.7,62.18 139.03,61.85 139.27,61.85 139.41,61.99 139.41,62.99 138.98,63.43 138.98,63.93 138.88,64.03 138.73,64.03 138.65,64.11 JDIMM2.62
DDR_B_MA0: length 80.9
  IN3 w0.084: v2(105.76,108.38) 106.1,108.03 106.1,107.38 105.88,107.16 105.88,101.05 105.18,100.35 105.18,96.22 104.78,95.81 104.78,95.67
  IN3 w0.208: v2(151.16,67.68) 151.62,68.15 151.62,71.69 150.96,72.35 150.96,72.9 148.5,75.36 120.1,75.36 104.78,90.68 104.78,95.67
  BOTTOM w0.076: UC1.AP40 106.08,108.7 v2(105.76,108.38)
  BOTTOM w0.165: JDIMM2.98 151.85,66.99 v2(151.16,67.68)
DDR_B_MA1: length 81.2
  IN3 w0.084: 104.31,95.67 104.31,96.02 104.01,96.32 104.01,97.48 104.89,98.36 104.89,101.83 105.53,102.47 105.53,107.53 v2(105.73,107.73)
  IN3 w0.208: 104.31,95.67 104.31,90.5 120.5,74.31 125.38,74.31 125.96,74.89 128.26,74.89 128.84,74.31 132.14,74.31 132.72,74.89 134.92,74.89 135.5,74.31 136.36,74.31 136.58,74.52 136.58,74.67 136.79,74.89 137.23,74.89 137.44,74.67 137.44,74.51 137.65,74.31 138.84,74.31 139.05,74.51 139.05,74.67 139.26,74.89 139.7,74.89 139.91,74.67 139.91,74.52 140.13,74.31 140.88,74.31 141.46,74.89 144.62,74.89 145.12,74.39 145.43,74.39 145.89,74.86 146.38,74.86 146.84,74.39 147.22,74.39 147.72,74.89 148.31,74.89 150.49,72.7 150.49,70.93 150.69,70.73 v2(151.16,70.73)
  BOTTOM w0.076: UC1.AR40 106.06,108.05 v2(105.73,107.73)
  BOTTOM w0.165: v2(151.16,70.73) 151.6,71.17 151.6,72.18 151.55,72.23 JDIMM2.97
DDR_B_MA2: length 85.9
  IN3 w0.084: 103.37,95.67 103.37,95.96 103.66,96.25 103.66,97.99 104.28,98.61 104.28,107.87 v2(104.84,108.43)
  IN3 w0.208: 103.37,95.67 103.37,90.11 118.08,75.4 118.08,74.75 119.46,73.37 147.86,73.37 149.55,71.68 149.55,63.81 v2(150.62,62.75)
  BOTTOM w0.076: v2(104.84,108.43) 105.12,108.7 UC1.AP42
  BOTTOM w0.165: JDIMM2.96 151.25,63.38 v2(150.62,62.75)
DDR_B_MA3: length 82.7
  IN3 w0.084: v2(104.84,107.78) 104.65,107.59 104.65,98.63 103.84,97.82 103.84,95.67
  IN3 w0.208: v2(151.16,69.21) 150.22,69.21 150.02,69.41 150.02,72.51 148.61,73.92 144.33,73.92 143.84,74.42 141.65,74.42 141.07,73.84 135.3,73.84 134.72,74.42 132.92,74.42 132.34,73.84 128.64,73.84 128.06,74.42 126.15,74.42 125.58,73.84 119.65,73.84 118.55,74.94 118.55,75.59 103.84,90.3 103.84,95.67
  BOTTOM w0.076: UC1.AR42 105.12,108.05 v2(104.84,107.78)
  BOTTOM w0.165: v2(151.16,69.21) 150.72,69.65 150.72,72.03 150.95,72.26 JDIMM2.95
DDR_B_MA4: length 90.1
  IN3 w0.084: 101.96,95.67 101.96,97.86 102.28,98.18 102.28,103.59 101.68,104.18 101.68,104.5 101.95,104.76 102.09,104.76 102.51,105.19 102.51,107.38 v2(102.94,107.8)
  IN3 w0.208: v2(149.08,62.75) 148.43,63.4 148.43,67.37 147.68,68.12 147.68,70.97 146.69,71.96 140.62,71.96 140.15,71.5 140.15,70.2 138.68,68.72 135.14,68.72 134.86,68.44 132.89,68.44 132.61,68.72 129.16,68.72 128.81,69.08 128.81,70.94 128.17,71.58 125.88,71.58 125.5,71.96 118.87,71.96 116.67,74.16 116.67,74.81 101.96,89.52 101.96,95.67
  BOTTOM w0.076: UC1.AR45 103.18,108.05 v2(102.94,107.8)
  BOTTOM w0.165: v2(149.08,62.75) 150.05,63.72 JDIMM2.92
DDR_B_MA5: length 86.8
  IN3 w0.084: v2(102.94,108.46) 103.4,108.46 103.47,108.38 103.47,107.37 103.95,106.89 103.95,101.21 103.87,101.13 103.19,101.13 103.13,101.06 103.13,97.63 102.71,97.21 102.71,96.19 102.9,96 102.9,95.67
  IN3 w0.208: v2(149.08,70.73) 149.01,70.66 148.75,70.66 148.62,70.79 148.62,71.95 147.67,72.9 137.02,72.9 136.64,72.52 135.96,72.52 135.59,72.9 135.12,72.9 134.74,72.52 134.26,72.52 133.87,72.9 133.39,72.9 133.01,72.52 132.53,72.52 132.15,72.9 131.27,72.9 131.15,72.77 131.15,70.81 131.02,70.68 130.43,70.68 130.3,70.81 130.3,72.77 130.17,72.9 129.24,72.9 128.86,72.52 128.38,72.52 128,72.9 127.52,72.9 127.14,72.52 126.65,72.52 126.27,72.9 119.26,72.9 117.61,74.55 117.61,75.2 102.9,89.91 102.9,95.67
  BOTTOM w0.076: UC1.AP45 103.18,108.7 v2(102.94,108.46)
  BOTTOM w0.165: v2(149.08,70.73) 149.37,70.73 149.57,70.53 149.57,70.3 149.77,70.09 150.09,70.09 150.29,70.3 150.29,71.14 149.75,71.68 JDIMM2.91
DDR_B_MA6: length 93
  IN3 w0.084: 101.49,95.67 101.49,97.97 102.06,98.54 102.06,103.56 101.51,104.11 101.51,104.83 v2(101.97,105.29)
  IN3 w0.208: 101.49,95.67 101.49,89.33 116.2,74.62 116.2,73.97 118.68,71.49 120.07,71.49 120.27,71.28 120.27,69.02 121.04,68.25 123.23,68.25 123.45,68.47 123.45,69.08 123.58,69.2 124.4,69.2 124.53,69.08 124.53,68.47 124.74,68.25 132.41,68.25 132.69,67.97 135.06,67.97 135.33,68.25 139.22,68.25 139.71,68.74 141,68.74 141.32,69.06 141.32,71.17 141.63,71.49 146.49,71.49 147.21,70.77 147.21,65.28 147.96,64.53 147.96,62.35 v2(149.08,61.22)
  BOTTOM w0.076: UC1.AW46 102.28,105.59 101.98,105.29 v2(101.97,105.29)
  BOTTOM w0.165: JDIMM2.90 149.45,64.13 149.32,64 148.95,64 148.62,63.67 148.62,61.69 v2(149.08,61.22)
DDR_B_MA7: length 91.2
  IN3 w0.084: v2(100.16,102.12) 100.16,99.49 98.01,97.34 98.01,95.67
  IN3 w0.208: v2(147.43,62.75) 147.17,62.75 146.97,62.95 146.97,64.24 146.76,64.44 144.57,64.44 144.37,64.24 144.37,62.73 144.24,62.6 143.63,62.6 143.51,62.73 143.51,64.24 143.3,64.44 142.85,64.44 142.64,64.24 142.64,62.73 142.52,62.6 141.91,62.6 141.78,62.73 141.78,64.24 141.58,64.44 118.84,64.44 107.15,76.14 107.15,78.96 98.01,88.1 98.01,95.67
  BOTTOM w0.076: v2(100.16,102.12) 100.33,102.29 101.5,102.29 102.45,103.24 102.45,104.87 UC1.AY46
  BOTTOM w0.165: v2(147.43,62.75) 147.87,63.19 147.87,63.74 148.25,64.12 JDIMM2.86
DDR_B_MA8: length 89.9
  IN3 w0.084: 102.43,95.67 102.19,95.91 102.19,97.44 102.47,97.72 102.47,103.92 v2(102.05,104.34)
  IN3 w0.208: 102.43,95.67 102.43,89.72 117.14,75.01 117.14,74.36 119.07,72.43 125.7,72.43 126.08,72.05 129.71,72.05 129.84,71.92 129.84,70.35 129.97,70.22 131.48,70.22 131.61,70.35 131.61,71.84 131.81,72.05 133.93,72.05 134.06,71.92 134.06,70.41 134.19,70.28 134.93,70.28 135.05,70.41 135.05,71.93 135.18,72.06 136.07,72.06 136.19,71.93 136.19,70.41 136.32,70.28 136.9,70.28 137.03,70.41 137.03,72.25 137.15,72.38 138.63,72.38 138.76,72.25 138.76,71.17 138.89,71.05 139.49,71.05 139.62,71.17 139.62,72.3 139.74,72.43 146.88,72.43 148.15,71.16 148.15,69.48 148.42,69.21 v2(149.08,69.21)
  BOTTOM w0.076: UC1.AY47 101.55,104.76 101.97,104.34 v2(102.05,104.34)
  BOTTOM w0.165: JDIMM2.89 149.15,72.27 148.37,71.5 148.37,69.92 v2(149.08,69.21)
DDR_B_MA9: length 92.4
  IN3 w0.084: 101.02,95.67 101.02,97.84 101.23,98.05 101.23,101.52 101.74,102.02 101.74,103.64 101.34,104.04 101.34,105.95 v2(101.98,106.59)
  IN3 w0.208: v2(146.58,70.73) 146.27,70.73 146.15,70.6 146.15,70.12 146.02,69.99 145.41,69.99 145.28,70.12 145.28,70.89 145.15,71.02 143.64,71.02 143.51,70.89 143.51,70.06 143.39,69.93 142.78,69.93 142.65,70.06 142.65,70.89 142.52,71.02 141.91,71.02 141.79,70.89 141.79,68.86 141.2,68.27 140.01,68.27 139.51,67.78 135.53,67.78 135.25,67.5 132.5,67.5 132.22,67.78 120.84,67.78 119.8,68.82 119.8,70.81 119.6,71.02 118.18,71.02 117.39,70.23 117.1,70.23 116.78,70.55 116.78,70.84 117.57,71.63 117.57,71.93 117.26,72.24 116.96,72.24 116.17,71.45 115.88,71.45 115.56,71.77 115.56,72.06 116.35,72.85 116.35,73.16 116.04,73.46 115.73,73.46 114.94,72.67 114.66,72.67 114.33,73 114.33,73.28 115.41,74.36 115.41,74.74 101.02,89.13 101.02,95.67
  BOTTOM w0.076: v2(101.98,106.59) 102.13,106.59 UC1.AU46
  BOTTOM w0.165: v2(146.58,70.73) 147.1,70.73 147.95,71.58 JDIMM2.85
DDR_B_MA10: length 96.7
  IN3 w0.084: 107.75,98.48 107.75,98.9 107.53,99.11 107.53,100.57 108.85,101.89 108.85,106.7 108.59,106.97 108.59,111.03 108.49,111.13 v2(108.18,111.13)
  IN3 w0.208: 107.75,98.48 107.75,91.92 119.33,80.34 124.43,80.34 124.64,80.13 124.64,78.53 124.84,78.32 125.3,78.32 125.5,78.53 125.5,80.13 125.7,80.34 126.16,80.34 126.36,80.13 126.36,78.53 126.57,78.32 127.02,78.32 127.23,78.53 127.23,80.13 127.43,80.34 127.89,80.34 128.09,80.13 128.09,78.53 128.29,78.32 150.51,78.32 152.04,76.79 152.32,76.79 152.99,77.46 153.32,77.46 153.66,77.12 153.66,76.79 153.44,76.57 153.44,76.38 154.08,75.75 154.08,75.49 153.95,75.36 153.95,75.03 154.25,74.73 154.57,74.73 154.82,74.98 155.11,74.98 155.4,74.7 155.4,74.33 155.17,74.11 155.17,73.81 155.4,73.58 155.4,69.33 155.52,69.21 v2(155.87,69.21)
  BOTTOM w0.076: v2(108.18,111.13) 108.35,111.31 UC1.AK36
  BOTTOM w0.165: v2(155.87,69.21) 154.55,70.52 JDIMM2.107
DDR_B_MA11: length 93.1
  IN3 w0.084: v2(100.17,102.68) 99.79,102.3 99.79,99.48 97.54,97.23 97.54,95.67
  IN3 w0.208: v2(147.43,61.22) 146.7,61.22 146.5,61.43 146.5,63.77 146.29,63.97 145.04,63.97 144.84,63.77 144.84,62.17 144.64,61.96 141.51,61.96 141.31,62.17 141.31,63.77 141.11,63.97 118.65,63.97 106.68,75.94 106.68,78.77 97.54,87.91 97.54,95.67
  BOTTOM w0.076: v2(100.17,102.68) 100.22,102.63 101.4,102.63 101.58,102.81 101.58,104.44 101.26,104.75 101.26,105.95 UC1.AV47
  BOTTOM w0.165: v2(147.43,61.22) 146.97,61.69 146.97,63.74 147.65,64.42 JDIMM2.84
DDR_B_MA12: length 88.6
  IN3 w0.084: v2(100.39,105.24) 100.77,104.86 100.77,104.09 100.54,103.87 100.54,99.22 98.48,97.16 98.48,95.67
  IN3 w0.208: v2(146.58,69.21) 146.02,68.64 146.02,65.2 145.72,64.91 119.04,64.91 107.62,76.33 107.62,79.16 98.48,88.29 98.48,95.67
  BOTTOM w0.076: UC1.AU47 101.5,106.61 101.1,106.2 101.1,105.47 100.89,105.27 100.42,105.27 v2(100.39,105.24)
  BOTTOM w0.165: v2(146.58,69.21) 146.14,69.65 146.14,71.43 147.35,72.63 JDIMM2.83
DDR_B_MA13: length 96.5
  IN3 w0.084: 110.11,98.05 110.22,98.16 110.71,98.16 110.84,98.29 110.84,98.49 110.71,98.62 110.26,98.62 110.14,98.75 110.14,98.99 110.26,99.11 110.71,99.11 110.84,99.24 110.84,103.43 111.09,103.68 111.09,104.65 110.65,105.08 110.65,109.23 110.48,109.41 110.48,110.95 110.39,111.04 v2(110.09,111.04)
  IN3 w0.208: v2(158.96,70.73) 159.09,70.86 159.09,75.07 153.49,80.67 147.92,80.67 147.71,80.87 147.71,82.48 147.51,82.69 147.05,82.69 146.85,82.48 146.85,80.87 146.65,80.67 146.19,80.67 145.98,80.87 145.98,82.48 145.78,82.69 145.32,82.69 145.12,82.48 145.12,80.87 144.92,80.67 144.46,80.67 144.26,80.87 144.26,82.48 144.05,82.69 143.6,82.69 143.39,82.48 143.39,80.87 143.19,80.67 142.73,80.67 142.53,80.87 142.53,82.48 142.33,82.69 120.3,82.69 110.1,92.89 110.1,98.03 110.11,98.05
  BOTTOM w0.076: v2(110.09,111.04) 110.35,111.31 UC1.AK33
  BOTTOM w0.165: JDIMM2.119 158.15,71.54 v2(158.96,70.73)
DDR_B_MA14: length 93.1
  IN3 w0.084: v2(101.98,107.86) 101.98,107.71 101.42,107.14 100.46,107.14 99.85,106.53 99.85,104.41 100.15,104.11 100.15,103.37 99.58,102.81 99.58,99.51 97.07,97.01 97.07,95.67
  IN3 w0.208: v2(145.78,62.75) 145.31,62.28 145.31,61.97 144.77,61.43 144.77,60.69 144.64,60.57 140.37,60.57 140.24,60.69 140.24,62.02 140.04,62.22 139.37,62.22 139.16,62.02 139.16,60.2 138.96,60 121.96,60 106.21,75.75 106.21,78.57 97.07,87.71 97.07,95.67
  BOTTOM w0.076: v2(101.98,107.86) 102.28,107.86 UC1.AR46
  BOTTOM w0.165: v2(145.78,62.75) 146.45,63.42 JDIMM2.80
DDR_B_MA15: length 93.7
  IN3 w0.084: v2(101.98,108.51) 101.86,108.64 101.63,108.64 101.5,108.51 101.5,107.54 101.3,107.34 100.4,107.34 99.67,106.61 99.67,104.34 99.97,104.04 99.97,103.44 99.41,102.88 99.41,99.68 96.6,96.87 96.6,95.67
  IN3 w0.208: 96.6,95.67 96.6,87.52 105.74,78.38 105.74,75.55 121.87,59.42 145.1,59.42 145.23,59.55 145.23,61.24 145.36,61.37 145.65,61.37 145.78,61.24 v2(145.78,61.22)
  BOTTOM w0.076: UC1.AP46 102.28,108.51 v2(101.98,108.51)
  BOTTOM w0.165: v2(145.78,61.22) 145.32,61.69 145.32,63.68 145.85,64.21 JDIMM2.78
DDR_B_RAS#: length 97.3
  IN3 w0.084: v2(109.16,109.65) 109.54,109.27 109.54,107.47 109.28,107.21 109.28,101.56 108.87,101.14 108.87,98.99 108.69,98.81 108.69,98.35
  IN3 w0.208: 108.69,98.35 108.69,92.31 119.72,81.28 134.01,81.28 134.21,81.07 134.21,79.46 134.42,79.26 152.85,79.26 155.09,77.02 155.09,76.71 154.91,76.53 154.91,76.25 155.23,75.92 155.52,75.92 155.7,76.1 156.01,76.1 156.56,75.55 156.56,75.17 156.33,74.95 156.33,67.49 156.46,67.36 156.81,67.36 156.94,67.24 156.94,66.54 156.81,66.41 155.86,66.41 155.73,66.28 155.73,65.72 155.86,65.59 158.36,65.59 158.56,65.39 158.56,64.84 158.36,64.64 157.36,64.64 157.15,64.43 157.15,63.96 156.84,63.64 156.84,62.61 156.63,62.4 156.24,62.4 156.04,62.61 v2(156.04,62.75)
  BOTTOM w0.089: v2(109.16,109.65) 109.51,110 UC1.AM35
  BOTTOM w0.165: v2(156.04,62.75) 155.45,63.33 JDIMM2.110
DDR_B_WE#: length 95.8
  IN3 w0.084: 109.16,98.19 109.16,101.13 109.48,101.46 109.48,103.86 110.01,104.38 110.01,104.61 109.48,105.13 109.48,107.11 109.73,107.36 109.73,109.36 109.64,109.45 109.64,110.84 109.5,110.98 v2(109.13,110.98)
  IN3 w0.208: 109.16,98.19 109.16,92.51 119.91,81.75 134.48,81.75 134.68,81.54 134.68,79.93 134.88,79.73 135.34,79.73 135.55,79.93 135.55,81.54 135.75,81.75 136.21,81.75 136.41,81.54 136.41,79.93 136.61,79.73 153.04,79.73 157.68,75.09 157.68,74.79 157.32,74.43 157.32,74.12 157.52,73.91 157.94,73.91 158.15,73.71 158.15,73.25 157.94,73.05 157.01,73.05 156.8,72.85 156.8,72.39 157.01,72.19 157.94,72.19 158.15,71.98 158.15,71.53 157.94,71.32 157.01,71.32 156.8,71.12 156.8,69.21 157,69.02 157.24,69.02 v2(157.43,69.21)
  BOTTOM w0.076: v2(109.13,110.98) 109.46,111.31 UC1.AK35
  BOTTOM w0.165: JDIMM2.113 156.35,70.29 v2(157.43,69.21)
DDR_CKE0_DIMMA: length 74.6
  IN1 w0.084: 97.69,95.67 97.69,96.05 99.95,98.31 100.9,98.31 103.98,101.39 103.98,106.17 v2(103.56,106.59)
  IN1 w0.183: v2(65.15,70.69) 64.56,71.28 64.56,73.22 65.15,73.81 65.15,75.68 65.87,76.4 66.18,76.4 67.16,77.38 67.16,77.64 66.62,78.17 66.62,78.36 66.95,78.69 67.21,78.69 67.75,78.15 67.93,78.15 68.27,78.49 68.27,78.67 67.73,79.21 67.73,79.47 67.99,79.73 68.25,79.73 68.79,79.19 68.97,79.19 69.3,79.52 69.3,79.7 68.76,80.25 68.76,80.5 71.6,83.34 87.31,83.34 93.3,89.32 93.55,89.32 94.37,88.5 94.55,88.5 94.89,88.84 94.89,89.02 94.07,89.83 94.07,90.09 94.33,90.35 94.59,90.35 95.37,89.57 95.62,89.57 97.69,91.63 97.69,95.67
  BOTTOM w0.076: UC1.AU43 103.7,106.59 v2(103.56,106.59)
  BOTTOM w0.165: JDIMM1.73 65.8,71.34 v2(65.15,70.69)
DDR_CKE1_DIMMA: length 74.3
  IN1 w0.084: 97.22,95.67 97.22,96.1 98.44,97.32 98.64,97.32 99.86,98.54 100.82,98.54 102.91,100.63 102.91,101.52 103.15,101.77 103.15,104.9 v2(103.54,105.29)
  IN1 w0.183: v2(66.45,62.71) 66,63.16 66,64.89 64.89,66 64.89,69.01 64.1,69.8 64.1,73.7 64.61,74.21 64.61,75.79 65.84,77.02 65.84,78.23 71.4,83.8 87.02,83.8 94.21,90.98 96.38,90.98 97.22,91.82 97.22,95.67
  BOTTOM w0.076: v2(103.54,105.29) 103.56,105.29 103.86,105.59 UC1.AW43
  BOTTOM w0.165: JDIMM1.74 66.1,63.81 66.01,63.72 66.01,63.15 v2(66.45,62.71)
DDR_CKE2_DIMMB: length 83.2
  IN3 w0.084: v2(101.12,103.6) 101.57,103.16 101.57,102.1 101.06,101.59 101.06,98.48 100.8,98.22 100.8,96.38 100.3,95.87 100.3,95.67
  IN3 w0.208: 100.3,95.67 100.3,88.83 114.45,74.68 114.45,74.42 113.38,73.35 113.38,72.93 118.48,67.82 118.66,67.82 119.13,68.29 119.31,68.29 119.74,67.86 119.74,67.67 119.29,67.21 119.27,67.21 119.27,67.03 119.72,66.58 119.96,66.58 120.44,67.06 126.57,67.06 127.05,66.58 127.5,66.58 127.98,67.06 128.41,67.06 128.89,66.58 129.16,66.58 129.65,67.06 130.15,67.06 130.63,66.58 131.07,66.58 131.55,67.06 131.92,67.06 132.4,66.58 135.35,66.58 135.83,67.06 139.93,67.06 140.43,67.55 141.19,67.55 141.32,67.42 141.32,66.7 141.44,66.58 142.38,66.58 142.51,66.7 142.51,69.08 142.64,69.21 v2(143.32,69.21)
  BOTTOM w0.076: v2(101.12,103.6) 100.8,103.92 UC1.AY49
  BOTTOM w0.165: v2(143.32,69.21) 143.32,70.95 144.35,71.98 JDIMM2.73
DDR_CKE3_DIMMB: length 85.3
  IN3 w0.084: 99.67,95.67 99.28,96.07 99.28,97.21 100.89,98.82 100.89,102.7 v2(101.18,103)
  IN3 w0.208: 99.67,95.67 99.67,88.79 112.45,76.02 112.45,75.84 111.28,74.67 111.28,74.36 111.58,74.06 111.89,74.06 113.06,75.23 113.24,75.23 113.67,74.79 113.67,74.61 112.5,73.44 112.5,73.14 119.53,66.11 143.96,66.11 144.09,66.23 144.09,67.77 143.92,67.93 143.57,67.93 v2(143.32,67.68)
  BOTTOM w0.076: v2(101.18,103) 99.69,104.5 99.69,106.7 UC1.AU50
  BOTTOM w0.165: JDIMM2.74 144.65,66.35 v2(143.32,67.68)
DDR_CS0_DIMMA#: length 76.1
  IN1 w0.084: 111.79,97.4 111.8,97.39 111.8,96.58 ; 110.88,108.44 v2(110.1,108.44)
  IN1 w0.089: 111.79,97.4 111.58,97.61 111.58,107.74 110.88,108.44
  IN1 w0.183: v2(77.63,62.71) 78.84,63.92 98.95,63.92 104.74,69.7 104.74,72.79 106.1,74.15 106.1,75.76 111.8,81.45 111.8,96.58
  BOTTOM w0.089: UC1.AP33 110.37,108.7 110.11,108.44 v2(110.1,108.44)
  BOTTOM w0.165: JDIMM1.114 78.1,63.18 v2(77.63,62.71)
DDR_CS1_DIMMA#: length 77.1
  IN1 w0.084: 109.61,104.13 109.61,103.94 110.83,102.73 110.83,98.53 109.5,97.2 109.5,96.58
  IN1 w0.089: v2(111.06,107.73) 110.6,107.26 109.74,107.26 109.33,106.86 109.33,105.25 109.61,104.96 109.61,104.13
  IN1 w0.183: v2(80.51,69.2) 81.51,69.2 81.63,69.08 81.63,68.35 82.31,67.67 90.24,67.67 90.42,67.48 90.42,66.77 90.55,66.64 91.03,66.64 91.15,66.77 91.15,67.48 91.34,67.67 93.16,67.67 93.35,67.48 93.35,66.77 93.47,66.64 93.95,66.64 94.08,66.77 94.08,67.48 94.26,67.67 96.27,67.67 96.46,67.48 96.46,66.85 96.64,66.66 97.01,66.66 97.19,66.85 97.19,67.48 97.37,67.67 99.51,67.67 100.86,69.02 100.86,72.25 103.4,74.79 103.4,76.25 109.5,82.34 109.5,96.58
  BOTTOM w0.076: v2(111.06,107.73) 111.39,108.05 UC1.AR32
  BOTTOM w0.165: JDIMM1.121 80.2,72.44 81.22,71.42 81.22,69.92 v2(80.51,69.2)
DDR_CS2_DIMMB#: length 90.5
  IN3 w0.084: 111.29,98.05 111.29,103.04 111.63,103.39 111.63,109.12 111.04,109.71 v2(111.03,109.71)
  IN3 w0.208: v2(157.56,62.75) 160.28,65.47 160.28,75.57 153.98,81.87 150.02,81.87 148,83.88 120.8,83.88 111.29,93.39 111.29,98.05
  BOTTOM w0.089: UC1.AM32 111.32,110 v2(111.03,109.71)
  BOTTOM w0.165: v2(157.56,62.75) 156.65,63.66 JDIMM2.114
DDR_CS3_DIMMB#: length 90.3
  IN3 w0.084: v2(111.04,110.98) 110.85,111.17 110.77,111.17 110.65,111.06 110.65,109.48 110.8,109.34 111.17,109.34 111.44,109.06 111.44,107.4 110.84,106.8 110.84,105.37 111.44,104.76 111.44,103.47 111.03,103.05 111.03,98.03 110.77,97.78 110.52,97.78 110.4,97.66 110.4,97.2
  IN3 w0.208: 110.4,97.2 110.82,96.78 110.82,93.19 120.6,83.41 147.81,83.41 148.44,82.78 148.44,81.71 148.75,81.4 153.79,81.4 159.81,75.37 159.81,70.56 159.42,70.17 159.42,69.83 159.81,69.44 159.81,69.02 159.68,68.89 159.27,68.89 v2(158.96,69.21)
  BOTTOM w0.076: v2(111.04,110.98) 111.36,111.31 UC1.AK32
  BOTTOM w0.165: v2(158.96,69.21) 159.6,69.86 159.6,71.04 158.94,71.71 158.94,72.16 158.75,72.34 JDIMM2.121
DDR_PG_CTRL: length 136.1
  TOP w0.102: U2303.2 v1(74.17,53.49) 46.04,53.49 38.89,60.64 38.89,73.15 39.78,74.04 v2(39.78,74.66)
  BOTTOM w0.076: UC1.AV61 92.5,106.52 92.44,106.58 92.16,106.58 92.15,106.57 91.12,106.57
  BOTTOM w0.089: 88.23,101.66 88.23,103.68 88.55,104
  BOTTOM w0.102: 91.12,106.57 88.55,104 ; v2(39.78,74.66) 39.78,76.51 40.16,76.89 48.86,76.89 55.97,84 86.01,84 88.23,86.22 88.23,101.66
DDR_XDP_SMBCLK_R1: length 2.9
  BOTTOM w0.102: RP46.7 60.1,93.01 60.29,93.21 60.29,94.07 60.2,94.16 JXDP1.53
DDR_XDP_SMBDAT_R1: length 2.9
  BOTTOM w0.102: RP46.8 60.6,93.08 60.49,93.18 60.49,93.95 60.7,94.16 JXDP1.51
DDR_XDP_WLAN_TP_SMBCLK: length 423.6
  TOP w0.102: v2(63.27,110.24) 62.3,111.22 JTP.5 ; v2(146.46,112.57) 147.8,112.57 149.95,114.72 149.95,117.63 149.45,118.13 149.45,119.69 145.77,123.37 145.77,126.81 146.83,127.87 146.83,131 148.27,132.44 150.43,132.44 151.63,133.64 151.63,134.27 151.13,134.77 150.75,134.77 v2(150.52,134.55) 150.36,134.71 148.71,134.71 147.17,136.26 137.16,136.26 135.2,138.22 132.62,138.22 132.48,138.08 129.34,138.08 126.97,140.45 126.97,147.18 v2(123.03,151.12)
  IN2 w0.127: v2(144.94,55.41) 144.62,55.73 144.62,57.77 144.36,58.02 144.36,61.68 144.62,61.94 144.62,64.42 144.55,64.48 144.55,68.01 144.05,68.52 144.05,75.26 144.85,76.06 144.85,107.24 146.65,109.04 146.65,112.38 v2(146.46,112.57)
  IN3 w0.127: v2(150.52,134.55) 150.66,134.69 151.22,134.69 152.24,135.7 152.24,138.62 158.78,145.16 158.78,154.17 165.49,160.87 188.9,160.87 191.48,163.45 198.44,163.45 198.9,163.9 198.9,164.25 v2(199.1,164.45) ; v2(63.27,110.24) 63.96,109.55 63.96,104.64 64.69,103.9 64.69,101.1 65.39,100.4 65.39,98.63 64.42,97.65 64.42,94.04 63.83,93.45 63.83,88.78 64.16,88.44 v2(64.16,88.22) 64.16,81.08 69.87,75.38 69.87,74.11 71.37,72.6 71.37,58.13 73.82,55.69 102.68,55.69 v2(103.34,55.03) 104.15,55.84 144.51,55.84 v2(144.94,55.41) 145.51,55.98 171.35,55.98 171.96,55.38 177.3,55.38 178.86,56.94 180.48,56.94 184.7,61.15 184.7,62.49 v2(186.33,64.13)
  BOTTOM w0.102: RX6.1 198.92,164.8 198.92,164.63 v2(199.1,164.45) ; v2(64.16,88.22) 63.76,87.81 60.54,87.81 60.1,88.26 RP46.2 ; JMINI.30 107.1,148.83 108.4,147.53 118.45,147.53 122.04,151.12 v2(123.03,151.12) ; JDIMM1.202 104.5,64.14 104.3,63.94 104.3,60.13 103.34,59.17 v2(103.34,55.03) ; v2(186.33,64.13) 185.44,63.23 183.67,63.23 183.05,63.86 JDIMM2.202 ; R2332.2 146.97,112.07 v2(146.46,112.57) 146.46,112.58 144.99,112.58 144.74,112.33 QC1.1
DDR_XDP_WLAN_TP_SMBDAT: length 427
  TOP w0.102: v2(145.71,109.51) 145.71,109.5 146.47,110.26 148.53,110.26 149.63,109.16 150.93,109.16 151.64,109.87 151.64,116.26 149.68,118.22 149.68,119.78 146,123.46 146,126.72 147.06,127.78 147.06,130.91 148.36,132.21 150.52,132.21 151.86,133.54 151.86,134.37 151.22,135 150.65,135 v2(150.52,135.13) 150.33,134.94 148.81,134.94 147.26,136.49 137.25,136.49 135.3,138.44 132.52,138.44 132.38,138.31 129.43,138.31 127.19,140.55 127.19,147.28 123.47,151 123.47,151.31 v2(123.03,151.75) ; JTP.6 v2(63.3,110.9)
  IN2 w0.127: v2(144.17,55.42) 144.36,55.61 144.36,57.66 144.11,57.91 144.11,61.79 144.36,62.04 144.36,64.31 144.3,64.38 144.3,67.91 143.79,68.41 143.79,75.36 144.59,76.16 144.59,107.34 146.02,108.76 146.02,109.21 v2(145.71,109.51)
  IN3 w0.127: v2(63.3,110.9) 62.77,110.37 62.77,109.98 63.7,109.05 63.7,104.54 64.43,103.81 64.43,101 65.13,100.3 65.13,98.73 64.16,97.76 64.16,94.14 63.57,93.55 63.57,88.23 v2(63.58,88.22) 63.58,81.29 69.61,75.27 69.61,59.47 74.05,55.03 v2(102.69,55.03) 103.36,54.36 105.06,54.36 106.28,55.58 144.01,55.58 v2(144.17,55.42) 144.6,54.99 146.9,54.99 147.63,55.72 171.25,55.72 171.85,55.12 177.41,55.12 178.96,56.68 180.58,56.68 185.07,61.16 185.07,62.26 v2(186.32,63.52) ; v2(198.52,164.48) 198.64,164.35 198.64,164.01 198.34,163.71 191.37,163.71 188.79,161.13 165.38,161.13 158.52,154.27 158.52,145.27 151.98,138.73 151.98,135.81 151.12,134.94 150.71,134.94 v2(150.52,135.13)
  BOTTOM w0.102: RX31.1 198.7,164.81 198.7,164.66 v2(198.52,164.48) ; JDIMM1.200 103.9,64.16 104.07,63.98 104.07,60.23 102.69,58.84 v2(102.69,55.03) ; RP46.1 60.6,90.48 60.35,90.23 60.35,88.64 60.78,88.22 v2(63.58,88.22) ; v2(186.32,63.52) 185.72,62.92 183.62,62.92 182.45,64.09 JDIMM2.200 ; JMINI.32 107.9,148.6 108.74,147.76 118.35,147.76 122.35,151.75 v2(123.03,151.75) ; v2(145.71,109.51) 146.04,109.84 QC1.4 146.64,110.18 146.71,110.1 R2331.2
DEVSLP0: length 141.7
  TOP w0.089: RC11.1 132.02,120.32 v2(132.23,120.54)
  TOP w0.102: RS8.1 218.71,51.58 217.96,50.83 214.6,50.83 214.01,51.41 v1(209.2,51.41) 202.34,51.41 201.74,52.01 199.86,52.01 199.19,52.68 197.67,52.68 196.99,52.01 196.31,52.01 194.97,50.67 v2(193.39,50.67)
  IN1 w0.084: 137.53,122.6 136.85,122.6 135.33,121.08 132.78,121.08 v2(132.23,120.54)
  IN1 w0.127: v2(193.39,50.67) 192.92,51.13 192.92,52.36 193.07,52.5 193.07,56.52 192.37,57.21 192.37,58.24 190.88,59.73 190.88,66.77 189.81,67.84 189.81,77.88 182.91,84.78 178.89,84.78 173.85,89.81 167.68,89.81 165.24,92.25 165.24,94.05 154.71,104.57 154.71,106.4 153.64,107.47 153.64,110.32 145.52,118.44 145.52,120.35 143.27,122.6 137.53,122.6
  BOTTOM w0.076: UC1.P2 130.08,120.06 131.53,120.06 132.01,120.54 v2(132.23,120.54)
DGPU_HOLD_RST#: length 40.6
  TOP w0.089: v2(128.68,119.94) 128.68,120.44 RC77.2
  TOP w0.102: v2(153.1,112.32) v1(153.1,111.72)
  IN1 w0.084: v2(128.68,119.94) 129.5,120.77 131.07,120.77 131.9,121.6 135.04,121.6 136.29,122.85 137.3,122.85
  IN1 w0.127: v2(153.1,112.32) 152.9,112.32 150.17,115.05 150.17,116.17 143.49,122.85 137.3,122.85
  IN3 w0.127: v2(158.82,110.42) 158.38,110.86 156.75,110.86 155.29,112.32 v2(153.1,112.32)
  BOTTOM w0.089: UC1.N4 128.33,120.29 128.61,120.01 v2(128.68,119.94)
  BOTTOM w0.102: v2(158.82,110.42) 158.65,110.42 158.31,110.76 158.31,111.03 158.38,111.1 UV13.1
DGPU_PRSNT#: length 13.4
  TOP w0.089: RC99.1 134.37,117.9 RC100.2 135.08,119.55 v2(135.22,119.69) v1(135.85,119.69)
  IN3 w0.084: v2(126.02,119.79) 126.44,119.37 127.92,119.37 128.11,119.56 129.95,119.56 130.56,120.17 134.74,120.17 v2(135.22,119.69)
  BOTTOM w0.089: UC1.R7 126.34,119.46 v2(126.02,119.79)
DGPU_PWROK: length 167.7
  TOP w0.102: UE1.18 189.99,38.72 189.92,38.79 189.92,39.2 v2(190.33,39.6)
  IN1 w0.127: v2(209,45.87) 208.99,45.88 v2(208.99,55.56) ; v2(136.81,118.73) 138.47,118.73 140.66,120.92 143.27,120.92 143.59,120.6 143.59,119.65 153.14,110.1 153.14,107.26 154.21,106.19 154.21,104.36 164.74,93.84 164.74,91.15 167.53,88.36 174.23,88.36 178.57,84.01 182.59,84.01 189.04,77.56 189.04,67.53 190.12,66.45 190.12,59.41 190.99,58.54 190.99,56.75 191.72,56.02 191.72,52.76 192.16,52.31 192.16,49.66 191.83,49.33 191.83,46.61 192.17,46.28 192.17,41.44 v2(190.33,39.6)
  IN3 w0.084: v2(126.52,117.91) 126.63,117.91 127.09,118.37 127.47,118.37 127.55,118.44 128.07,118.44 128.48,118.04 130.52,118.04 132,119.51 133.62,119.51 134.17,118.96 136.58,118.96 v2(136.81,118.73)
  BOTTOM w0.089: v2(126.52,117.91) 126.99,118.38 UC1.U6 ; RC73.2 137.13,119.05 v2(136.81,118.73)
  BOTTOM w0.102: v2(190.33,39.6) 190.33,40.5 195.7,45.87 v1(205.22,45.87) v2(209,45.87)
  BOTTOM w0.203: PU800.2 206.19,56.92 206.66,56.45
  BOTTOM w0.254: v2(208.99,55.56) PR808.2 208.63,55.88 207.23,55.88 206.66,56.45
DH_1.35V: length 4.7
  TOP w1.016: 154.78,25.4 153.38,24 153.38,21.32
  vias: v1(155.27,26.2) v3(153.13,20.38) v3(153.77,20.38) v3(155.74,25.78) v3(156.12,26.29)
DH_CHG: length 16.8
  TOP w0.102: v2(145.16,171.5) v1(145.16,172.54)
  IN1 w1.016: 163.8,171.63 152.94,171.63 152.56,171.25 ; 146.07,171.25 146.07,171.25 150.46,171.25
  vias: v2(145.16,170.87) v2(151.5,171.57) v2(151.5,170.93) v2(164.74,171.31) v2(165.32,171.31)
DISPOFF#: length 20.9
  TOP w0.102: v1(214.36,168.93) DX1.1 215.87,169.47 v2(216.32,169.93) RX9.1
  IN1 w0.127: v2(216.32,169.93) 219.1,169.93 224.44,175.26 228.5,175.26 v2(229.07,174.69)
  BOTTOM w0.102: JLVDS.37 230.51,175.17 230.22,174.88 229.26,174.88 v2(229.07,174.69)
DL_1.35V: length 7.3
  IN3 w1.016: 157.52,22.04 157.52,15.36 157.06,14.91
  vias: v1(157.52,23.26) v2(156.73,13.93) v2(157.32,13.93) v3(157.45,24.45) v3(157.45,23.81)
DL_CHG: length 5.4
  TOP w1.016: 166.14,175.19 164.18,177.15 v1(163.76,177.15) 161.57,177.15
DPB_HPD: length 198.7
  IN2 w0.089: v2(127.28,129.85) 130.08,127.05 130.08,121.2 131.6,119.68 131.6,118.8 133.19,117.2 133.19,116.8 132.73,116.34 130.84,116.34 130.27,115.76 130.27,114.81 131.51,113.57 132.94,113.57 133.18,113.34 133.18,112.63 131.45,110.9 131.45,109.82 130.11,108.48 130.11,102.69 129.83,102.41 128.24,102.41 124.68,98.86 124.3,98.86 121.07,95.62
  IN2 w0.127: v2(36.99,94.81) 36.99,94.79 42.5,89.28 42.5,78.23 43.65,77.08 47.67,77.08 58.02,87.43 112.87,87.43 121.07,95.62
  BOTTOM w0.076: UC1.C8 125.87,126.5 125.87,127.05 126.03,127.21 126.03,127.93 126.27,128.17 126.36,128.17 127.28,129.09 v2(127.28,129.85)
  BOTTOM w0.102: QX5.3 18.51,117.23 18.55,117.27 RX14.1 19.78,117.86 24.22,117.86 24.98,117.1 34.5,117.1 38.07,113.53 38.07,108 37.3,107.24 v1(37.3,106.25) 37.3,95.13 v2(36.99,94.81)
DPC_HPD: length 10.2
  BOTTOM w0.076: UC1.A8 125.74,127.87 126.91,129.05 126.91,130.53 127.7,131.31 127.7,133.16 128.44,133.9
  BOTTOM w0.102: RC84.2 130.13,135.59 v1(129.38,134.84) 128.44,133.9
DPLL_PVSS: length 3.8
  TOP w0.254: v2(169.68,110.29) v1(169.05,110.92) 168.44,110.92 RV247.2 167.94,110.4 RV248.2
  BOTTOM w0.254: v2(169.68,110.29) 169.27,110.7 UV1.AN32
DQA0_0: length 15.5
  TOP w0.102: v2(166.59,134.67) 166.21,135.05 166.21,136.84 165.65,137.4 ; UV5.U11 161.88,146.46
  TOP w0.127: 165.65,137.4 v1(165.3,137.74) 161.28,141.77 161.28,145.85 161.62,146.19 161.88,146.46
  BOTTOM w0.102: v2(166.59,134.67) 166.22,134.3 UV1.C37
DQA0_1: length 18.3
  TOP w0.102: UV5.T11 162.68,147.26 ; 165.11,137.4 165.26,137.25 165.26,135.31 166.59,133.97 v2(166.59,133.85)
  TOP w0.127: 162.68,147.26 161.86,147.26 160.79,146.19 160.79,141.71 v1(161.65,140.85) 165.11,137.4
  BOTTOM w0.127: UV1.C35 166.97,134.31 166.97,134.23 v2(166.59,133.85)
DQA0_2: length 12.7
  TOP w0.102: v2(166.59,135.43) v1(166.59,136.43) 166.59,137 166.19,137.4
  TOP w0.127: 166.19,137.4 161.66,141.93 161.66,144.69 162.22,145.26 UV5.U13
  BOTTOM w0.102: v2(166.59,135.43) 166.92,135.1 UV1.A35
DQA0_3: length 15
  TOP w0.127: v2(167.41,134.55) 167.41,134.67 167.03,135.05 167.03,137.09 v1(164.5,139.63) 162.68,141.44 162.68,142.93 161.89,143.73 161.89,144.6 162.14,144.86 162.68,144.86 UV5.T13
  BOTTOM w0.127: UV1.E34 167.41,133.95 v2(167.41,134.55)
DQA0_4: length 18
  TOP w0.102: UV5.M11 166.28,146.86 166.68,146.46 ; 169.95,137.4 v1(169.95,136.95) 169.95,136.39 169.64,136.07 169.64,135.74 170.14,135.24 170.14,132.88 v2(169.66,132.41)
  TOP w0.127: 169.95,137.4 169.95,137.4 166.72,140.64 166.72,141.91 167.48,142.67 167.48,145.46 167.28,145.66 167.01,145.66 166.68,145.98 166.68,146.46
  BOTTOM w0.102: UV1.G32 169.26,132.01 v2(169.66,132.41)
DQA0_5: length 17
  TOP w0.102: UV5.N11 165.08,146.46 ; v2(168.39,133.42) 168.5,133.53 169.3,133.53 169.53,133.75 169.53,134.99 168.94,135.58 168.94,136.8 168.34,137.4
  TOP w0.127: 165.08,146.46 165.08,140.66 v1(166.68,139.06) 168.34,137.4
  BOTTOM w0.102: v2(168.39,133.42) 168.66,133.69 UV1.D33
DQA0_6: length 14.8
  TOP w0.102: v2(169.64,133.02) 169.93,133.32 169.93,135.16 169.38,135.71 169.38,136.32 169.52,136.46 169.52,137.3 169.42,137.4
  TOP w0.127: UV5.M13 166.68,144.86 166.68,143.09 166.27,142.67 166.27,140.55 v1(168.55,138.26) 169.42,137.4
  BOTTOM w0.102: UV1.F32 169.32,132.7 v2(169.64,133.02)
DQA0_7: length 15
  TOP w0.102: v2(168.97,133.13) 169.19,133.13 169.73,133.67 169.73,135.07 169.14,135.66 169.14,137.14 168.88,137.4
  TOP w0.127: 168.88,137.4 165.88,140.4 v1(165.88,141.02) 165.88,144.86 UV5.N13
  BOTTOM w0.102: v2(168.97,133.13) 169.35,133.5 UV1.E32
DQA0_8: length 42.8
  BOTTOM w0.102: 168.79,135.83 169.19,135.43 169.57,135.43 169.77,135.23 169.77,134.97 169.75,134.96 169.75,134.41 UV1.D31
  BOTTOM w0.127: UV4.F4 166.74,152.91 166.74,155.82 165.4,157.15 160.83,157.15 158.38,154.7 v1(158.38,154.29) 158.38,140.5 160.46,138.42 162.97,138.42 165.45,135.94 165.9,135.94 166.02,135.83 168.79,135.83
DQA0_9: length 40.5
  BOTTOM w0.102: UV1.F30 170.86,133 170.59,133.28 170.59,134.05 170.34,134.3 170.18,134.3 169.95,134.53 169.95,134.87 169.97,134.89 169.97,135.31 169.12,136.16 165.77,136.16 164.53,137.4
  BOTTOM w0.127: UV4.F2 165.94,154.41 165.94,155.58 164.75,156.77 161,156.77 158.91,154.67 v1(158.91,152.31) 158.91,140.51 160.56,138.86 163.06,138.86 164.53,137.4
DQA0_10: length 37.6
  BOTTOM w0.102: UV1.C30 170.59,134.77 170.59,135.92
  BOTTOM w0.127: 170.59,135.92 170.14,136.37 166.09,136.37 163.1,139.37 160.62,139.37 159.29,140.7 v1(159.29,149.47) 159.29,154.42 161.26,156.39 164.45,156.39 165.08,155.77 165.08,154.47 UV4.E2
DQA0_11: length 36.5
  BOTTOM w0.127: UV1.A30 170.84,135.33 170.84,136.14 170.37,136.6 166.46,136.6 162.97,140.09 160.88,140.09 v1(160.09,140.89) 159.81,141.16 159.81,154.12 161.7,156.01 163.99,156.01 164.29,155.71 164.29,154.69 164.56,154.42 164.8,154.42 165.07,154.15 165.07,152.88 UV4.E4
DQA0_12: length 30.3
  BOTTOM w0.102: 171.42,136.67 172.18,135.9 172.18,135.1 172.37,134.91 172.37,134.49 172.22,134.34 172.22,132.94 UV1.F28
  BOTTOM w0.127: 171.42,136.67 171.42,136.88 170.45,137.85 167.77,137.85 v1(166.15,139.47) 164.38,141.23 161.65,141.23 160.96,141.92 160.96,153.23 161.42,153.7 161.93,153.7 UV4.A2
DQA0_13: length 27.5
  BOTTOM w0.102: 172.18,136.72 172.66,136.24 172.66,135.54 172.97,135.23 172.97,134.97 172.66,134.67 UV1.C28
  BOTTOM w0.127: UV4.A4 161.9,152.46 161.72,152.28 161.72,142.24 161.96,142 162.3,142 162.43,142.12 162.43,142.5 162.55,142.63 162.81,142.63 162.93,142.5 162.93,142.12 163.06,142 164.69,142 168.08,138.61 v1(169.68,138.61) 170.77,138.61 172.18,137.2 172.18,136.72
DQA0_14: length 27.9
  BOTTOM w0.127: UV1.A28 172.44,135.32 172.44,136.13 171.8,136.78 171.8,137.04 170.61,138.23 167.92,138.23 v1(167.69,138.46) 164.54,141.62 161.8,141.62 161.34,142.08 161.34,152.34 161.83,152.83 162.4,152.83 162.65,153.09 162.65,153.63 UV4.B2
DQA0_15: length 28.4
  BOTTOM w0.102: UV1.E28 172.97,133.81 172.97,134.69 173.17,134.89 173.17,135.31 172.86,135.62 172.86,136.34 172.56,136.64 172.56,136.7
  BOTTOM w0.127: UV4.B4 162.7,152.07 162.14,152.07 161.95,151.87 161.95,143.51 162.46,143.01 163.19,143.01 163.32,142.88 163.32,142.5 163.44,142.38 163.76,142.38 163.89,142.5 163.89,142.86 164.02,142.99 164.27,142.99 164.4,142.86 164.4,142.5 164.52,142.38 164.85,142.38 168.24,138.99 170.93,138.99 v1(171.68,138.23) 172.56,137.36 172.56,136.7
DQA0_16: length 24
  TOP w0.127: v2(173.19,136.53) 173.64,136.98 173.64,138.28 v1(176.6,141.25) 177.27,141.92 177.27,150.14 176.3,151.1 176.3,152.18 176.17,152.31 176.17,153.14 176,153.31 175.53,153.31 175.22,153.62 174.72,153.62 UV5.B2
  BOTTOM w0.102: UV1.D27 173.76,134.2 173.76,134.57 173.77,134.57 173.77,134.83 173.75,134.84 173.75,135.97 v2(173.19,136.53)
DQA0_17: length 24.9
  TOP w0.127: UV5.A2 175.29,154.06 175.57,153.78 176.2,153.78 176.55,153.43 176.55,152.47 176.69,152.33 176.69,151.26 177.65,150.29 177.65,141.76 v1(175.09,139.2) 174.15,138.25 174.15,133.98 v2(173.51,133.34)
  BOTTOM w0.102: UV1.F26 174.06,132.79 v2(173.51,133.34)
DQA0_18: length 21.8
  TOP w0.127: v2(173.19,137.21) 172.88,137.21 172.69,137.4 172.69,138.41 174.76,140.48 v1(174.76,141) 174.76,141.34 176.51,143.1 176.51,149.82 175.5,150.83 175.5,151.77 175.18,152.09 174.66,152.09 UV5.B4
  BOTTOM w0.102: UV1.C26 174.26,134.6 173.96,134.91 173.96,136.45 v2(173.19,137.21)
DQA0_19: length 21.5
  TOP w0.127: UV5.A4 175.48,152.46 175.92,152.02 175.92,150.95 176.89,149.98 176.89,142.94 176.61,142.65 176.61,142.48 176.86,142.22 176.86,142.04 176.68,141.86 176.5,141.86 176.25,142.12 176.07,142.12 175.89,141.94 175.89,141.76 176.14,141.5 176.14,141.32 v1(173.34,138.52) 173.19,138.38 v2(173.19,137.85)
  BOTTOM w0.127: v2(173.19,137.85) 173.19,137.8 174.19,136.8 174.19,135.17 UV1.A26
DQA0_20: length 38.5
  TOP w0.127: v2(175.29,133.36) 175.29,134.74 v1(177.14,136.59) 179.94,139.39 179.94,154.37 176.87,157.43 172.22,157.43 170.82,156.03 170.82,155.72 170.64,155.53 170.64,152.91 UV5.F4
  BOTTOM w0.102: UV1.F24 175.66,132.99 v2(175.29,133.36)
DQA0_21: length 32.4
  TOP w0.102: v2(175.16,137.02) 175.54,137.4
  TOP w0.127: UV5.E4 172.34,152.91 172.34,154.21 172.59,154.46 172.88,154.46 173.14,154.72 173.14,155.72 173.47,156.05 176.64,156.05 178.8,153.89 178.8,140.66 v1(176.97,138.83) 175.54,137.4
  BOTTOM w0.102: UV1.C24 175.86,134.65 176.17,134.95 176.17,136.08 175.16,137.09 v2(175.16,137.02)
DQA0_22: length 31.3
  TOP w0.127: v2(175.17,136.44) 175.35,136.44 179.18,140.28 v1(179.18,149) 179.18,154.05 176.64,156.58 173.05,156.58 172.32,155.86 172.32,154.63 171.89,154.19 UV5.E2
  BOTTOM w0.127: UV1.A24 175.86,136.03 175.45,136.44 v2(175.17,136.44)
DQA0_23: length 34.9
  TOP w0.127: UV5.F2 171.51,154.49 171.51,156.18 172.38,157.05 176.71,157.05 179.56,154.21 v1(179.56,146.28) 179.56,139.83 175.58,135.85 v2(175.19,135.85)
  BOTTOM w0.102: v2(175.19,135.85) 175.57,135.47 175.57,135.24 175.56,135.23 175.56,133.81 UV1.E24
DQA0_24: length 15.8
  BOTTOM w0.102: 170.69,146.46 171.08,146.86 UV4.M11 ; 176.82,136 177.13,135.69 177.13,134.93 177.46,134.59 UV1.C22
  BOTTOM w0.127: 176.82,136 175.54,137.28 175.54,138.25 v1(173.62,140.17) 173.26,140.54 173.26,141.03 171.94,142.34 171.47,142.34 170.69,143.13 170.69,146.46
DQA0_25: length 13
  BOTTOM w0.127: UV1.A22 177.46,135.8 175.96,137.3 175.96,138.37 v1(175.12,139.21) 173.64,140.69 173.64,141.19 172.1,142.72 171.73,142.72 171.48,142.97 171.48,144.86 UV4.M13
DQA0_26: length 15.2
  BOTTOM w0.102: 177.7,135.94 177.71,135.94 177.71,135.49 177.77,135.43 177.77,134.97 177.77,134.97 177.77,134.92 177.75,134.91 177.75,134.49 177.77,134.48 177.77,133.21 UV1.F22
  BOTTOM w0.127: UV4.N13 171.89,145 172.28,144.6 172.28,143.08 v1(173.28,142.09) 174.02,141.34 174.02,140.85 176.4,138.47 176.4,137.24 177.7,135.94
DQA0_27: length 15.8
  BOTTOM w0.102: 177.97,136.12 177.97,134.89 177.97,134.89 177.97,134.84 177.96,134.83 177.96,134.57 178.26,134.27 UV1.D21 ; 172.28,146.45 172.28,146.46 171.89,146.86 UV4.N11
  BOTTOM w0.127: 177.97,136.12 176.94,137.15 176.94,138.47 175.11,140.3 v1(175.11,140.79) 173.09,142.82 173.09,144.64 172.83,144.9 172.56,144.9 172.28,145.17 172.28,146.45
DQA0_28: length 12.5
  BOTTOM w0.102: 179.2,136.71 178.98,136.92
  BOTTOM w0.127: UV4.T13 174.48,145.26 174.91,144.83 175.23,144.83 175.5,144.55 175.5,142.24 v1(176.46,141.28) 178.98,138.77 178.98,136.92 ; UV1.A20 179.2,135.23 179.2,136.71
