# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDBIB0_2: length 15.1
  BOTTOM w0.102: UV1.P1 192.94,126.18 193.96,126.18 194.08,126.3 194.39,126.3
  BOTTOM w0.127: UV8.P13 205.56,130.91 205.2,130.54 205.2,130.26 204.84,129.9 202.84,129.9 v1(202.13,129.19) 201.83,128.89 199.42,128.89 196.83,126.3 194.39,126.3
DDBIB0_3: length 30.8
  TOP w0.127: UV7.D2 214.36,130.84 214.81,130.39 214.81,130.07 214.99,129.89 215.44,129.89 215.97,129.36 215.97,128.1 213.26,125.39 v1(208.87,125.39) 197.02,125.39 194.6,122.97 v2(193.96,122.97)
  BOTTOM w0.102: v2(193.96,122.97) 193.31,122.32 192.68,122.32 192.58,122.42 192.32,122.42 192.23,122.33 191.89,122.33 UV1.W4
DDBIB1_0: length 29.5
  BOTTOM w0.102: UV1.AC4 191.76,119 192.09,119 192.34,119.24 192.59,119.24 192.66,119.18 193.21,119.18 193.9,119.88 194.39,119.88
  BOTTOM w0.127: 194.39,119.88 197.64,119.88 v1(201.02,123.26) 201.36,123.59 213.14,123.59 214.53,122.2 214.53,120.16 214.25,119.88 213.96,119.88 213.83,119.75 213.83,119.06 UV10.D2
DDBIB1_1: length 16.5
  TOP w0.127: v2(194.89,115.95) 194.89,115.79 195.16,115.51 195.65,115.51 195.96,115.83 195.96,116.13 v1(198.91,119.07) 199.68,119.84 202.89,119.84 203.62,119.12 204.97,119.12 UV9.P13
  BOTTOM w0.102: UV1.AH3 192.41,114.9 192.73,115.22 193.91,115.22 194.15,115.46 194.39,115.46
  BOTTOM w0.127: 194.39,115.46 v2(194.89,115.95)
DDBIB1_2: length 39.1
  TOP w0.102: v2(188.43,113.72) 188.64,113.92 190.95,113.92 191.42,113.45
  TOP w0.127: UV9.D2 214.3,110.59 214.3,110.31 214.62,110 214.62,109.67 214.8,109.49 215.25,109.49 215.78,108.96 215.78,106.92 213.46,104.61 v1(207.57,104.61) 202.15,104.61 197.25,109.51 192.82,109.51 191.42,110.91 191.42,113.45
  BOTTOM w0.102: v2(188.43,113.72) 188.51,113.72 188.86,114.07 UV1.AJ8
DDBIB1_3: length 15
  BOTTOM w0.102: UV1.AM3 192.43,111.7 192.74,111.4 193.54,111.4 193.78,111.15 194.39,111.15
  BOTTOM w0.127: 194.39,111.15 v1(197.11,111.15) 198.48,111.15 199.97,109.67 203.27,109.67 203.42,109.51 204.74,109.51 204.97,109.74 204.97,110.18 205.37,110.58 UV10.P13
DDI1_LANE_N0: length 96.9
  IN1 w0.127: v2(95.76,129.55) 95.58,129.72 95.26,129.72 93.57,128.03 87.47,128.03 85.5,126.06 84.94,126.06 83.56,124.68 81.95,124.68 80.32,123.05 74.83,123.05 68.49,116.71 47.96,116.71 44.29,113.03 42.76,113.03 31.32,101.58 24.67,101.58 24.38,101.87 24.38,102.26 v2(24.23,102.41)
  BOTTOM w0.076: v2(95.76,129.55) 95.59,129.72 95.41,129.72 95.34,129.65 95.34,129.19 95.47,129.05 96.23,128.3 96.59,127.93 96.59,127.5 96.65,127.38 96.65,127.16 96.63,127.08 96.62,127.06 96.59,127.01 96.59,126.87 96.62,126.77 96.83,126.56 97.01,126.56 97.18,126.39 UC1.C54
  BOTTOM w0.102: v2(24.23,102.41) 24.35,102.29 24.35,99.86 22.44,97.95 20.38,97.95 CX18.2
DDI1_LANE_N1: length 94.2
  IN1 w0.127: v2(23.71,100.51) 23.47,100.75 23.47,102.61 27.7,106.84 35.4,106.84 46.1,117.54 61.34,117.54 61.71,117.91 68.55,117.91 76.09,125.46 83.19,125.46 86.55,128.82 91.49,128.82 92.54,129.86 93.73,129.86 93.93,129.66 v2(93.93,129.55)
  BOTTOM w0.076: 94.11,129.83 94.16,129.88 94.28,129.88 94.36,129.8 94.36,128.67 95,128.04 95,127.28 94.96,127.24 94.87,127.24 94.83,127.2 94.83,127.05 94.87,127.01 94.97,127.01 95,126.99 95,126.86 94.88,126.74 94.88,126.65 UC1.B58
  BOTTOM w0.089: v2(93.93,129.55) 93.93,129.65 94.11,129.83
  BOTTOM w0.102: v2(23.71,100.51) 23.49,100.73 23.49,100.99 23.23,101.25 22.61,101.25 21.83,100.47 19.64,100.47 CX16.2
DDI1_LANE_N2: length 96.8
  IN1 w0.127: v2(95.76,132.15) 95.58,131.98 95.1,131.98 94.88,132.2 94.88,132.96 94.4,133.43 93.3,133.43 92.58,132.71 92.58,132.16 92.07,131.64 91.67,131.64 91.03,130.99 86.06,130.99 82.35,127.29 75.19,127.29 67.67,119.77 60.94,119.77 60.56,119.39 45.36,119.39 42.53,116.56 30.26,116.56 24.22,110.51 24.22,107.49 22.84,106.11 21.23,106.11 v2(21.06,106.28)
  BOTTOM w0.076: UC1.B55 97.15,126.92 97.37,127.14 97.37,127.84 96.34,128.86 96.34,131.55 96.34,131.71 96.16,131.9 96.01,131.9 v2(95.76,132.15)
  BOTTOM w0.102: CX14.2 20.29,106.11 20.89,106.11 v2(21.06,106.28)
DDI1_LANE_N3: length 95.4
  IN1 w0.127: v2(22.48,102.54) 22.27,102.75 22.27,103.08 25.55,106.37 25.55,110.36 30.7,115.51 42.97,115.51 45.79,118.33 60.99,118.33 61.35,118.69 68.18,118.69 75.73,126.24 82.83,126.24 86.35,129.76 91.29,129.76 92.15,130.62 92.92,130.62 93.29,131 93.29,131.54 93.42,131.67 93.78,131.67 v2(93.96,131.5)
  BOTTOM w0.076: UC1.A57 95.5,127.57 95.62,127.45 95.72,127.45 95.81,127.54 95.81,127.82 94.73,128.9 94.73,131.54 94.48,131.79 94.05,131.79 93.96,131.7 v2(93.96,131.5)
  BOTTOM w0.102: CX12.2 20.79,103.54 20.79,103.33 20.87,103.25 22.05,103.25 22.29,103.01 22.29,102.73 v2(22.48,102.54)
DDI1_LANE_P0: length 96.7
  IN1 w0.127: v2(95.76,130.2) 95.55,130 95.15,130 93.46,128.3 87.36,128.3 85.39,126.33 84.83,126.33 83.44,124.95 81.84,124.95 80.21,123.32 74.72,123.32 68.37,116.98 47.85,116.98 44.18,113.3 42.65,113.3 31.2,101.86 24.78,101.86 24.65,101.98 24.65,102.26 v2(24.81,102.41)
  BOTTOM w0.076: UC1.C55 96.57,126.55 96.47,126.7 96.43,126.85 96.43,127.04 96.44,127.07 96.49,127.19 96.49,127.3 96.43,127.46 96.43,127.83 95.34,128.92 95.24,129.01 95.15,129.11 95.15,129.73 95.33,129.91 95.47,129.91 v2(95.76,130.2)
  BOTTOM w0.102: v2(24.81,102.41) 24.57,102.17 24.57,99.77 22.53,97.73 20.25,97.73 CX19.2
DDI1_LANE_P1: length 94.5
  IN1 w0.127: v2(93.93,130.2) 93.86,130.13 92.42,130.13 91.38,129.09 86.44,129.09 83.08,125.73 75.98,125.73 68.43,118.18 61.6,118.18 61.23,117.81 45.99,117.81 35.29,107.11 27.58,107.11 23.19,102.72 23.19,100.58 v2(23.12,100.51)
  BOTTOM w0.076: 94.06,130.07 94.36,130.07 94.55,129.88 94.55,128.75 95.19,128.12 95.19,126.78 95.24,126.73 95.24,126.48 94.94,126.18 UC1.C58
  BOTTOM w0.089: 94.06,130.07 v2(93.93,130.2)
  BOTTOM w0.102: v2(23.12,100.51) 23.27,100.66 23.27,100.9 23.14,101.03 22.7,101.03 21.92,100.26 19.22,100.26 CX17.2
DDI1_LANE_P2: length 96.6
  IN1 w0.127: v2(21.06,105.7) 21.21,105.84 22.95,105.84 24.49,107.38 24.49,110.4 30.37,116.29 42.64,116.29 45.47,119.11 60.67,119.11 61.05,119.5 67.78,119.5 75.3,127.02 82.47,127.02 86.17,130.72 91.14,130.72 91.79,131.37 92.18,131.37 92.85,132.04 92.85,132.6 93.41,133.16 94.29,133.16 94.6,132.85 94.6,132.09 94.98,131.71 95.55,131.71 v2(95.76,131.5)
  BOTTOM w0.076: v2(95.76,131.5) 95.96,131.71 96.08,131.71 96.15,131.63 96.15,128.79 97.18,127.76 97.18,127.21 97.1,127.14 97.08,127.14 96.88,127.33 UC1.A55
  BOTTOM w0.102: CX15.2 20.48,105.89 20.86,105.89 v2(21.06,105.7)
DDI1_LANE_P3: length 95.6
  IN1 w0.127: v2(21.89,102.54) 21.99,102.64 21.99,103.19 25.28,106.48 25.28,110.47 30.58,115.78 42.85,115.78 45.67,118.6 60.88,118.6 61.24,118.96 68.07,118.96 75.62,126.51 82.72,126.51 86.24,130.03 91.18,130.03 92.04,130.89 92.8,130.89 93.02,131.11 93.02,131.65 93.31,131.94 93.75,131.94 v2(93.96,132.14)
  BOTTOM w0.076: v2(93.96,132.14) 94.12,131.98 94.56,131.98 94.92,131.62 94.92,128.98 96,127.9 96,127.47 95.5,126.97 UC1.B57
  BOTTOM w0.102: CX13.2 21.17,103.04 21.96,103.04 22.08,102.92 22.08,102.73 v2(21.89,102.54)
DDR3_DRAMRST#: length 122.2
  TOP w0.102: v2(90.58,52.45) 90.58,55.06 v1(88.26,57.38) 84.37,61.27 RD5.1 ; v2(51.65,60.42) 50.96,61.12 50.96,64.24 CD3.1 ; v2(130.2,60.46) 129.31,61.35 CD34.1
  BOTTOM w0.102: JDIMM2.30 129.05,61.62 v2(130.2,60.46) 130.2,57.14 124.98,51.92 91.11,51.92 v2(90.58,52.45) 90.05,51.92 60.24,51.92 51.74,60.42 v2(51.65,60.42) 50.5,61.58 JDIMM1.30
DDR3_DRAMRST#_CPU: length 99.9
  TOP w0.102: RD3.2 80.92,58.28 v2(80.93,58.3) 80.94,58.3 82.64,60 v1(82.64,60.53) 82.64,63.27 83.46,64.09 RD5.2
  BOTTOM w0.076: 122.01,99.68 121.9,99.79 121.9,102.55 121.77,102.68 121.77,103.26 121.55,103.48 121.55,104.63 121.37,104.82 121.37,105.06 121.44,105.14 121.44,105.4 121.36,105.47 121.36,105.99 UC1.AV15
  BOTTOM w0.102: 122.01,99.68 122.16,99.53 122.16,96.99 CC35.1 122.19,90.57 114.03,82.41 114.03,54.19 112.85,53.01 97.64,53.01 96.49,54.17 85.61,54.17 81.49,58.3 v2(80.93,58.3)
DDR_A_BS0: length 76.9
  IN1 w0.084: 109.12,98.54 108.87,98.54 108.04,97.71 108.03,97.71
  IN1 w0.089: v2(109.86,101.55) 109.48,101.17 109.48,100 109.38,99.9 109.38,98.8 109.12,98.54
  IN1 w0.183: 108.03,97.71 107.42,97.1 107.42,83.37 100.72,76.67 100.23,76.67 100.09,76.52 100.09,74.93 99.96,74.8 98.59,74.8 98.47,74.93 98.47,76.54 98.34,76.67 97.86,76.67 97.73,76.54 97.73,73.11 97.61,72.99 97.13,72.99 97,73.11 97,75.7 96.88,75.83 96.4,75.83 96.27,75.7 96.27,73.11 96.14,72.99 95.67,72.99 95.54,73.11 95.54,74.2 95.41,74.33 94.94,74.33 94.81,74.2 94.81,73.08 94.72,72.99 80.15,72.99 79.2,72.03 78.39,72.03 77.59,71.23 v2(77.59,70.71)
  BOTTOM w0.076: UC1.AU35 109.24,106.75 109.24,106.68 108.97,106.42 108.97,102.43 v2(109.86,101.55)
  BOTTOM w0.165: JDIMM1.109 76.6,72.13 77.59,71.14 v2(77.59,70.71)
DDR_A_BS1: length 76.3
  IN1 w0.084: 108.75,97.35 110.41,99.01 110.41,102.14 110.26,102.3 v2(109.87,102.3)
  IN1 w0.183: v2(77.59,67.66) 78.51,68.59 78.51,70.88 78.79,71.16 79.56,71.16 80.4,72 93.27,72 93.45,71.82 93.45,68.92 93.58,68.79 94.06,68.79 94.18,68.92 94.18,71.98 94.31,72.11 96.88,72.11 97,71.98 97,70.74 97.13,70.61 98.83,70.61 98.96,70.74 98.96,71.94 102.28,75.26 102.28,76.71 108.34,82.78 108.34,97.08 108.61,97.35 108.75,97.35
  BOTTOM w0.076: UC1.AV35 109.14,105.95 109.14,103.03 v2(109.87,102.3)
  BOTTOM w0.165: v2(77.59,67.66) 76.86,66.94 76.86,66.79 76.3,66.23 JDIMM1.108
DDR_A_BS2: length 73
  IN1 w0.084: v2(105.13,103.94) 104.64,103.45 104.64,101.26 101.89,98.51 101.89,98.51 101.29,97.91 100.3,97.91 98.84,96.45 98.84,95.67
  IN1 w0.183: 98.84,95.67 98.84,91.16 89.86,82.18 73.56,82.18 72.93,81.56 72.67,81.56 72.13,82.1 71.95,82.1 71.61,81.76 71.61,81.58 72.15,81.04 72.15,80.78 71.9,80.52 71.64,80.52 71.1,81.06 70.92,81.06 70.58,80.72 70.58,80.54 71.12,80 71.12,79.75 67.78,76.41 67.78,75.49 67.57,75.27 66.4,75.27 66.28,75.15 66.28,74.42 66.4,74.29 67.65,74.29 67.78,74.16 67.78,73.68 67.65,73.56 66.4,73.56 66.28,73.43 66.28,72.95 66.4,72.83 67.25,72.83 67.37,72.7 67.37,72.22 67.25,72.09 66.4,72.09 66.28,71.97 66.28,70.79 66.4,70.66 66.7,70.66 v2(66.75,70.69)
  BOTTOM w0.076: v2(105.13,103.94) 105.53,104.34 105.53,104.42 105.53,104.77 105.53,104.77 UC1.AY41
  BOTTOM w0.165: JDIMM1.79 67.6,71.54 v2(66.75,70.69)
DDR_A_CAS#: length 75.4
  IN1 w0.084: 110.65,96.58 110.65,97.26 111.19,97.81 111.19,102.88 110.26,103.81 110.26,106.19 v2(109.86,106.59)
  IN1 w0.183: v2(78.98,69.12) 79.35,68.74 79.35,68.68 79.42,68.61 79.42,67.93 79.15,67.65 79.15,66.48 80.13,65.49 98.93,65.49 102.24,68.8 102.24,71.88 104.98,74.62 104.98,76.22 110.65,81.9 110.65,96.58
  BOTTOM w0.076: v2(109.86,106.59) 110,106.59 UC1.AU34
  BOTTOM w0.165: JDIMM1.115 78.4,72.11 79.47,71.05 79.47,69.61 v2(78.98,69.12)
DDR_A_D0: length 73.5
  IN3 w0.127: v2(82.79,71.47) 82.15,71.47 82.02,71.6 82.02,72.33 81.9,72.45 78.06,72.45 77.93,72.58 77.93,72.87 78.06,72.99 80.82,72.99 80.94,73.12 80.94,73.41 80.82,73.53 78.06,73.53 77.93,73.66 77.93,73.95 78.06,74.08 79.73,74.08 79.86,74.2 79.86,74.49 79.73,74.62 78.56,74.62 78.43,74.74 78.43,75.03 78.56,75.16 79.18,75.16 79.31,75.28 79.31,75.57 79.18,75.7 78.56,75.7 78.43,75.83 78.43,76.45 73.72,81.16 73.72,95.12 74.45,95.86 74.45,101.36 76.52,103.43 76.52,107.46 79.09,110.03 84.86,110.03 v2(85.31,110.48)
  BOTTOM w0.076: 86.08,110.06 86.24,110.06 87.64,111.47 89.87,111.47 90.57,112.16 91.26,112.16 91.39,112.29 UC1.AH63
  BOTTOM w0.102: JDIMM1.129 82.6,71.66 v2(82.79,71.47) ; v2(85.31,110.48) 85.72,110.06 86.08,110.06
DDR_A_D1: length 73.8
  IN3 w0.127: v2(82.79,69.95) 81.51,69.95 81.38,69.82 81.38,69.49 81.51,69.36 82.24,69.36 82.37,69.23 82.37,68.95 82.24,68.82 81.51,68.82 81.38,68.69 81.38,67.62 81.25,67.49 80.17,67.49 79.91,67.74 79.91,71.84 79.66,72.09 77.7,72.09 77.57,72.22 77.57,76.8 73.35,81.01 73.35,95.27 74.09,96.01 74.09,101.51 76.16,103.58 76.16,107.61 78.94,110.39 83.59,110.39 84.19,110.99 86.35,110.99 v2(86.37,110.96)
  BOTTOM w0.076: v2(86.37,110.96) 86.9,110.96 87.6,111.66 89.83,111.66 90.5,112.33 91.19,112.33 91.45,112.59 91.72,112.59 91.9,112.49 92.1,112.49 UC1.AH62
  BOTTOM w0.102: JDIMM1.131 83.2,70.35 v2(82.79,69.95)
DDR_A_D2: length 71.9
  IN3 w0.084: v2(88.58,110.07) 89.2,109.45 89.2,108.87 87.34,107 87.34,106.94 87.12,106.73
  IN3 w0.127: v2(86.53,69.95) 86.22,69.95 86.11,70.06 86.11,71.96 83.17,74.89 83.17,75.58 77.05,81.7 77.05,97.04 77.99,97.98 77.99,98.22 77.44,98.78 77.44,98.96 77.69,99.21 77.87,99.21 78.89,98.18 79.07,98.18 79.27,98.39 79.27,98.57 78.25,99.59 78.25,99.77 78.45,99.97 78.63,99.97 80.18,98.42 80.36,98.42 80.56,98.63 80.56,98.81 79.4,99.97 79.02,100.35 79.02,100.53 80.04,101.56 81.95,101.56 84.91,104.52 84.91,104.71 84.51,105.1 84.51,105.28 84.72,105.48 84.9,105.48 85.29,105.09 85.48,105.09 85.68,105.28 85.68,105.47 84.93,106.21 84.93,106.39 85.14,106.6 85.32,106.6 86.06,105.85 86.25,105.85 86.44,106.05 86.44,106.24 85.7,106.98 85.7,107.15 85.91,107.36 86.08,107.36 86.82,106.62 87.01,106.62 87.12,106.73
  BOTTOM w0.076: UC1.AK63 91.52,110.81 91.25,110.81 91.01,110.57 89.56,110.57 89.07,110.07 v2(88.58,110.07)
  BOTTOM w0.102: v2(86.53,69.95) 86.08,70.4 86.08,71.94 86.2,72.06 JDIMM1.141
DDR_A_D3: length 72.6
  IN3 w0.127: v2(85.3,63.47) 86.31,63.47 86.43,63.6 86.43,65.77 86.31,65.9 85.16,65.9 85.04,66.03 85.04,66.88 85.16,67 86.64,67 86.77,67.13 86.77,67.42 86.64,67.55 85.16,67.55 85.04,67.67 85.04,67.96 85.16,68.09 86.64,68.09 86.77,68.21 86.77,68.5 86.64,68.63 85.88,68.63 85.74,68.76 85.74,71.81 82.81,74.74 82.81,75.43 76.69,81.55 76.69,98.72 79.89,101.92 81.8,101.92 84.15,104.27 84.15,106.13 84.72,106.69 84.72,106.88 84.26,107.35 84.26,107.53 84.46,107.73 84.64,107.73 85.1,107.27 85.29,107.27 85.75,107.72 86.97,107.72 87.53,108.28 87.53,108.45 87.74,108.65 v2(87.74,109.23)
  BOTTOM w0.076: v2(87.74,109.23) 88.28,109.23 88.71,109.66 88.89,109.66 89.63,110.4 91.08,110.4 91.32,110.65 91.77,110.65 92.06,110.94 UC1.AK62
  BOTTOM w0.102: v2(85.3,63.47) 85.9,64.07 JDIMM1.140
DDR_A_D4: length 74.4
  IN3 w0.127: v2(83.44,61.95) 83.44,62.11 78.36,67.19 78.36,70.82 77.21,71.97 77.21,76.65 72.99,80.86 72.99,95.42 73.73,96.16 73.73,101.67 75.79,103.73 75.79,107.76 78.79,110.75 83.44,110.75 84.05,111.36 86.64,111.36 v2(86.76,111.47)
  BOTTOM w0.076: v2(86.76,111.47) 87.11,111.82 89.76,111.82 90.44,112.5 91.13,112.5 91.38,112.75 91.76,112.75 91.8,112.73 91.9,112.68 92.57,112.68 UC1.AH61
  BOTTOM w0.102: JDIMM1.132 83.5,64.09 83.98,63.62 83.98,62.48 v2(83.44,61.95)
DDR_A_D5: length 74.8
  IN3 w0.127: v2(86.5,109.66) 79.24,109.66 76.88,107.31 76.88,102.33 76.35,101.8 75.54,101.8 74.82,101.07 74.82,95.71 74.08,94.97 74.08,81.32 79.95,75.44 79.95,74.95 83.4,71.5 83.4,69.21 83.58,69.03 84.02,69.03 84.15,68.9 84.15,68.63 84.02,68.49 83.58,68.49 83.45,68.36 83.45,68.08 83.58,67.95 84.02,67.95 84.15,67.82 84.15,67.54 84.02,67.41 83.58,67.41 83.45,67.27 83.45,67 83.58,66.87 84.02,66.87 84.15,66.73 84.15,66.46 84.02,66.33 83.58,66.33 83.45,66.19 83.45,65.92 83.58,65.79 83.9,65.79 84.03,65.66 84.03,65.37 83.9,65.25 83.58,65.25 83.45,65.11 83.45,63.47 v2(83.44,63.47)
  BOTTOM w0.076: 87.12,109.66 87.47,109.66 88.72,110.92 90.89,110.92 91.12,111.15 91.21,111.15 91.46,111.4 91.75,111.4 91.91,111.33 92.04,111.33 92.2,111.4 92.4,111.4 92.45,111.37 92.54,111.33 92.56,111.33 92.75,111.33 92.76,111.34 93.14,111.34 93.15,111.33 93.4,111.33 93.6,111.53 UC1.AH60
  BOTTOM w0.102: 87.12,109.66 v2(86.5,109.66) ; v2(83.44,63.47) 82.9,64.01 JDIMM1.130
DDR_A_D6: length 73.2
  IN3 w0.084: v2(88.88,110.55) 88.88,110.83 89,110.96 89.8,110.96 89.93,110.83 89.93,109.35 87.71,107.13 87.71,106.8 87.12,106.21
  IN3 w0.127: 87.12,106.21 85.36,104.45 85.36,104.12 85.84,103.64 85.84,103.39 85.57,103.12 85.38,103.12 84.8,103.7 84.61,103.7 84.42,103.51 84.42,103.32 85,102.73 85,102.55 84.8,102.35 84.62,102.35 84.03,102.93 83.84,102.93 83.65,102.74 83.65,102.55 84.24,101.96 84.24,101.79 84.03,101.58 83.85,101.58 83.27,102.17 83.08,102.17 82.88,101.98 82.88,101.79 83.47,101.2 83.47,101.02 83.27,100.82 83.09,100.82 82.5,101.4 82.31,101.4 82.12,101.21 82.12,101.02 82.7,100.44 82.7,100.25 82.51,100.06 82.32,100.06 81.18,101.2 81,101.2 80.79,100.99 80.79,100.81 81.93,99.67 81.93,99.48 81.74,99.29 81.55,99.29 80.5,100.34 80.32,100.34 80.11,100.14 80.11,99.96 81.17,98.91 81.17,98.72 80.27,97.82 78.35,97.82 77.42,96.88 77.42,81.85 83.54,75.73 83.54,75.04 86.53,72.05 v2(86.53,71.47)
  BOTTOM w0.076: v2(88.88,110.55) 89.06,110.73 90.94,110.73 91.19,110.98 91.27,110.98 91.53,111.23 91.71,111.23 91.82,111.18 91.87,111.16 92.08,111.16 92.13,111.18 92.13,111.19 92.22,111.23 92.23,111.23 92.37,111.23 92.42,111.21 92.47,111.18 92.61,111.05 UC1.AK61
  BOTTOM w0.102: JDIMM1.143 86.8,72.16 87.35,71.61 87.35,71.43 87.05,71.13 86.87,71.13 v2(86.53,71.47)
DDR_A_D7: length 74.2
  IN3 w0.084: 86.58,108.09 v2(87.3,108.81)
  IN3 w0.127: 86.58,108.09 83.95,108.09 83.79,107.93 83.79,104.42 81.65,102.29 79.74,102.29 76.33,98.87 76.33,81.21 81.82,75.72 81.82,75.22 85.38,71.66 85.38,68.85 84.67,68.14 84.67,65.65 84.8,65.52 85.97,65.52 86.07,65.42 86.07,65.11 85.94,64.98 84.83,64.98 84.74,64.88 84.74,64.57 84.86,64.44 85.97,64.44 86.07,64.34 86.07,64.03 85.94,63.9 85.01,63.9 84.88,63.77 84.88,62.07 85.01,61.95 v2(85.3,61.95)
  BOTTOM w0.076: v2(87.3,108.81) 88.1,108.81 88.72,109.43 88.91,109.43 89.71,110.24 91.15,110.24 91.39,110.48 91.84,110.48 92,110.65 92.42,110.65 92.55,110.78 92.81,110.78 92.83,110.76 93.07,110.76 93.36,111.05 UC1.AK60
  BOTTOM w0.102: v2(85.3,61.95) 86.5,63.14 JDIMM1.142
DDR_A_D8: length 89
  IN1 w0.084: 87.57,107.47 87.72,107.62 88.51,107.62 88.64,107.49 v2(88.64,107.47)
  IN1 w0.127: v2(42.19,69.93) 41.78,70.35 41.78,76.89 41.9,77.02 42.34,77.02 42.47,77.14 42.47,77.4 42.34,77.53 41.9,77.53 41.78,77.65 41.78,77.91 41.9,78.03 42.34,78.03 42.47,78.16 42.47,78.41 42.34,78.54 41.9,78.54 41.78,78.67 41.78,78.92 41.9,79.05 42.34,79.05 42.47,79.18 42.47,79.43 42.34,79.56 41.9,79.56 41.78,79.68 41.78,79.94 41.9,80.07 42.57,80.07 42.7,80.19 42.7,84.59 44.51,86.4 44.69,86.4 45.15,85.94 45.33,85.94 45.51,86.12 45.51,86.3 45.05,86.76 45.05,86.94 45.23,87.12 45.41,87.12 45.87,86.66 46.05,86.66 46.23,86.84 46.23,87.02 45.77,87.48 45.77,87.66 45.95,87.84 46.13,87.84 46.59,87.37 46.77,87.37 46.95,87.55 46.95,87.73 46.49,88.2 46.49,88.38 47.16,89.05 47.4,89.05 47.76,88.7 48.09,88.7 61.04,101.64 61.4,101.64 61.95,102.2 74.25,102.2 75.42,103.37 78.2,103.37 78.32,103.24 78.32,102.58 78.45,102.45 81.85,102.45 86.87,107.47 87.57,107.47
  BOTTOM w0.076: v2(88.64,107.47) 88.64,108.06 89.37,108.78 89.37,109.09 90,109.73 91.34,109.73 91.47,109.86 UC1.AM63
  BOTTOM w0.102: JDIMM1.7 43.6,71.34 42.76,70.5 v2(42.19,69.93)
DDR_A_D9: length 89.9
  IN1 w0.084: v2(88.43,108.63) 87.87,108.63 87.68,108.44 86.96,108.44
  IN1 w0.127: 86.96,108.44 83.79,108.44 83.24,108.99 79.42,108.99 73.34,102.91 61.69,102.91 61.11,102.33 60.75,102.33 48.17,89.74 46.88,89.74 42.02,84.88 42.02,81.15 41.09,80.22 41.09,69.95 41.34,69.7 41.34,69.23 41.34,66.79 42.68,65.46 42.68,61.8 42.76,61.71 43.04,61.71 v2(43.27,61.95)
  BOTTOM w0.076: UC1.AM62 92.06,109.86 91.77,110.15 91.53,110.15 91.27,109.9 89.93,109.9 89.2,109.16 89.2,108.85 88.98,108.63 v2(88.43,108.63)
  BOTTOM w0.102: v2(43.27,61.95) 42.7,62.52 JDIMM1.4
DDR_A_D10: length 88.2
  IN1 w0.084: v2(89.26,105.95) 89.25,105.95 87.99,105.95 87.12,105.08
  IN1 w0.127: v2(44.22,69.93) 44.22,69.7 44.09,69.57 43.89,69.57 43.77,69.7 43.77,71.77 43.89,71.89 44.21,71.89 44.34,72.02 44.34,72.27 44.21,72.4 43.89,72.4 43.77,72.53 43.77,72.78 43.89,72.91 44.21,72.91 44.34,73.04 44.34,73.29 44.21,73.42 43.89,73.42 43.77,73.54 43.77,73.8 43.89,73.93 44.21,73.93 44.34,74.05 44.34,74.33 44.24,74.43 43.89,74.43 43.77,74.56 43.77,75.81 43.89,75.93 44.21,75.93 44.33,76.06 44.33,78.96 45.85,80.48 45.85,82.46 47.33,83.93 47.33,84.63 47.78,85.09 47.78,85.27 47.65,85.4 47.65,85.62 47.84,85.8 48.02,85.8 48.52,85.3 48.7,85.3 48.88,85.48 48.88,85.66 48.38,86.16 48.38,86.34 52.05,90.01 52.53,90.01 62.7,100.19 74.58,100.19 74.7,100.07 74.7,99.82 74.83,99.69 75.08,99.69 75.21,99.82 75.21,100.02 75.34,100.14 75.59,100.14 75.72,100.02 75.72,99.82 75.85,99.69 76.1,99.69 76.23,99.82 76.23,100.02 76.35,100.14 76.61,100.14 76.73,100.02 76.73,99.82 76.86,99.69 77.12,99.69 77.24,99.82 77.24,100.38 77.37,100.51 77.62,100.51 77.75,100.38 77.75,99.82 77.88,99.69 78.13,99.69 78.26,99.82 78.26,100.32 78.39,100.45 78.64,100.45 78.77,100.32 78.77,99.82 78.89,99.69 79.15,99.69 79.27,99.82 79.27,100.32 79.4,100.45 79.66,100.45 79.78,100.32 79.78,99.82 79.91,99.69 80.16,99.69 80.29,99.82 80.29,100.38 80.42,100.51 80.67,100.51 80.8,100.38 80.8,99.82 80.93,99.69 81.73,99.69 87.12,105.08
  BOTTOM w0.076: UC1.AP63 91.26,108.51 90.73,107.98 90.37,107.98 89.26,106.88 v2(89.26,105.95)
  BOTTOM w0.102: JDIMM1.17 46.6,72.31 v2(44.22,69.93)
DDR_A_D11: length 89.4
  IN1 w0.084: 87.12,104.01 88.6,104.01 90.01,105.42 90.01,105.99 v2(89.66,106.34)
  IN1 w0.127: v2(46.57,63.47) 46.57,64.07 46.45,64.2 46.19,64.2 46.07,64.07 46.07,63.17 45.94,63.04 45.69,63.04 45.56,63.17 45.56,64.07 45.43,64.2 44.99,64.2 44.86,64.33 44.86,64.58 44.99,64.71 46.52,64.71 46.65,64.84 46.65,65.09 46.52,65.22 44.99,65.22 44.86,65.34 44.86,65.6 44.99,65.72 46.13,65.72 46.26,65.85 46.26,66.11 46.13,66.23 45.15,66.23 45.03,66.36 45.03,77.02 45.02,77.03 45.02,78.67 46.54,80.19 46.54,82.17 54.31,89.95 56.71,92.34 56.71,93.09 61.05,97.44 61.84,97.44 62.59,98.18 63.32,98.18 64.61,99.47 73.35,99.47 73.84,98.99 82.04,98.99 87.06,104.01 87.12,104.01
  BOTTOM w0.076: v2(89.66,106.34) 89.66,107.04 90.44,107.82 90.8,107.82 91.2,108.22 91.77,108.22 92.06,108.51 UC1.AP62
  BOTTOM w0.102: JDIMM1.18 46.9,63.8 v2(46.57,63.47)
DDR_A_D12: length 90.2
  IN1 w0.084: v2(88.83,109.03) 88.99,109.03 89.18,108.83 89.18,108.61 88.45,107.88 86.96,107.88
  IN1 w0.127: v2(43.27,63.47) 43.27,65.8 42.85,66.22 42.85,66.94 42.73,67.06 41.81,67.06 41.68,67.19 41.68,67.44 41.81,67.57 43.02,67.57 43.15,67.7 43.15,67.95 43.02,68.08 41.81,68.08 41.68,68.21 41.68,69.84 41.43,70.09 41.43,80.08 42.36,81.01 42.36,84.73 47.02,89.4 48.31,89.4 60.89,101.98 61.25,101.98 61.82,102.55 73.47,102.55 79.56,108.64 82.81,108.64 83.58,107.88 86.96,107.88
  BOTTOM w0.076: v2(88.83,109.03) 88.83,109.03 89.87,110.06 91.2,110.06 91.46,110.32 91.84,110.32 92,110.15 92.42,110.15 92.82,109.76 UC1.AM61
  BOTTOM w0.102: JDIMM1.6 43.3,63.5 v2(43.27,63.47)
DDR_A_D13: length 91.3
  IN1 w0.084: v2(88.2,106.98) 87.53,106.98
  IN1 w0.127: v2(42.19,71.45) 42.25,71.51 42.25,76.44 42.81,77 42.81,79.59 43.04,79.82 43.04,80.47 43.22,80.65 43.87,80.65 44,80.77 44,81.03 43.87,81.15 43.17,81.15 43.04,81.28 43.04,81.54 43.17,81.66 44.2,81.66 44.33,81.79 44.33,82.04 44.2,82.17 43.21,82.17 43.08,82.3 43.08,82.55 43.21,82.68 44.2,82.68 44.33,82.81 44.33,83.06 44.2,83.19 43.21,83.19 43.08,83.31 43.08,83.57 43.21,83.69 44.75,83.69 44.88,83.82 44.88,84.08 44.75,84.2 43.31,84.2 43.19,84.33 43.19,84.58 43.31,84.71 44.59,84.71 51.82,91.94 52,91.94 52.07,91.88 52.25,91.88 52.43,92.06 52.43,92.24 52.36,92.3 52.36,92.48 52.54,92.66 52.72,92.66 52.78,92.6 52.96,92.6 53.14,92.78 53.14,92.96 53.08,93.02 53.08,93.2 53.26,93.38 53.44,93.38 53.5,93.32 53.68,93.32 53.86,93.5 53.86,93.68 53.8,93.74 53.8,93.92 53.98,94.1 54.16,94.1 54.22,94.04 54.4,94.04 54.58,94.22 54.58,94.4 54.52,94.46 54.52,94.64 54.7,94.82 54.88,94.82 54.94,94.76 55.12,94.76 55.3,94.94 55.3,95.12 55.24,95.18 55.24,95.36 55.42,95.54 55.6,95.54 55.66,95.48 55.84,95.48 56.02,95.65 56.02,95.83 55.96,95.9 55.96,96.08 56.14,96.26 56.32,96.26 56.38,96.19 56.56,96.19 56.74,96.37 56.74,96.55 56.68,96.61 56.68,96.79 56.86,96.97 57.04,96.97 57.1,96.91 57.28,96.91 57.46,97.09 57.46,97.27 57.4,97.33 57.4,97.51 58.16,98.28 58.34,98.28 58.4,98.22 58.58,98.22 58.76,98.4 58.76,98.58 58.7,98.64 58.7,98.82 58.88,99 59.06,99 59.12,98.94 59.3,98.94 59.48,99.12 59.48,99.3 59.42,99.36 59.42,99.54 60.26,100.37 60.44,100.37 60.5,100.31 60.68,100.31 60.86,100.49 60.86,100.67 60.8,100.73 60.8,100.91 61.18,101.3 61.66,101.3 62.21,101.84 74.4,101.84 75.58,103.02 76.5,103.02 77.43,102.1 81.98,102.1 84.33,104.44 86.86,106.98 87.53,106.98
  BOTTOM w0.076: v2(88.2,106.98) 88.89,106.98 90.23,108.31 90.59,108.31 91.25,108.97 91.75,108.97 91.91,108.89 92.04,108.89 92.2,108.97 92.4,108.97 92.45,108.94 92.54,108.9 92.56,108.89 93.4,108.89 93.6,109.1 UC1.AM60
  BOTTOM w0.102: v2(42.19,71.45) 43,72.27 JDIMM1.5
DDR_A_D14: length 89.5
  IN1 w0.084: v2(88.4,105.08) 87.62,105.08 87.12,104.58
  IN1 w0.127: v2(44.22,71.45) 44.22,71.36 44.35,71.24 44.56,71.24 44.68,71.36 44.68,76.88 44.68,76.89 44.68,78.81 46.2,80.33 46.2,82.32 47.67,83.79 47.67,84.49 48.07,84.89 48.77,84.89 49.45,85.57 49.45,85.75 48.95,86.25 48.95,86.43 49.14,86.63 49.32,86.63 49.82,86.13 50,86.13 50.42,86.54 50.42,86.72 49.94,87.2 49.94,87.42 50.11,87.59 50.29,87.59 50.81,87.06 50.94,87.06 51.15,87.27 51.15,87.45 50.65,87.95 50.65,88.13 50.83,88.31 51.01,88.31 51.51,87.81 51.69,87.81 51.87,87.99 51.87,88.17 51.37,88.67 51.37,88.85 51.55,89.03 51.73,89.03 52.23,88.53 52.41,88.53 52.59,88.71 52.59,88.89 52.17,89.31 52.17,89.49 52.35,89.67 52.53,89.67 52.95,89.25 53.13,89.25 53.31,89.43 53.31,89.61 53.05,89.87 53.05,90.05 53.23,90.23 53.41,90.23 53.67,89.97 53.85,89.97 54.03,90.15 54.03,90.33 53.77,90.59 53.77,90.77 53.95,90.95 54.13,90.95 54.39,90.69 54.57,90.69 54.75,90.87 54.75,91.05 54.49,91.31 54.49,91.49 54.67,91.67 54.85,91.67 55.11,91.41 55.29,91.41 55.47,91.59 55.47,91.77 55.21,92.03 55.21,92.21 55.39,92.39 55.57,92.39 55.83,92.13 56.01,92.13 56.24,92.36 56.24,92.51 55.97,92.77 55.97,92.97 61.21,98.21 61.39,98.21 61.64,97.97 61.82,97.97 62,98.15 62,98.33 61.75,98.57 61.75,98.75 61.93,98.93 62.11,98.93 62.52,98.53 62.7,98.53 62.88,98.71 62.88,98.89 62.47,99.29 62.47,99.47 62.83,99.83 73.48,99.83 73.97,99.35 81.89,99.35 87.12,104.58
  BOTTOM w0.076: v2(88.4,105.08) 88.4,106.25 90.3,108.15 90.66,108.15 91.31,108.8 91.71,108.8 91.82,108.75 91.87,108.73 92.08,108.73 92.13,108.75 92.22,108.8 92.23,108.8 92.37,108.8 92.47,108.75 92.71,108.51 UC1.AP61
  BOTTOM w0.102: JDIMM1.15 46,72.38 45.08,71.45 v2(44.22,71.45)
DDR_A_D15: length 89.9
  IN1 w0.084: 87.12,103.58 87.22,103.67 88.5,103.67 90.29,105.46 90.29,106.51 v2(90.05,106.74)
  IN1 w0.127: 87.12,103.58 82.18,98.64 73.71,98.64 73.23,99.12 64.74,99.12 63.46,97.84 62.74,97.84 61.98,97.09 61.98,96.84 61.68,96.55 60.65,96.55 57.05,92.95 57.05,92.19 46.88,82.02 46.88,80.05 45.36,78.53 45.36,77.77 45.37,77.76 45.37,70.49 45.49,70.36 45.81,70.36 45.94,70.23 45.94,69.98 45.81,69.85 45.49,69.85 45.37,69.72 45.37,69.47 45.49,69.34 46.08,69.34 46.21,69.22 46.21,68.96 46.08,68.84 45.49,68.84 45.37,68.71 45.37,68.45 45.49,68.33 46.51,68.33 46.64,68.2 46.64,67.95 46.51,67.82 45.49,67.82 45.37,67.69 45.37,67.44 45.49,67.31 46.07,67.31 46.19,67.18 46.19,66.65 46.99,65.85 46.99,62.37 v2(46.57,61.95)
  BOTTOM w0.076: v2(90.05,106.74) 90.05,107.2 90.5,107.65 90.87,107.65 91.27,108.05 91.84,108.05 92,108.22 92.42,108.22 92.43,108.23 92.82,108.23 92.83,108.22 93.07,108.22 93.14,108.29 93.38,108.29 UC1.AP60
  BOTTOM w0.102: JDIMM1.16 46.3,64 46.13,63.83 46.13,62.39 v2(46.57,61.95)
DDR_A_D16: length 63.5
  IN3 w0.084: v2(94.42,108.38) 94.72,108.38 94.81,108.29 94.81,107.27 94.14,106.59 93.17,106.59 92.86,106.29 92.86,105.5 90.31,102.94 90.15,102.94 89.04,101.82 89.04,101.66
  IN3 w0.127: 89.04,101.66 89.04,101.46 82.92,95.34 82.92,89.58 82.78,89.45 82.13,89.45 82.01,89.32 82.01,89.04 82.13,88.91 82.83,88.91 82.93,88.81 82.93,88.46 82.83,88.37 82.14,88.37 82.01,88.24 82.01,87.95 82.14,87.83 82.83,87.83 82.93,87.73 82.93,87.38 82.83,87.29 82.14,87.29 82.01,87.16 82.01,86.87 82.14,86.74 82.83,86.74 82.93,86.65 82.93,86.3 82.83,86.2 82.14,86.2 82.01,86.08 82.01,85.79 82.14,85.66 82.83,85.66 82.93,85.57 82.93,85.22 82.83,85.12 82.13,85.12 82.01,84.99 82.01,84.71 82.13,84.58 82.83,84.58 82.93,84.49 82.93,84.13 82.83,84.04 82.13,84.04 82,83.91 82,83.63 82.13,83.5 82.8,83.5 82.93,83.37 82.93,83.08 82.8,82.96 82.13,82.96 82,82.83 82,82.54 82.13,82.42 82.78,82.42 82.92,82.28 82.92,81.48 88.49,75.92 88.49,75.23 91.02,72.71 91.02,70.09 90.87,69.95 v2(90.59,69.95)
  BOTTOM w0.076: v2(94.42,108.38) 94.74,108.7 UC1.AP58
  BOTTOM w0.102: v2(90.59,69.95) 91.6,70.95 JDIMM1.159
DDR_A_D17: length 63.1
  IN3 w0.084: v2(94.42,107.73) 94.44,107.73 94.57,107.6 94.57,107.4 94.44,107.27 94.06,107.27 93.58,106.8 93.25,106.8 93.09,106.96 92.71,106.96 92.42,106.67 92.42,106.46 92.69,106.19 92.69,106.01 92.52,105.84 92.35,105.84 91.81,106.37 91.63,106.37 91.46,106.21 91.46,106.03 92.15,105.34 92.15,105.16 91.98,105 91.8,105 91.1,105.7 90.92,105.7 90.75,105.53 90.75,105.35 91.43,104.68 91.43,104.5 91.26,104.33 91.08,104.33 90.42,104.99 90.24,104.99 88.99,103.75 88.99,103.57 89.59,102.97 89.59,102.79 89.44,102.63 89.26,102.63 89.02,102.87 88.84,102.87 88.67,102.7 88.67,102.53 89.02,102.17 89.02,102.08 88.67,101.73 88.67,101.66
  IN3 w0.127: v2(90.59,71.47) 90.59,72.58 88.12,75.05 88.12,75.76 82.56,81.33 82.56,81.9 82.45,82.02 81.87,82.02 81.65,82.24 81.65,89.69 81.78,89.81 82.43,89.81 82.56,89.94 82.56,90.23 82.43,90.35 81.78,90.35 81.65,90.48 81.65,90.77 81.78,90.89 82.43,90.89 82.56,91.02 82.56,91.31 82.43,91.44 81.78,91.44 81.65,91.56 81.65,91.85 81.78,91.98 82.43,91.98 82.56,92.1 82.56,92.39 82.43,92.52 81.78,92.52 81.65,92.64 81.65,92.93 81.78,93.06 82.43,93.06 82.56,93.19 82.56,93.47 82.43,93.6 81.78,93.6 81.65,93.73 81.65,94.13 81.78,94.25 82.43,94.25 82.56,94.38 82.56,95.49 88.67,101.61 88.67,101.66
  BOTTOM w0.076: UC1.AR58 94.74,108.05 v2(94.42,107.73)
  BOTTOM w0.102: JDIMM1.157 91,71.88 v2(90.59,71.47)
DDR_A_D18: length 65.4
  IN3 w0.084: v2(95.31,109.81) 94.94,110.17 94.94,110.74 94.58,111.1 94.25,111.1 93.66,110.51 93.66,110.49 91.3,108.13 90.56,108.13 87.12,104.7
  IN3 w0.127: 87.12,104.7 86.94,104.51 86.94,103.07 82.98,99.11 80.69,96.81 78.77,96.81 78.42,96.47 78.42,82.27 84.54,76.14 84.54,75.46 88.07,71.94 88.07,68.92 88.2,68.79 88.74,68.79 88.87,68.66 88.87,68.38 88.74,68.25 88.2,68.25 88.07,68.11 88.07,63.89 v2(87.64,63.47)
  BOTTOM w0.076: v2(95.31,109.81) 95.51,110 UC1.AM57
  BOTTOM w0.102: v2(87.64,63.47) 87.7,63.53 JDIMM1.146
DDR_A_D19: length 67.4
  IN3 w0.084: 87.12,105.21 90.22,108.31 91.23,108.31 93.49,110.56 93.49,110.58 94.18,111.27 95.12,111.27 v2(95.31,111.08)
  IN3 w0.127: 87.12,105.21 86.58,104.66 86.58,103.22 83.12,99.76 80.54,97.18 78.62,97.18 78.06,96.62 78.06,82.11 84.18,75.99 84.18,75.31 87.52,71.97 87.52,64.45 87.07,64 87.07,62.52 v2(87.64,61.95)
  BOTTOM w0.076: v2(95.31,111.08) 95.53,111.31 UC1.AK57
  BOTTOM w0.102: JDIMM1.148 88.3,62.6 v2(87.64,61.95)
DDR_A_D20: length 65.6
  IN3 w0.084: v2(94.41,110.16) 94.19,110.16 94.05,110.01 94.05,109.57 93.92,109.44 93.21,109.44 91.73,107.96 91.73,107.59 87.55,103.41 87.55,102.65
  IN3 w0.127: 87.55,102.65 80.14,95.24 80.14,91.65 80.01,91.52 79.72,91.52 79.59,91.39 79.59,91.11 79.72,90.98 80.01,90.98 80.14,90.85 80.14,90.51 80,90.37 79.28,90.37 79.15,90.24 79.15,89.97 79.28,89.83 80.01,89.83 80.14,89.7 80.14,89.42 80.01,89.29 79.28,89.29 79.15,89.16 79.15,88.88 79.28,88.75 80,88.75 80.14,88.61 80.14,88.34 80,88.21 79.28,88.21 79.15,88.07 79.15,87.8 79.28,87.67 80,87.67 80.14,87.53 80.14,87.26 80,87.13 79.28,87.13 79.15,86.99 79.15,86.72 79.28,86.58 80,86.58 80.14,86.45 80.14,86.18 80,86.04 79.28,86.04 79.15,85.91 79.15,85.64 79.28,85.5 80,85.5 80.14,85.37 80.14,85.1 80,84.96 79.28,84.96 79.15,84.83 79.15,84.56 79.28,84.42 80,84.42 80.14,84.29 80.14,84.01 80,83.88 79.28,83.88 79.15,83.74 79.15,83.47 79.28,83.34 80.01,83.34 80.14,83.21 80.14,82.92 80.01,82.8 79.34,82.8 79.21,82.67 79.21,82.49 79.45,82.26 80,82.26 80.14,82.12 80.14,81.58 86.11,75.61 86.11,74.93 89.07,71.96 v2(89.07,71.47)
  BOTTOM w0.089: UC1.AL58 94.87,110.61 v2(94.41,110.16)
  BOTTOM w0.102: v2(89.07,71.47) 88.6,71.94 JDIMM1.149
DDR_A_D21: length 66.7
  IN3 w0.084: v2(94.39,110.71) 94.23,110.71 91.55,108.04 91.55,107.66 87.34,103.44 87.34,102.95
  IN3 w0.127: v2(89.07,69.95) 89.07,69.72 88.94,69.59 88.56,69.59 88.43,69.72 88.43,72.09 85.74,74.78 85.74,75.46 78.79,82.42 78.79,90.67 78.91,90.79 79.1,90.79 79.23,90.93 79.23,91.2 79.1,91.33 78.91,91.33 78.79,91.46 78.79,91.75 78.91,91.88 79.65,91.88 79.77,92 79.77,92.29 79.65,92.42 78.91,92.42 78.79,92.54 78.79,92.83 78.91,92.96 79.65,92.96 79.77,93.08 79.77,93.37 79.65,93.5 78.91,93.5 78.79,93.63 78.79,93.92 78.91,94.05 79.65,94.05 79.77,94.18 79.77,94.69 79.64,94.83 78.92,94.83 78.79,94.96 78.79,95.23 78.92,95.37 79.64,95.37 79.77,95.5 79.77,95.78 79.64,95.91 78.92,95.91 78.79,96.05 78.79,96.32 78.92,96.45 80.84,96.45 83.13,98.75 87.34,102.95
  BOTTOM w0.076: UC1.AK58 94.87,111.48 94.74,111.61 94.31,111.61 94.18,111.48 94.18,110.92 94.39,110.71 v2(94.39,110.71)
  BOTTOM w0.102: v2(89.07,69.95) 88,71.02 JDIMM1.147
DDR_A_D22: length 63.8
  IN3 w0.084: v2(95.37,107.73) 95.37,107.12 91.23,102.98 89.91,101.66
  IN3 w0.127: 89.91,101.66 89.76,101.51 89.76,101.16 84.23,95.63 84.23,95.01 84.1,94.88 83.77,94.88 83.65,94.76 83.65,94.42 83.78,94.29 84.14,94.29 84.26,94.16 84.26,93.87 84.14,93.75 83.78,93.75 83.65,93.61 83.65,93.34 83.78,93.2 84.13,93.2 84.26,93.08 84.26,92.79 84.13,92.66 83.78,92.66 83.65,92.53 83.65,81.79 89.85,75.58 89.85,74.89 91.78,72.97 91.78,68.79 91.91,68.65 92.45,68.65 92.58,68.53 92.58,68.24 92.45,68.11 92.29,68.11 92.17,67.98 92.17,67.7 92.29,67.57 92.45,67.57 92.58,67.44 92.58,66.58 93.61,65.54 93.61,62.56 92.99,61.95 v2(91.26,61.95)
  BOTTOM w0.076: UC1.AR57 95.7,108.05 v2(95.37,107.73)
  BOTTOM w0.102: JDIMM1.158 91.3,64.15 90.86,63.7 90.86,62.35 v2(91.26,61.95)
DDR_A_D23: length 65.5
  IN3 w0.084: 89.4,101.67 89.9,102.16 89.97,102.16 90.46,102.66 93.42,105.61 93.44,105.61 94.99,107.15 94.99,108.64 v2(95.37,109.03)
  IN3 w0.127: v2(91.26,63.47) 91.26,64.06 91.39,64.19 92.54,64.19 92.66,64.06 92.66,63.04 92.79,62.92 93.12,62.92 93.24,63.04 93.24,64.76 93.12,64.89 91.22,64.89 91.1,65.02 91.1,65.3 91.22,65.43 92.67,65.43 92.79,65.56 92.79,65.84 92.67,65.97 91.55,65.97 91.42,66.11 91.42,72.82 89.49,74.74 89.49,75.43 83.28,81.63 83.28,95.19 89.4,101.31 89.4,101.67
  BOTTOM w0.076: v2(95.37,109.03) 95.7,109.35 UC1.AN57
  BOTTOM w0.102: v2(91.26,63.47) 91.9,64.11 JDIMM1.160
DDR_A_D24: length 83.7
  IN1 w0.084: 87.12,101.67 88.1,102.64 88.51,102.64 92.51,106.65 95.08,106.65 95.93,107.5 95.93,107.99 v2(96.32,108.38)
  IN1 w0.127: v2(49.11,63.47) 49.13,63.48 49.13,66.28 49,66.41 47.34,66.41 47.21,66.54 47.21,66.79 47.34,66.92 47.91,66.92 48.03,67.04 48.03,67.3 47.91,67.43 47.52,67.43 47.39,67.55 47.39,78.36 48.2,79.17 48.2,80.31 49.7,81.81 49.7,82.97 61.11,94.38 61.87,94.38 65.26,97.77 70.22,97.77 70.7,97.29 82.74,97.29 87.12,101.67
  BOTTOM w0.076: UC1.AP55 96.65,108.7 v2(96.32,108.38)
  BOTTOM w0.102: v2(49.11,63.47) 48.7,63.88 JDIMM1.24
DDR_A_D25: length 83.6
  IN1 w0.084: 87.62,101.66 88.24,102.29 88.25,102.29 88.26,102.3 88.43,102.3 92.58,106.45 95.13,106.45 96.32,107.65 v2(96.32,107.73)
  IN1 w0.127: v2(49.11,61.95) 49.53,62.37 49.53,66.36 47.73,68.16 47.73,78.22 48.55,79.03 48.55,80.17 50.04,81.67 50.04,82.83 61.25,94.04 62.5,94.04 65.4,96.93 82.89,96.93 87.62,101.66
  BOTTOM w0.076: v2(96.32,107.73) 96.65,108.05 UC1.AR55
  BOTTOM w0.102: JDIMM1.22 48.1,62.96 v2(49.11,61.95)
DDR_A_D26: length 86.7
  IN1 w0.084: v2(97.28,109.68) 97.3,109.68 97.84,109.15 97.84,106.61 96.64,105.41 94.77,105.41 94.22,104.86 93.53,104.86 93.17,104.5 93.17,103.98 90.17,100.99
  IN1 w0.127: 90.17,100.99 83.89,94.7 66.29,94.7 61.8,90.22 60.55,90.22 60.06,89.73 60.06,88.48 52.25,80.66 52.25,76.32 51.07,75.15 51.07,67.45 50.94,67.32 50.42,67.32 50.3,67.19 50.3,66.94 50.42,66.81 50.94,66.81 51.07,66.68 51.07,66.43 50.94,66.3 50.42,66.3 50.3,66.18 50.3,65.92 50.42,65.79 50.94,65.79 51.07,65.67 51.07,62.4 v2(51.53,61.95)
  BOTTOM w0.076: UC1.AM54 97.6,110 v2(97.28,109.68)
  BOTTOM w0.102: JDIMM1.36 52.3,62.72 v2(51.53,61.95)
DDR_A_D27: length 87.4
  IN1 w0.084: v2(97.23,110.98) 97.76,110.45 97.76,109.47 98.01,109.22 98.01,106.53 96.71,105.23 95.46,105.23 94.88,104.66 94.88,104.33 93.96,103.41 93.85,103.41 91.82,101.39 91.82,101.24 91.04,100.46 90.17,100.46
  IN1 w0.127: v2(51.53,63.47) 51.41,63.58 51.41,64.53 51.54,64.65 52.35,64.65 52.48,64.78 52.48,65.03 52.35,65.16 51.54,65.16 51.41,65.29 51.41,65.54 51.54,65.67 52.35,65.67 52.48,65.8 52.48,66.05 52.35,66.18 51.54,66.18 51.41,66.3 51.41,67.42 51.54,67.54 52.29,67.54 52.42,67.67 52.42,67.93 52.29,68.05 51.54,68.05 51.41,68.18 51.41,75 52.59,76.18 52.59,80.52 60.41,88.34 60.41,89.59 60.69,89.87 61.95,89.87 66.42,94.35 84.03,94.35 90.15,100.46 90.17,100.46
  BOTTOM w0.076: UC1.AK54 97.55,111.31 v2(97.23,110.98)
  BOTTOM w0.102: v2(51.53,63.47) 51.57,63.47 51.7,63.6 JDIMM1.34
DDR_A_D28: length 86.6
  IN1 w0.084: 87.12,102.17 87.91,102.96 88.32,102.96 92.18,106.82 95.01,106.82 95.76,107.57 95.76,110.14 95.95,110.33 v2(96.32,110.33)
  IN1 w0.127: v2(46.63,69.93) 46.63,69.7 46.75,69.57 46.92,69.57 47.05,69.7 47.05,72.27 46.92,72.4 46.47,72.4 46.35,72.53 46.35,72.78 46.47,72.91 46.92,72.91 47.05,73.04 47.05,73.29 46.92,73.42 46.47,73.42 46.35,73.54 46.35,73.8 46.47,73.93 46.92,73.93 47.05,74.05 47.05,74.31 46.92,74.43 46.47,74.43 46.35,74.56 46.35,75.14 46.47,75.27 46.92,75.27 47.05,75.4 47.05,75.65 46.92,75.78 46.47,75.78 46.35,75.91 46.35,76.16 46.47,76.29 46.92,76.29 47.05,76.41 47.05,76.67 46.92,76.8 46.47,76.8 46.35,76.92 46.35,77.18 46.47,77.3 46.92,77.3 47.05,77.43 47.05,78.5 47.86,79.32 47.86,80.46 48.63,81.23 48.63,81.49 48.44,81.68 48.44,81.86 48.62,82.04 48.8,82.04 49.01,81.83 49.19,81.83 49.35,81.99 49.35,82.17 49.05,82.48 49.05,82.81 60.96,94.72 61.72,94.72 65.13,98.13 70.35,98.13 70.83,97.65 82.59,97.65 87.12,102.17
  BOTTOM w0.076: v2(96.32,110.33) 96.65,110.65 UC1.AL55
  BOTTOM w0.102: JDIMM1.23 48.4,72.35 48.05,72 48.05,71.35 v2(46.63,69.93)
DDR_A_D29: length 86.8
  IN1 w0.084: 87.12,102.68 87.75,103.3 88.42,103.3 92.11,106.99 94.59,106.99 94.91,107.31 94.91,111.4 95.03,111.53 96.74,111.53 96.87,111.4 96.87,111.11 96.74,110.98 v2(96.27,110.98)
  IN1 w0.127: 87.12,102.68 82.45,98 73.25,98 73.09,98.16 73.09,98.36 72.96,98.48 72.71,98.48 72.58,98.36 72.58,98.16 72.45,98.03 72.2,98.03 72.07,98.16 72.07,98.36 71.95,98.48 71.69,98.48 71.57,98.36 71.57,98.16 71.44,98.03 71.18,98.03 71.06,98.16 71.06,98.36 70.93,98.48 65,98.48 62.41,95.9 62.23,95.9 62.15,95.98 61.97,95.98 61.79,95.8 61.79,95.62 61.88,95.54 61.88,95.36 61.69,95.18 61.46,95.18 60.87,95.77 60.77,95.77 60.51,95.52 60.51,95.41 60.75,95.17 60.75,94.99 60.57,94.81 60.39,94.81 60.15,95.05 60.05,95.05 59.79,94.8 59.79,94.69 60.03,94.45 60.03,94.27 59.85,94.09 59.67,94.09 59.43,94.33 59.33,94.33 59.08,94.08 59.08,93.97 59.34,93.71 59.34,93.58 59.1,93.35 58.98,93.35 58.75,93.57 58.57,93.57 58.39,93.4 58.39,93.22 58.62,92.99 58.62,92.86 58.39,92.63 58.26,92.63 58.03,92.86 57.86,92.86 57.69,92.69 57.69,92.44 57.88,92.25 57.88,92.12 47.52,81.76 47.52,79.79 46,78.27 46,77.84 46,77.84 46,71.22 46.13,71.09 46.5,71.09 46.63,71.22 v2(46.63,71.45)
  BOTTOM w0.076: UC1.AK55 96.6,111.31 v2(96.27,110.98)
  BOTTOM w0.102: v2(46.63,71.45) 47.8,72.63 JDIMM1.21
DDR_A_D30: length 84.7
  IN1 w0.084: 89.95,101.78 91.72,103.56 91.72,104.13 92.42,104.83 92.42,105.08 92.6,105.26 93.94,105.26 94.47,105.78 95.54,105.78 97.28,107.52 v2(97.28,107.73)
  IN1 w0.127: v2(50.31,71.62) 50.31,74.17 49.61,74.87 49.38,74.87 49.25,74.99 49.25,75.29 49.38,75.41 50.37,75.41 50.49,75.54 50.49,75.85 50.37,75.97 49.38,75.97 49.25,76.1 49.25,76.37 49.38,76.5 51.43,76.5 51.56,76.62 51.56,76.89 51.43,77.02 49.38,77.02 49.25,77.14 49.25,77.4 49.38,77.52 51.43,77.52 51.56,77.65 51.56,80.94 52.3,81.69 52.3,81.87 51.86,82.31 51.86,82.49 52.04,82.67 52.22,82.67 52.66,82.22 52.84,82.22 53.02,82.4 53.02,82.58 52.58,83.03 52.58,83.21 52.75,83.39 52.93,83.39 53.38,82.94 53.56,82.94 53.74,83.12 53.74,83.3 53.29,83.75 53.29,83.93 53.47,84.11 53.65,84.11 54.1,83.66 54.28,83.66 54.51,83.9 54.51,84.09 54.07,84.53 54.07,84.7 61.69,92.33 62.94,92.33 66.03,95.41 83.58,95.41 89.95,101.78
  BOTTOM w0.076: UC1.AR54 97.6,108.05 v2(97.28,107.73)
  BOTTOM w0.102: v2(50.31,71.62) 51.02,71.62 51.4,72 JDIMM1.33
DDR_A_D31: length 86
  IN1 w0.084: v2(97.28,109.03) 97.55,109.03 97.66,108.92 97.66,107.58 95.7,105.61 94.54,105.61 94.01,105.08 93.51,105.08 92.87,104.44 92.87,104.19 90.17,101.49
  IN1 w0.127: 90.17,101.49 83.74,95.06 66.16,95.06 63.08,91.98 61.83,91.98 61.34,91.49 61.34,91.31 61.56,91.1 61.56,90.92 61.38,90.74 61.2,90.74 60.98,90.96 60.8,90.96 59.16,89.31 59.16,89.16 59.62,88.7 59.62,88.52 59.43,88.33 59.25,88.33 58.79,88.79 58.64,88.79 58.61,88.76 58.43,88.57 58.43,88.42 58.89,87.96 58.89,87.78 58.7,87.6 58.52,87.6 58.06,88.05 57.91,88.05 57.69,87.84 57.69,87.69 58.15,87.23 58.15,87.05 57.96,86.86 57.78,86.86 57.32,87.32 57.17,87.32 56.97,87.12 56.95,87.1 56.95,86.95 57.41,86.49 57.41,86.31 57.22,86.12 57.04,86.12 56.58,86.58 56.44,86.58 56.34,86.49 56.22,86.36 56.22,86.21 56.68,85.75 56.68,85.57 56.49,85.39 56.31,85.39 55.86,85.84 55.69,85.84 55.44,85.58 55.44,85.42 55.89,84.97 55.89,84.79 55.69,84.59 55.51,84.59 55.06,85.04 54.9,85.04 54.68,84.82 54.68,84.66 55.12,84.21 55.12,84.02 52.42,81.32 51.9,80.8 51.9,76.47 50.73,75.29 50.73,70.02 50.6,69.9 50.43,69.9 50.31,70.02 v2(50.31,70.1)
  BOTTOM w0.076: v2(97.28,109.03) 97.6,109.35 UC1.AN54
  BOTTOM w0.102: v2(50.31,70.1) 52,71.79 JDIMM1.35
DDR_A_D32: length 54.8
  IN3 w0.084: v2(93.22,103.34) 93.16,103.28 92.63,103.28 90.62,101.27 90.62,100.32 90.43,100.12 90.43,99.88 90.17,99.63
  IN3 w0.127: 90.17,99.63 86.31,95.77 86.31,95.09 86.17,94.96 85.94,94.96 85.82,94.83 85.82,94.54 85.94,94.42 86.17,94.42 86.31,94.28 86.31,94.01 86.17,93.87 85.77,93.87 85.63,93.74 85.63,93.47 85.77,93.33 86.17,93.33 86.31,93.2 86.31,92.93 86.17,92.79 85.77,92.79 85.63,92.66 85.63,92.39 85.77,92.25 86.17,92.25 86.31,92.12 86.31,81.16 91.51,75.96 91.51,75.17 93.22,73.47 93.22,68.85 93.35,68.72 93.69,68.72 93.82,68.59 93.82,68.3 93.69,68.18 93.35,68.18 93.22,68.04 93.22,67.77 93.35,67.63 93.69,67.63 93.82,67.51 93.82,66.24 94.25,65.81 v2(94.25,63.47)
  BOTTOM w0.076: v2(93.22,103.34) 93.92,103.34 94.72,104.14 94.72,104.83 UC1.AY58
  BOTTOM w0.102: v2(94.25,63.47) 93.7,64.02 JDIMM1.166
DDR_A_D33: length 55.8
  IN3 w0.084: 90.17,100.14 90.45,100.42 90.45,101.34 93.09,103.98 93.62,103.98 v2(93.81,103.78)
  IN3 w0.127: v2(92.42,69.95) 92.53,69.84 92.73,69.84 92.85,69.97 92.85,73.32 91.15,75.02 91.15,75.8 85.94,81.01 85.94,83.97 85.82,84.1 85.4,84.1 85.27,84.23 85.27,84.51 85.4,84.64 85.82,84.64 85.94,84.77 85.94,85.06 85.82,85.18 85.4,85.18 85.27,85.31 85.27,85.67 85.4,85.8 85.82,85.8 85.94,85.93 85.94,86.22 85.82,86.34 85.4,86.34 85.27,86.48 85.27,86.75 85.4,86.88 85.82,86.88 85.94,87.01 85.94,87.3 85.82,87.43 85.4,87.43 85.27,87.56 85.27,87.83 85.4,87.97 85.82,87.97 85.94,88.09 85.94,88.38 85.82,88.51 85.4,88.51 85.27,88.64 85.27,88.91 85.4,89.05 85.82,89.05 85.94,89.18 85.94,89.46 85.82,89.59 85.4,89.59 85.27,89.72 85.27,90 85.4,90.13 85.82,90.13 85.94,90.26 85.94,90.54 85.82,90.67 85.4,90.67 85.27,90.81 85.27,91.08 85.4,91.21 85.82,91.21 85.94,91.34 85.94,91.63 85.82,91.75 85.4,91.75 85.27,91.89 85.27,95.24 90.17,100.14
  BOTTOM w0.076: UC1.AW58 94.55,105.3 94.55,104.31 93.99,103.75 93.84,103.75 v2(93.81,103.78)
  BOTTOM w0.102: v2(92.42,69.95) 92.91,69.95 93.4,70.44 JDIMM1.165
DDR_A_D34: length 55.7
  IN3 w0.084: v2(95,103.08) 95.38,102.7 95.38,102.52 95.18,102.31 95,102.31 94.94,102.37 94.82,102.37 94.6,102.14 94.6,102.02 94.74,101.88 94.74,101.76 91.41,98.43 91.41,97.19 90.17,95.95
  IN3 w0.127: 90.17,95.95 88.91,94.69 88.91,83.43 92,80.33 92.19,80.33 92.97,81.11 93.16,81.11 93.36,80.92 93.36,80.73 92.58,79.95 92.58,79.76 92.77,79.57 92.96,79.57 93.74,80.35 93.93,80.35 94.12,80.15 94.12,79.96 93.34,79.19 93.34,79 93.54,78.8 93.73,78.8 94.5,79.58 94.69,79.58 94.89,79.39 94.89,79.2 94.11,78.42 94.11,78.23 94.3,78.04 94.49,78.04 95.27,78.81 95.46,78.81 95.65,78.62 95.65,78.43 94.87,77.65 94.87,77.46 95.16,77.18 95.35,77.18 96.04,77.86 96.22,77.86 96.42,77.65 96.42,77.48 95.72,76.78 95.72,76.61 96.42,75.92 96.42,72.28 96.55,72.15 96.74,72.15 96.87,72.02 96.87,71.6 96.74,71.47 v2(96.51,71.47)
  BOTTOM w0.076: v2(95,103.08) 95.16,102.92 95.34,102.92 96.17,103.76 96.17,104.74 96.19,104.76 UC1.AY56
  BOTTOM w0.102: JDIMM1.175 96.4,72.36 95.98,71.93 95.98,71.72 96.22,71.47 v2(96.51,71.47)
DDR_A_D35: length 56.5
  IN3 w0.084: 90.17,96.47 91.23,97.53 91.23,98.5 94.14,101.4 v2(94.14,102.21)
  IN3 w0.127: 90.17,96.47 88.54,94.84 88.54,83.06 95.89,75.71 95.89,71.47 96.08,71.27 96.08,68.89 96.21,68.76 96.75,68.76 96.88,68.64 96.88,68.35 96.75,68.23 96.28,68.23 96.16,68.1 96.16,67.81 96.28,67.69 96.75,67.69 96.88,67.56 96.88,62.07 96.75,61.95 v2(96.25,61.95)
  BOTTOM w0.076: v2(94.14,102.21) 94.86,102.21 96.34,103.69 96.34,104.67 96.48,104.82 96.48,105.06 96.19,105.36 UC1.AW56
  BOTTOM w0.102: v2(96.25,61.95) 95.84,62.35 95.84,63.64 96.1,63.9 JDIMM1.174
DDR_A_D36: length 56.2
  IN3 w0.127: v2(92.42,71.47) 92.42,73.24 90.79,74.87 90.79,75.65 85.58,80.86 85.58,81.47 85.49,81.56 84.78,81.56 84.65,81.69 84.65,81.99 84.78,82.12 85.45,82.12 85.58,82.25 85.58,82.54 85.45,82.67 84.42,82.67 84.29,82.79 84.29,83.07 84.42,83.2 85.45,83.2 85.58,83.32 85.58,83.61 85.45,83.74 84.42,83.74 84.29,83.86 84.29,84.18 84.42,84.3 84.8,84.3 84.91,84.41 84.91,84.92 84.77,85.06 84.42,85.06 84.29,85.19 84.29,85.46 84.42,85.6 84.77,85.6 84.91,85.73 84.91,86 84.77,86.14 84.42,86.14 84.29,86.27 84.29,86.54 84.42,86.68 84.77,86.68 84.91,86.81 84.91,87.09 84.77,87.22 84.42,87.22 84.29,87.35 84.29,87.63 84.42,87.76 84.77,87.76 84.91,87.9 84.91,88.17 84.77,88.3 84.42,88.3 84.29,88.44 84.29,88.71 84.42,88.84 84.77,88.84 84.91,88.98 84.91,89.25 84.77,89.38 84.42,89.38 84.29,89.52 84.29,89.79 84.42,89.92 84.77,89.92 84.91,90.06 84.91,90.33 84.77,90.47 84.42,90.47 84.29,90.6 84.29,90.87 84.42,91.01 84.77,91.01 84.91,91.14 84.91,91.41 84.77,91.55 84.42,91.55 84.29,91.68 84.29,91.95 84.42,92.09 84.77,92.09 84.91,92.22 84.91,95.39 90.17,100.66 90.17,101.48 93.2,104.51 93.38,104.51 v2(93.54,104.35)
  BOTTOM w0.076: v2(93.54,104.35) 93.86,104.67 93.86,105.08 94.62,105.84 94.62,106.02 UC1.AV58
  BOTTOM w0.102: JDIMM1.163 92.8,71.85 v2(92.42,71.47)
DDR_A_D37: length 58
  IN3 w0.084: 90.17,99.12 90.62,99.57 90.62,100.01 91,100.38 v2(91,100.99)
  IN3 w0.127: v2(94.25,61.95) 94.67,62.37 94.67,65.9 94.18,66.39 94.18,69.06 93.58,69.67 93.58,73.62 91.88,75.32 91.88,76.11 86.67,81.31 86.67,95.62 90.17,99.12
  BOTTOM w0.076: v2(91,100.99) 92.31,100.99 95.25,103.94 95.65,103.94 95.84,104.13 95.84,104.65 95.73,104.75 95.73,105.05 95.81,105.2 95.81,105.33 95.73,105.49 95.73,105.7 95.76,105.75 95.8,105.84 95.81,105.85 95.81,106.04 95.79,106.05 95.79,106.43 95.84,106.48 95.84,106.66 95.6,106.89 UC1.AU58
  BOTTOM w0.102: JDIMM1.164 93.1,63.09 v2(94.25,61.95)
DDR_A_D38: length 57.2
  IN3 w0.084: v2(95.4,103.54) 95.71,103.23 95.71,102.48 91.68,98.46 91.68,96.95 90.4,95.67
  IN3 w0.127: v2(96.51,69.95) 96.68,69.78 97.12,69.78 97.23,69.89 97.23,72.75 96.78,73.2 96.78,78.01 93.05,81.74 92.86,81.74 92.08,80.95 91.9,80.95 91.7,81.16 91.7,81.34 92.48,82.12 92.48,82.31 92.29,82.5 92.1,82.5 91.41,81.81 91.23,81.81 91.03,82.02 91.03,82.2 91.71,82.89 91.71,83.08 91.52,83.27 91.33,83.27 90.61,82.55 90.42,82.55 90.23,82.74 90.23,82.93 90.95,83.65 90.95,83.84 90.76,84.03 90.57,84.03 89.84,83.31 89.65,83.31 89.46,83.51 89.46,83.7 90.18,84.42 90.18,84.61 89.93,84.86 89.78,84.86 89.64,84.72 89.4,84.72 89.27,84.85 89.27,85.14 89.36,85.23 89.36,85.46 89.27,85.55 89.27,94.54 90.4,95.67
  BOTTOM w0.076: UC1.AV56 96.08,105.9 95.95,105.76 95.92,105.71 95.9,105.66 95.9,105.53 95.91,105.51 95.95,105.42 95.95,105.42 95.97,105.37 95.97,105.14 95.95,105.11 95.9,105.01 95.9,104.82 96.01,104.72 96.01,103.82 95.72,103.54 v2(95.4,103.54)
  BOTTOM w0.102: v2(96.51,69.95) 97,70.44 JDIMM1.177
DDR_A_D39: length 58.2
  IN3 w0.084: v2(93.71,101.78) 93.71,101.22 90.93,98.44 90.93,97.74 90.17,96.98
  IN3 w0.127: v2(96.25,63.47) 95.57,63.47 95.44,63.6 95.44,64.16 95.57,64.28 96.38,64.28 96.51,64.42 96.51,64.69 96.38,64.82 95.56,64.82 95.43,64.95 95.43,65.24 95.56,65.37 96.38,65.37 96.51,65.5 96.51,65.77 96.38,65.91 95.86,65.91 95.72,66.04 95.72,66.31 95.86,66.45 96.38,66.45 96.51,66.58 96.51,66.85 96.38,66.99 95.86,66.99 95.72,67.12 95.72,71.12 95.53,71.32 95.53,75.56 88.18,82.91 88.18,94.99 90.17,96.98
  BOTTOM w0.076: v2(93.71,101.78) 94.66,101.78 96.5,103.62 96.5,104.61 96.65,104.75 96.65,105.55 96.37,105.83 96.37,106.12 96.38,106.12 96.38,106.36 96.08,106.66 UC1.AU56
  BOTTOM w0.102: JDIMM1.176 96.7,63.92 v2(96.25,63.47)
DDR_A_D40: length 71.3
  IN1 w0.084: v2(91.48,99.6) 90.18,99.6 90.17,99.59
  IN1 w0.127: v2(52.9,68.41) 52.13,69.17 52.13,74.83 53.23,75.92 53.23,80.26 61.05,88.08 66.68,93.71 84.3,93.71 84.67,94.08 84.67,94.08 90.17,99.59
  BOTTOM w0.076: UC1.AY54 97.14,104.82 97.14,104.55 97,104.4 97,103.4 96.72,103.13
  BOTTOM w0.089: 96.72,103.13 93.19,99.6 v2(91.48,99.6)
  BOTTOM w0.102: v2(52.9,68.41) 54.1,67.2 JDIMM1.42
DDR_A_D41: length 71.6
  IN1 w0.084: v2(92.37,100.49) 92.37,99.94 91.52,99.09 90.18,99.09 90.17,99.08
  IN1 w0.127: 90.17,99.08 83.91,92.83 78.13,92.83 78,92.95 78,93.23 77.88,93.36 77.62,93.36 77.5,93.23 77.5,92.95 77.37,92.83 77.11,92.83 76.99,92.95 76.99,93.23 76.86,93.36 66.81,93.36 61.39,87.94 53.57,80.11 53.57,74.93 52.48,73.84 52.48,70.35 v2(52.9,69.93)
  BOTTOM w0.076: UC1.AW54 97.27,105.36 96.98,105.06 96.98,104.62 96.83,104.47 96.83,103.48 93.84,100.49 v2(92.37,100.49)
  BOTTOM w0.102: JDIMM1.41 53.8,70.8 52.93,69.93 v2(52.9,69.93)
DDR_A_D42: length 71.3
  IN1 w0.084: v2(94.99,100.27) 94.35,100.27 92.61,98.53 92.61,97.76 90.52,95.67
  IN1 w0.127: 90.52,95.67 85.04,90.19 68.47,90.19 64.26,85.97 63.04,85.97 62.73,85.67 57.13,80.07 57.13,79.9 57.59,79.45 57.59,79.32 57.34,79.08 57.22,79.08 56.77,79.53 56.59,79.53 56.38,79.32 56.38,79.14 56.8,78.73 56.8,78.53 56.12,77.85 56.12,71.78 56.11,71.77 56.11,71.14 56.12,71.13 56.12,71.02 56.11,71.01 56.11,70.38 56.12,70.37 56.12,68.82 56.53,68.41 v2(56.87,68.41)
  BOTTOM w0.076: v2(94.99,100.27) 95.66,100.27 95.96,100.57 96.19,100.57 98.47,102.85 98.47,104.32 98.49,104.34 98.49,104.82 UC1.AY52
  BOTTOM w0.102: JDIMM1.50 56.5,66.26 56.35,66.41 56.35,67.89 v2(56.87,68.41)
DDR_A_D43: length 72.4
  IN1 w0.084: 91.53,95.67 94.01,98.15 94.01,98.73 94.07,98.79 v2(94.07,99.35)
  IN1 w0.127: v2(56.87,71.45) 57.15,71.45 57.27,71.58 57.27,72.06 57.15,72.19 56.93,72.19 56.8,72.32 56.8,72.65 56.93,72.78 57.15,72.78 57.27,72.91 57.27,73.16 57.15,73.29 56.93,73.29 56.8,73.42 56.8,73.67 56.93,73.8 57.15,73.8 57.27,73.92 57.27,74.18 57.15,74.31 56.93,74.31 56.8,74.43 56.8,75.28 56.93,75.41 57.15,75.41 57.27,75.54 57.27,75.79 57.15,75.92 56.93,75.92 56.8,76.04 56.8,76.3 56.93,76.43 57.15,76.43 57.27,76.55 57.27,78.04 61.23,81.99 61.23,82.17 60.81,82.59 60.81,82.77 60.99,82.95 61.17,82.95 61.59,82.53 61.77,82.53 61.95,82.71 61.95,82.89 61.53,83.31 61.53,83.49 61.71,83.67 61.89,83.67 62.31,83.25 62.49,83.25 62.67,83.43 62.67,83.61 62.24,84.03 62.24,84.21 62.42,84.39 62.6,84.39 63.03,83.97 63.2,83.97 63.38,84.15 63.38,84.33 62.96,84.75 62.96,84.93 63.14,85.11 63.32,85.11 63.74,84.69 63.92,84.69 64.51,85.27 64.52,85.27 68.73,89.48 85.33,89.48 91.53,95.67
  BOTTOM w0.076: UC1.AW52 98.84,105.37 98.84,105.17 98.86,105.11 98.87,105.11 98.91,105.01 98.91,104.82 98.66,104.56 98.66,104.27 98.64,104.25 98.64,102.78 95.21,99.35 v2(94.07,99.35)
  BOTTOM w0.102: JDIMM1.51 56.8,71.53 v2(56.87,71.45)
