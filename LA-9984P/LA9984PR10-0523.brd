# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D3: length 82.1
  IN3 w0.084: v2(113.58,99.73) 113.88,100.03 114.21,100.03 114.33,99.91 114.33,99.47 114.22,99.37 114.04,99.37 113.95,99.27 113.95,99.14 114.08,99.01 114.21,99.01 114.33,98.89 114.33,97.29 115.55,96.06 115.55,95.95
  IN3 w0.127: 115.55,95.95 115.55,95.19 117.55,93.2 117.89,93.2 122.94,88.15 149.77,88.15 150.68,87.24 151.5,87.24 152.6,86.13 156.08,86.13 165.05,77.16 165.05,76.22 165.19,76.09 165.31,76.09 165.43,75.96 165.43,75.7 165.31,75.57 165.19,75.57 165.05,75.44 165.05,73.86 165.19,73.73 165.31,73.73 165.43,73.6 165.43,73.34 165.31,73.21 165.19,73.21 165.05,73.08 165.05,72.83 165.19,72.7 165.31,72.7 165.43,72.57 165.43,72.31 165.31,72.18 165.19,72.18 165.05,72.05 165.05,70.37 165.18,70.24 v2(165.47,70.24)
  BOTTOM w0.076: UC1.AW29 112.85,105.36 113.15,105.06 113.15,104.82 113.02,104.69 113.02,103.84 112.91,103.73 112.91,100.41 v2(113.58,99.73)
  BOTTOM w0.102: v2(165.47,70.24) 165.45,70.24 164.75,70.94 JDIMM2.141
DDR_B_D4: length 83.1
  IN3 w0.084: 112.23,97.34 112.35,97.46 112.35,98.61 112.23,98.73 112.07,98.73 111.96,98.61 v2(111.96,98.43)
  IN3 w0.127: v2(161.24,71.76) 161.24,72.11 161.32,72.19 161.6,72.19 161.72,72.32 161.72,72.63 161.6,72.76 161.34,72.76 161.22,72.89 161.22,73.21 161.34,73.34 161.6,73.34 161.72,73.46 161.72,73.73 161.6,73.85 161.37,73.85 161.24,73.98 161.24,75.97 154.41,82.8 151.22,82.8 151.07,82.96 150.88,82.96 150.72,82.8 150.54,82.8 150.33,83.01 150.33,83.19 150.49,83.34 150.49,83.53 150.12,83.91 149.92,83.91 149.76,83.75 149.47,83.75 148.39,84.82 121.19,84.82 121.06,84.94 121.06,85.32 120.8,85.59 120.42,85.59 120.23,85.77 120.23,86.15 120.03,86.35 119.66,86.35 119.47,86.53 119.47,86.91 119.33,87.05 118.96,87.05 118.77,87.23 118.77,87.61 118.64,87.75 118.26,87.75 118.14,87.87 118.14,88.24 118,88.38 117.62,88.38 117.44,88.56 117.44,88.94 117.24,89.14 116.86,89.14 116.68,89.33 116.68,89.7 116.51,89.87 116.13,89.87 112.23,93.78 112.23,97.34
  BOTTOM w0.076: UC1.AV31 111.12,105.86 111.12,105.2 111.12,105.2 111.04,105.05 111.04,103.63 110.86,103.44 110.86,98.77 111.2,98.43 v2(111.96,98.43)
  BOTTOM w0.102: JDIMM2.129 161.15,72.4 160.81,72.06 160.62,72.06 160.49,72.19 160.3,72.19 160.18,72.06 160.18,71.74 160.74,71.18 160.84,71.18 161.24,71.58 v2(161.24,71.76)
DDR_B_D5: length 83.4
  IN3 w0.084: v2(111.96,101.03) 112.86,100.13 112.86,97.48 113.32,97.03 113.32,96.22
  IN3 w0.127: 113.32,96.22 113.32,94.23 116.59,90.96 116.96,90.96 122.02,85.91 148.84,85.91 149.75,85 150.57,85 151.68,83.89 154.84,83.89 162.81,75.92 162.81,71.76 162.39,71.34 162.39,67.49 162.09,67.19 v2(161.24,67.19)
  BOTTOM w0.076: v2(111.96,101.03) 112.38,101.46 112.38,103.98 112.5,104.1 112.5,104.5 112.4,104.61 112.4,105.05 112.47,105.2 112.47,105.33 112.4,105.49 112.4,105.7 112.42,105.75 112.46,105.84 112.47,105.85 112.47,106.04 112.45,106.05 112.45,106.43 112.47,106.45 112.47,106.69 112.27,106.89 UC1.AU31
  BOTTOM w0.102: JDIMM2.130 161.45,66.98 v2(161.24,67.19)
DDR_B_D6: length 82.9
  IN3 w0.084: v2(113.58,97.78) 113.58,97.55 114.84,96.29 114.84,95.95
  IN3 w0.127: v2(165.47,67.19) 164.02,67.19 163.9,67.32 163.9,69.56 164.33,70 164.33,76.57 164.33,76.58 164.33,76.86 155.78,85.4 155.5,85.4 155.49,85.41 152.31,85.41 151.2,86.52 150.38,86.52 149.47,87.43 122.64,87.43 117.59,92.48 117.25,92.48 114.84,94.89 114.84,95.95
  BOTTOM w0.076: UC1.AV29 112.66,106.16 112.66,105.82 112.61,105.76 112.56,105.66 112.56,105.53 112.57,105.51 112.61,105.42 112.61,105.42 112.64,105.37 112.64,105.17 112.56,105.01 112.56,104.68 112.66,104.57 112.66,103.98 112.56,103.88 112.56,98.8 v2(113.58,97.78)
  BOTTOM w0.102: v2(165.47,67.19) 165.05,66.77 JDIMM2.142
DDR_B_D7: length 83.2
  IN3 w0.084: 115.92,95.95 115.92,96.1 115.76,96.25 115.61,96.25 115.58,96.29 114.5,97.36 114.5,102.47 114.38,102.6 114.2,102.6 114.07,102.47 114.07,100.51 113.95,100.38 v2(113.58,100.38)
  IN3 w0.127: 115.92,95.95 115.92,95.34 117.7,93.56 118.04,93.56 123.09,88.51 149.92,88.51 150.83,87.6 151.65,87.6 152.76,86.49 156.23,86.49 165.42,77.31 165.42,76.63 165.54,76.51 165.67,76.51 165.8,76.38 165.8,75.36 165.67,75.24 165.54,75.24 165.42,75.11 165.42,74.13 165.54,74 165.67,74 165.8,73.88 165.8,71.89 165.67,71.76 v2(165.47,71.76)
  BOTTOM w0.076: v2(113.58,100.38) 113.07,100.89 113.07,103.64 113.18,103.75 113.18,104.63 113.31,104.75 113.31,105.13 113.15,105.3 113.15,105.71 113.02,105.84 113.02,106.1 113.04,106.12 113.04,106.36 112.75,106.66 UC1.AU29
  BOTTOM w0.102: v2(165.47,71.76) 165.47,71.74 165.35,71.87 JDIMM2.143
DDR_B_D8: length 55.4
  IN1 w0.084: v2(113.58,101.68) 113.19,101.29 113.19,97.62 113.43,97.38 113.43,96.11
  IN1 w0.127: 113.43,96.11 113.43,78.27 115.75,75.95 115.94,75.95 116.19,76.2 116.37,76.2 116.56,76.01 116.56,75.83 116.05,75.32 116.05,75.15 116.24,74.96 116.42,74.96 117.61,76.15 117.79,76.15 117.98,75.96 117.98,75.78 116.79,74.59 116.79,74.41 116.98,74.22 117.16,74.22 117.79,74.86 117.97,74.86 118.16,74.67 118.16,74.49 117.53,73.85 117.53,73.67 117.71,73.48 117.89,73.48 118.54,74.13 118.72,74.13 118.91,73.94 118.91,73.76 118.26,73.12 118.26,72.94 118.45,72.75 118.63,72.75 119.51,73.62 119.69,73.62 119.88,73.43 119.88,73.25 119,72.38 119,72.2 119.19,72.01 119.37,72.01 120.52,73.16 120.7,73.16 120.88,72.97 120.88,72.79 119.74,71.64 119.74,71.46 120.13,71.07 120.31,71.07 v2(120.74,71.49)
  BOTTOM w0.076: UC1.AY27 113.81,104.82 113.81,104.55 113.69,104.43 113.69,103.81 114.14,103.36 114.14,102.24 v2(113.58,101.68)
  BOTTOM w0.102: v2(120.74,71.49) 121.55,72.31 JDIMM2.5
DDR_B_D9: length 56.3
  IN1 w0.084: v2(113.58,102.33) 112.99,101.75 112.99,97.19 113.07,97.11 113.07,96.47
  IN1 w0.127: v2(121.82,63.51) 121.82,64.15 121.25,64.72 120.37,64.72 120.25,64.85 120.25,65.1 120.37,65.23 120.94,65.23 121.06,65.36 121.06,65.61 120.94,65.74 120.37,65.74 120.25,65.86 120.25,66.12 120.37,66.24 121.1,66.24 121.23,66.37 121.23,66.63 121.1,66.75 120.37,66.75 120.25,66.88 120.25,67.13 120.37,67.26 121.63,67.26 121.76,67.39 121.76,67.64 121.63,67.77 120.37,67.77 120.25,67.9 120.25,68.15 120.37,68.28 121.2,68.28 121.33,68.4 121.33,68.66 121.2,68.78 120.37,68.78 120.25,68.91 120.25,70.47 113.07,77.64 113.07,96.47
  BOTTOM w0.076: UC1.AW27 113.93,105.36 113.64,105.06 113.64,104.62 113.53,104.5 113.53,103.74 113.98,103.29 113.98,102.73 v2(113.58,102.33)
  BOTTOM w0.102: v2(121.82,63.51) 121.85,63.54 JDIMM2.6
DDR_B_D10: length 55.8
  IN1 w0.084: v2(115.67,99.08) 115.34,99.08 115.22,99.21 115.22,99.69 115.09,99.82 114.75,99.82 114.62,99.69 114.62,96.47 114.75,96.35 115.2,96.35 115.33,96.22 115.33,95.95
  IN1 w0.127: 115.33,95.95 115.33,81.36 118.38,78.3 118.61,78.3 119.36,79.05 119.52,79.05 119.73,78.84 119.73,78.68 118.9,77.85 118.9,77.67 119.09,77.49 119.27,77.49 120.1,78.31 120.26,78.31 120.46,78.11 120.46,77.95 119.64,77.12 119.64,76.94 119.82,76.75 120,76.75 120.83,77.58 120.99,77.58 121.2,77.37 121.2,77.21 120.37,76.38 120.37,76.2 120.56,76.01 120.74,76.01 121.57,76.84 121.73,76.84 121.94,76.63 121.94,76.47 121.11,75.64 121.11,75.46 121.3,75.28 121.48,75.28 122.31,76.1 122.47,76.1 122.67,75.9 122.67,75.74 121.84,74.9 121.84,74.74 122.77,73.81 v2(122.77,71.49)
  BOTTOM w0.076: v2(115.67,99.08) 116.06,99.48 116.06,103.15 115.6,103.61 115.58,103.61 115.16,104.04 115.16,104.82 UC1.AY25
  BOTTOM w0.102: v2(122.77,71.49) 123.63,71.49 124.55,72.41 JDIMM2.15
DDR_B_D11: length 56.4
  IN1 w0.084: 115.68,95.95 115.68,96.45 115.55,96.57 114.96,96.57 114.84,96.7 114.84,97.07 114.92,97.15 115.2,97.15 115.28,97.23 115.28,97.4 115.2,97.48 114.92,97.48 114.84,97.57 114.84,97.74 114.92,97.82 115.2,97.82 115.28,97.9 115.28,98.07 115.2,98.16 114.92,98.16 114.84,98.24 114.84,98.61 114.96,98.73 115.54,98.73 115.67,98.61 v2(115.67,98.43)
  IN1 w0.127: v2(122.77,69.97) 123.39,70.59 123.39,75.71 119.45,79.65 119.24,79.65 118.52,78.93 118.34,78.93 118.15,79.12 118.15,79.3 118.87,80.02 118.87,80.18 118.67,80.39 118.51,80.39 117.78,79.66 117.6,79.66 117.41,79.85 117.41,80.03 118.14,80.76 118.14,80.92 117.93,81.13 117.77,81.13 117.06,80.42 116.88,80.42 116.69,80.61 116.69,80.79 117.4,81.5 117.4,81.66 117.19,81.86 117.03,81.86 116.33,81.16 116.04,81.16 115.68,81.52 115.68,82.48 116.06,82.85 116.06,83.06 115.68,83.44 115.68,95.95
  BOTTOM w0.076: UC1.AW25 115.5,105.37 115.5,105.17 115.53,105.11 115.53,105.11 115.58,105.01 115.58,104.82 115.32,104.56 115.32,104.1 115.65,103.78 115.67,103.78 116.23,103.22 116.23,98.99 v2(115.67,98.43)
  BOTTOM w0.102: JDIMM2.17 125.15,72.35 v2(122.77,69.97)
DDR_B_D12: length 56.6
  IN1 w0.084: 112.72,96.58 112.72,97.88 112.67,97.93 112.67,102.07 v2(113.58,102.98)
  IN1 w0.127: 112.72,96.58 112.72,77.49 119.89,70.32 119.89,64.43 120.02,64.31 121.12,64.31 121.25,64.18 121.25,63.92 121.12,63.8 120.02,63.8 119.89,63.67 119.89,63.42 120.02,63.29 121.12,63.29 121.25,63.16 121.25,62.91 121.12,62.78 120.74,62.78 120.62,62.65 120.62,62.4 120.74,62.27 121.53,62.27 v2(121.82,61.99)
  BOTTOM w0.076: UC1.AV27 114.04,106.11 113.64,105.71 113.64,105.31 113.48,105.14 113.48,104.68 113.35,104.56 113.35,103.65 113.58,103.41 v2(113.58,102.98)
  BOTTOM w0.102: JDIMM2.4 121.25,62.56 v2(121.82,61.99)
DDR_B_D13: length 57.2
  IN1 w0.084: 116.45,95.95 116.54,96.04 116.54,97.4 116.04,97.9 116.04,101.96 v2(115.67,102.33)
  IN1 w0.127: 116.45,95.95 116.45,83.66 124.1,76.01 124.1,69.9 123.76,69.56 123.76,68.76 123.88,68.64 124.62,68.64 124.74,68.51 124.74,68.23 124.62,68.1 123.88,68.1 123.76,67.98 123.76,67.7 123.88,67.57 124.93,67.57 125.06,67.44 125.06,67.16 124.93,67.04 123.88,67.04 123.76,66.91 123.76,66.63 123.88,66.5 124.74,66.5 124.87,66.38 124.87,66.1 124.74,65.97 123.88,65.97 123.76,65.84 123.76,65.34 123.88,65.21 125,65.21 125.12,65.08 v2(125.12,63.51)
  BOTTOM w0.076: v2(115.67,102.33) 115.24,102.76 115.24,103.09 114.83,103.5 114.83,105.05 114.9,105.2 114.9,105.33 114.83,105.49 114.83,105.7 114.85,105.75 114.89,105.84 114.9,105.85 114.9,106.69 114.7,106.89 UC1.AU27
  BOTTOM w0.102: v2(125.12,63.51) 124.85,63.78 JDIMM2.16
DDR_B_D14: length 56.7
  IN1 w0.084: 113.79,95.95 113.79,97.43 113.98,97.62 113.98,101.3 v2(115.67,102.98)
  IN1 w0.127: 113.79,95.95 113.79,80.63 114,80.42 114,80.24 113.79,80.03 113.79,79.73 114,79.52 114.18,79.52 114.4,79.74 114.58,79.74 114.76,79.55 114.76,79.37 113.9,78.51 113.9,78.33 114.09,78.14 114.27,78.14 115.15,79.02 115.33,79.02 115.51,78.83 115.51,78.65 114.62,77.75 114.62,77.57 114.8,77.38 114.98,77.38 115.9,78.3 116.08,78.3 116.27,78.11 116.27,77.93 115.35,77.01 115.35,76.83 115.54,76.64 115.72,76.64 116.66,77.58 116.84,77.58 117,77.42 117,77.24 116.54,76.78 116.54,76.6 116.74,76.41 116.92,76.41 117.38,76.86 117.56,76.86 118.6,75.82 118.6,75.62 118.43,75.45 118.43,74.92 119.38,73.97 119.66,73.97 119.96,74.27 120.15,74.27 121.23,73.19 121.23,70.09 121.1,69.97 v2(120.74,69.97)
  BOTTOM w0.076: v2(115.67,102.98) 114.99,103.66 114.99,105.01 115.04,105.11 115.07,105.17 115.07,105.37 115.04,105.42 115.04,105.42 115,105.51 114.99,105.53 114.99,105.66 115.04,105.76 115.28,106.01 UC1.AV25
  BOTTOM w0.102: JDIMM2.7 122.15,71.38 v2(120.74,69.97)
DDR_B_D15: length 58.2
  IN1 w0.084: v2(115.67,97.78) 115.61,97.72 115.61,96.94 116.1,96.45 116.1,95.95
  IN1 w0.127: 116.1,95.95 116.1,83.51 116.54,83.07 116.54,82.85 116.07,82.38 116.07,82.2 116.26,82.01 116.44,82.01 116.91,82.48 117.13,82.48 123.74,75.86 123.74,70.05 123.4,69.71 123.4,64.99 123.53,64.87 124.58,64.87 124.71,64.74 124.71,64.36 124.58,64.23 123.92,64.23 123.79,64.1 123.79,63.82 123.92,63.7 124.58,63.7 124.71,63.57 124.71,63.17 124.58,63.04 124.23,63.04 124.11,62.92 124.11,62.54 124.23,62.41 124.7,62.41 v2(125.12,61.99)
  BOTTOM w0.076: UC1.AU25 115.67,106.51 115.67,105.2 115.72,105.1 115.74,105.04 115.74,104.75 115.6,104.61 115.49,104.5 115.49,104.17 115.72,103.94 115.73,103.94 116.39,103.28 116.39,98.51 v2(115.67,97.78)
  BOTTOM w0.102: JDIMM2.18 125.45,63.86 125.53,63.78 125.53,62.39 v2(125.12,61.99)
DDR_B_D16: length 89.4
  IN3 w0.084: v2(112.54,109.68) 111.99,109.13 111.99,107.45 112.15,107.3 112.15,105.32 114.89,102.58 114.89,97.5 115.53,96.85 115.78,96.6 116.33,96.6 116.92,96.01 116.92,95.95
  IN3 w0.127: v2(167.76,68.72) 167.46,68.72 167.34,68.59 167.34,68.19 167.21,68.06 166.93,68.06 166.8,68.19 166.8,77.45 156.75,87.5 153.17,87.5 152.07,88.6 151.25,88.6 150.34,89.51 123.51,89.51 118.46,94.57 118.11,94.57 117.55,95.13 116.92,95.76 116.92,95.95
  BOTTOM w0.076: UC1.AM29 112.86,110 v2(112.54,109.68)
  BOTTOM w0.102: v2(167.76,68.72) 166.25,67.21 JDIMM2.146
DDR_B_D17: length 90.9
  IN3 w0.084: v2(112.54,110.98) 111.82,110.26 111.82,107.36 111.97,107.21 111.97,105.25 114.7,102.53 114.7,97.41 115.41,96.7 115.68,96.43 116.12,96.43 116.3,96.25
  IN3 w0.127: 116.3,96.25 116.56,95.99 116.56,95.61 117.96,94.2 118.31,94.2 123.36,89.15 150.19,89.15 151.1,88.24 151.92,88.24 153.02,87.14 156.6,87.14 166.44,77.3 166.44,66.73 166.57,66.6 167.63,66.6 167.76,66.73 v2(167.76,67.19)
  BOTTOM w0.076: UC1.AK29 112.86,111.31 v2(112.54,110.98)
  BOTTOM w0.102: JDIMM2.148 166.85,66.67 167.37,67.19 v2(167.76,67.19)
DDR_B_D18: length 89.6
  IN3 w0.084: v2(113.48,110.33) 113.95,109.86 113.95,109.24 114.04,109.15 114.04,107.35 116.79,104.61 116.79,98.21 117.91,97.09 118.09,97.09 118.43,96.76 119.79,96.76 120.55,95.99 121.29,95.99 121.66,95.62
  IN3 w0.127: v2(170.34,68.72) 170.78,69.15 170.78,77.96 157.19,91.55 155.5,91.55 154.57,92.48 126.45,92.48 125.93,92.99 124.29,92.99 121.66,95.62
  BOTTOM w0.076: v2(113.48,110.33) 113.8,110.65 UC1.AL28
  BOTTOM w0.102: v2(170.34,68.72) 170.78,68.27 170.78,66.73 170.45,66.4 JDIMM2.160
DDR_B_D19: length 90.3
  IN3 w0.084: 122.29,95.62 121.75,96.17 120.63,96.17 119.86,96.93 118.5,96.93 118.17,97.26 117.98,97.26 116.96,98.28 116.96,104.82 114.82,106.96 114.82,110.46 v2(114.31,110.97)
  IN3 w0.127: v2(170.34,67.19) 170.87,67.72 170.87,68.73 171.14,69 171.14,78.11 157.35,91.9 155.66,91.9 154.72,92.84 126.6,92.84 126.08,93.36 124.56,93.36 122.29,95.62
  BOTTOM w0.076: UC1.AK28 113.98,111.31 v2(114.31,110.97)
  BOTTOM w0.102: v2(170.34,67.19) 169.85,66.7 JDIMM2.158
DDR_B_D20: length 87.1
  IN3 w0.084: v2(112.54,107.73) 112.54,105.42 115.27,102.69 115.27,97.62 115.8,97.08 115.94,96.95 116.69,96.95 117.52,96.11 117.67,96.11 117.83,95.95
  IN3 w0.127: v2(167.76,71.76) 167.76,71.76 168.03,71.49 168.27,71.49 168.4,71.62 168.4,72.15 168.27,72.28 167.65,72.28 167.52,72.41 167.52,72.67 167.65,72.8 168.27,72.8 168.4,72.92 168.4,73.18 168.27,73.31 167.65,73.31 167.52,73.44 167.52,73.7 167.65,73.83 168.19,73.83 168.32,73.95 168.32,74.22 168.19,74.34 167.65,74.34 167.52,74.47 167.52,77.75 157.05,88.22 156.28,88.22 156.14,88.35 156.14,89.13 156.01,89.26 155.75,89.26 155.63,89.13 155.63,88.35 155.5,88.23 155.24,88.23 155.11,88.35 155.11,89.2 154.99,89.32 151.55,89.32 150.64,90.23 123.81,90.23 118.75,95.29 118.49,95.29 117.83,95.95
  BOTTOM w0.089: UC1.AR29 112.92,107.86 112.79,107.73 v2(112.54,107.73)
  BOTTOM w0.102: JDIMM2.149 167.15,72.14 167.52,71.76 v2(167.76,71.76)
DDR_B_D21: length 88.8
  IN3 w0.084: 117,96.26 116.5,96.77 115.87,96.77 115.08,97.56 115.08,102.64 112.35,105.36 112.35,107.34 112.17,107.52 112.17,108.95 112.24,109.03 v2(112.54,109.03)
  IN3 w0.127: v2(167.76,70.24) 167.29,70.24 167.17,70.37 167.17,77.6 156.9,87.86 154.87,87.86 154.75,87.99 154.75,88.84 154.62,88.97 154.36,88.97 154.23,88.84 154.23,87.99 154.1,87.86 153.84,87.86 153.72,87.99 153.72,88.83 153.58,88.97 153.33,88.97 153.2,88.83 153.2,88.5 153.07,88.37 152.81,88.37 152.68,88.5 152.68,88.83 152.55,88.97 151.4,88.97 150.49,89.88 123.66,89.88 118.61,94.93 118.34,94.93 117,96.26
  BOTTOM w0.076: v2(112.54,109.03) 112.86,109.35 UC1.AN29
  BOTTOM w0.102: JDIMM2.147 166.55,71.45 v2(167.76,70.24)
DDR_B_D22: length 87.3
  IN3 w0.084: 120.64,95.62 120.44,95.62 119.65,96.41 118.28,96.41 117.95,96.74 117.77,96.74 116.39,98.12 116.39,104.35 113.48,107.27 v2(113.48,107.73)
  IN3 w0.127: 120.64,95.62 121.69,94.57 124.51,91.75 151.99,91.75 152.12,91.63 152.12,90.97 152.26,90.83 156.87,90.83 169.04,78.67 169.04,76.51 169.17,76.39 169.79,76.39 169.92,76.26 169.92,76 169.79,75.87 169.32,75.87 169.19,75.74 169.19,75.48 169.32,75.36 169.79,75.36 169.92,75.23 169.92,70.88 169.65,70.61 169.65,70.22 169.77,70.09 170.19,70.09 v2(170.34,70.24)
  BOTTOM w0.089: v2(113.48,107.73) 113.48,107.87 113.66,108.05 UC1.AR28
  BOTTOM w0.102: JDIMM2.157 169.55,71.03 v2(170.34,70.24)
DDR_B_D23: length 88
  IN3 w0.084: 121.15,95.62 120.95,95.82 120.48,95.82 119.72,96.58 118.35,96.58 118.02,96.92 117.84,96.92 116.56,98.19 116.56,104.52 113.87,107.21 113.87,108.27 113.76,108.38 v2(113.48,108.38)
  IN3 w0.127: 121.15,95.62 124.14,92.63 125.21,92.63 125.34,92.5 125.34,92.24 125.47,92.12 152.36,92.12 152.49,91.99 152.49,91.33 152.61,91.21 152.87,91.21 153,91.33 153,91.99 153.13,92.12 153.39,92.12 153.52,91.99 153.52,91.33 153.64,91.21 153.9,91.21 154.03,91.33 154.03,91.99 154.16,92.12 154.42,92.12 154.55,91.99 154.55,91.33 154.69,91.19 157.03,91.19 169.4,78.82 169.4,77.91 169.53,77.78 170.29,77.78 170.41,77.65 170.41,77.39 170.29,77.27 169.53,77.27 169.4,77.14 169.4,76.87 169.52,76.75 170.21,76.75 170.34,76.62 v2(170.34,71.76)
  BOTTOM w0.076: v2(113.48,108.38) 113.48,108.53 113.65,108.7 UC1.AP28
  BOTTOM w0.102: v2(170.34,71.76) 170.15,71.95 JDIMM2.159
DDR_B_D24: length 56.6
  IN1 w0.084: 117.8,95.95 117.8,96.87 116.56,98.11 116.56,103.11 115.92,103.75 115.66,103.75 115.34,104.07 115.34,104.59 114.04,105.89 114.04,108.93 114.15,109.03 v2(114.43,109.03)
  IN1 w0.127: 117.8,95.95 117.8,86.49 118.5,85.79 118.5,83.51 126.17,75.84 126.17,64.83 126.29,64.7 127.03,64.7 127.16,64.57 127.16,64.29 127.03,64.17 126.29,64.17 126.17,64.04 126.17,63.64 126.29,63.51 v2(127.66,63.51)
  BOTTOM w0.076: UC1.AN26 114.76,109.35 v2(114.43,109.03)
  BOTTOM w0.102: v2(127.66,63.51) 127.25,63.92 JDIMM2.24
DDR_B_D25: length 56.2
  IN1 w0.084: v2(114.43,107.73) 114.27,107.56 114.27,106.03 115.47,104.83 115.92,104.83 116.26,104.49 116.26,103.65 116.73,103.18 116.73,98.2 118.15,96.77 118.15,95.95
  IN1 w0.127: v2(127.66,61.99) 128.16,62.48 128.16,65.47 126.52,67.11 126.52,75.99 118.85,83.66 118.85,85.92 118.15,86.62 118.15,95.95
  BOTTOM w0.089: UC1.AR26 114.76,108.05 v2(114.43,107.73)
  BOTTOM w0.102: v2(127.66,61.99) 126.65,63 JDIMM2.22
DDR_B_D26: length 55.1
  IN1 w0.084: v2(115.38,107.73) 115.38,107.67 117,106.05 117,105.93 116.69,105.62 116.69,105.45 116.81,105.33 116.98,105.33 117.28,105.63 117.4,105.63 117.62,105.4 117.62,105.29 117.36,105.02 117.36,104.91 117.94,104.32 117.94,98.05 119.68,96.31 119.68,95.62
  IN1 w0.127: v2(129.38,71.49) 129.38,71.26 129.25,71.13 128.68,71.13 128.55,71.26 128.55,71.49 128.43,71.62 128.17,71.62 128.04,71.74 128.04,72.05 128.17,72.18 129.37,72.18 129.51,72.32 129.51,72.59 129.39,72.71 128.17,72.71 128.04,72.83 128.04,73.11 128.17,73.24 129.37,73.24 129.51,73.38 129.51,73.66 129.39,73.77 128.17,73.77 128.04,73.9 128.04,74.18 128.17,74.31 129.37,74.31 129.51,74.45 129.51,75.18 129.38,75.31 128.23,75.31 128.1,75.44 128.1,76.59 120.38,84.32 120.38,92.28 119.68,92.98 119.68,95.62
  BOTTOM w0.076: UC1.AR25 115.71,108.05 v2(115.38,107.73)
  BOTTOM w0.102: v2(129.38,71.49) 129.51,71.49 129.95,71.94 JDIMM2.33
DDR_B_D27: length 55.8
  IN1 w0.084: 120.04,95.62 120.04,96.24 118.12,98.16 118.12,104.4 117.68,104.83 117.68,105.1 117.82,105.24 117.82,105.47 115.77,107.53 115.77,108.25 115.64,108.38 v2(115.38,108.38)
  IN1 w0.127: 120.04,95.62 120.04,93.11 120.74,92.41 120.74,85.4 120.95,85.19 120.95,85.1 120.72,84.87 120.72,84.69 121,84.41 121.18,84.41 121.46,84.69 121.64,84.69 121.84,84.49 121.84,84.31 121.45,83.93 121.45,83.78 121.68,83.55 121.83,83.55 122.21,83.93 122.39,83.93 122.59,83.74 122.59,83.56 122.21,83.17 122.21,83.02 122.44,82.8 122.58,82.8 122.99,83.2 123.17,83.2 123.37,83.01 123.37,82.83 122.96,82.42 122.96,82.24 123.16,82.04 123.34,82.04 123.68,82.38 123.86,82.38 124.06,82.19 124.06,82.01 123.72,81.66 123.72,81.48 128.67,76.53 128.67,76.35 128.45,76.12 128.45,75.95 128.64,75.75 128.82,75.75 129.05,75.97 129.23,75.97 129.86,75.34 129.86,69.9 129.73,69.78 129.51,69.78 129.38,69.9 v2(129.38,69.97)
  BOTTOM w0.076: v2(115.38,108.38) 115.71,108.7 UC1.AP25
  BOTTOM w0.102: v2(129.38,69.97) 130.55,71.14 JDIMM2.35
DDR_B_D28: length 58.1
  IN1 w0.084: 117.09,95.95 117.09,96.83 116.83,97.08 116.83,97.35 116.21,97.97 116.21,102.97 115.78,103.4 115.52,103.4 114.99,103.94 114.99,104.35 114.86,104.48 113.04,104.48 112.91,104.61 112.91,110.87 113.04,111 113.85,111 113.93,111.08 113.93,111.4 113.85,111.49 113.02,111.49 112.9,111.61 112.9,112.02 113.02,112.14 115.21,112.14 115.33,112.02 115.33,111.8 115.21,111.67 v2(115.2,111.67)
  IN1 w0.127: 117.09,95.95 117.09,83.92 124.73,76.27 124.73,76.07 124.86,75.94 125.04,75.94 125.16,75.81 125.16,75.54 125.04,75.41 124.87,75.41 124.74,75.28 124.74,74.6 124.87,74.47 125.34,74.47 125.47,74.35 125.47,74.07 125.34,73.94 124.87,73.94 124.74,73.81 124.74,73.57 124.87,73.45 125.34,73.45 125.47,73.32 125.47,73.04 125.34,72.91 124.87,72.91 124.74,72.78 124.74,71.36 124.87,71.24 125.18,71.24 125.31,71.36 v2(125.31,71.49)
  BOTTOM w0.076: UC1.AK26 114.84,111.31 v2(115.2,111.67)
  BOTTOM w0.102: v2(125.31,71.49) 126.35,72.53 JDIMM2.21
DDR_B_D29: length 58
  IN1 w0.084: 117.44,95.95 117.44,96.98 116.38,98.04 116.38,103.04 115.85,103.57 115.59,103.57 115.16,104.01 115.16,104.53 115.03,104.65 114.58,104.65 114.46,104.78 114.46,105.02 114.33,105.14 113.76,105.14 113.63,105.02 113.63,104.78 113.55,104.7 113.25,104.7 113.12,104.83 113.12,105.48 113.25,105.61 113.79,105.61 113.87,105.69 113.87,106.68 113.79,106.76 113.21,106.76 113.08,106.89 113.08,107.13 113.21,107.25 113.79,107.25 113.87,107.34 113.87,109.83 114,109.96 114.27,109.96 114.39,109.83 v2(114.39,109.64)
  IN1 w0.127: 117.44,95.95 117.44,86 117.57,85.87 117.93,85.87 118.06,85.74 118.06,85.48 117.93,85.35 117.63,85.35 117.5,85.22 117.5,84.99 117.63,84.87 117.92,84.87 118.05,84.74 118.05,84.47 117.92,84.35 117.71,84.35 117.58,84.22 117.58,83.93 117.76,83.75 118.03,83.75 118.15,83.62 118.15,83.37 125.81,75.71 125.81,72.73 125.65,72.57 125.25,72.57 125.12,72.44 125.12,72.06 125.25,71.93 125.6,71.93 125.75,71.78 125.75,69.79 125.6,69.65 125.43,69.65 125.31,69.77 v2(125.31,69.97)
  BOTTOM w0.076: UC1.AM26 114.76,110 v2(114.39,109.64)
  BOTTOM w0.102: JDIMM2.23 126.95,71.61 v2(125.31,69.97)
DDR_B_D30: length 58.2
  IN1 w0.084: v2(115.33,110.98) 115.94,110.37 115.94,110.17 116.73,109.38 116.73,107.65 118.02,106.37 118.02,105.83 118.47,105.38 118.47,98.38 120.75,96.09 120.75,95.62
  IN1 w0.127: v2(130.2,63.51) 131.41,63.51 131.54,63.64 131.54,63.89 131.41,64.02 130.74,64.02 130.62,64.14 130.62,75.59 124.76,81.45 124.76,82.59 121.45,85.9 121.45,92.67 120.75,93.37 120.75,95.62
  BOTTOM w0.076: UC1.AK25 115.66,111.31 v2(115.33,110.98)
  BOTTOM w0.102: JDIMM2.34 130.25,63.55 v2(130.2,63.51)
DDR_B_D31: length 58.9
  IN1 w0.084: 120.39,95.62 120.39,96.17 118.29,98.28 118.29,105.25 115.94,107.6 115.94,109.8 v2(115.42,110.33)
  IN1 w0.127: 120.39,95.62 120.39,93.24 121.09,92.54 121.09,85.77 124.4,82.46 124.4,81.3 130.24,75.46 130.24,65.95 129.79,65.5 129.79,62.4 v2(130.2,61.99)
  BOTTOM w0.076: v2(115.42,110.33) 115.74,110.65 UC1.AL25
  BOTTOM w0.102: JDIMM2.36 130.85,62.63 v2(130.2,61.99)
DDR_B_D32: length 85.6
  IN3 w0.084: v2(117.57,101.44) 117.95,101.44 118.33,101.06 118.33,98.18 118.82,97.68 120.08,97.68 120.91,96.86 125.95,96.86 126.16,96.65
  IN3 w0.127: v2(172.63,67.19) 173.25,67.82 173.25,74.41 173.13,74.54 173,74.54 172.87,74.66 172.87,75.17 173,75.3 173.16,75.3 173.29,75.43 173.29,78.7 157.64,94.35 155.66,94.35 155.44,94.57 137.92,94.57 137.79,94.7 137.79,94.87 137.67,94.99 132.22,94.99 132.09,94.87 132.09,94.7 131.96,94.57 128.23,94.57 126.16,96.65
  BOTTOM w0.076: v2(117.57,101.44) 116.89,102.13 116.89,103.72 116.65,103.96 116.65,104.67 116.64,104.69 UC1.AY23
  BOTTOM w0.102: v2(172.63,67.19) 172.25,66.82 JDIMM2.166
DDR_B_D33: length 86.5
  IN3 w0.084: 125.84,96.46 125.61,96.69 120.84,96.69 120.08,97.45 118.71,97.45 118.16,98 118.16,99.37 117.82,99.71 v2(117.57,99.71)
  IN3 w0.127: 125.84,96.46 126.29,96.01 126.29,95.82 126.04,95.57 126.04,95.39 126.22,95.2 126.4,95.2 126.65,95.45 126.84,95.45 127.02,95.28 127.02,95.09 126.74,94.81 126.74,94.64 126.93,94.45 127.11,94.45 127.38,94.72 127.57,94.72 128.08,94.21 132.45,94.21 132.58,94.35 132.58,94.5 132.72,94.63 132.96,94.63 133.1,94.5 133.1,94.35 133.23,94.21 133.48,94.21 133.61,94.35 133.61,94.5 133.75,94.63 133.99,94.63 134.13,94.5 134.13,94.35 134.26,94.21 134.51,94.21 134.64,94.35 134.64,94.5 134.78,94.63 135.03,94.63 135.16,94.5 135.16,94.35 135.29,94.21 135.54,94.21 135.68,94.35 135.68,94.5 135.81,94.63 136.06,94.63 136.19,94.5 136.19,94.35 136.33,94.21 136.57,94.21 136.71,94.35 136.71,94.5 136.84,94.63 137.09,94.63 137.22,94.5 137.22,94.35 137.36,94.21 155.29,94.21 155.51,93.99 157.49,93.99 172.51,78.96 172.51,77.47 172.64,77.34 172.79,77.34 172.93,77.2 172.93,76.96 172.79,76.82 172.64,76.82 172.51,76.69 172.51,76.44 172.64,76.31 172.79,76.31 172.93,76.17 172.93,75.92 172.79,75.79 172.64,75.79 172.51,75.66 172.51,74.31 172.64,74.18 172.76,74.18 172.89,74.05 172.89,73.79 172.76,73.66 172.64,73.66 172.51,73.53 172.51,73.28 172.64,73.15 172.76,73.15 172.89,73.02 172.89,72.76 172.76,72.63 172.64,72.63 172.51,72.5 172.51,71.88 v2(172.63,71.76)
  BOTTOM w0.076: UC1.AW23 116.64,105.39 116.44,105.19 116.34,105.01 116.34,104.74 116.48,104.61 116.48,103.89 116.72,103.65 116.72,100.56 v1(116.92,100.36) v2(117.57,99.71)
  BOTTOM w0.102: v2(172.63,71.76) 171.95,72.44 JDIMM2.165
DDR_B_D34: length 86.2
  IN3 w0.084: 130.88,97.41 130.22,97.41 129.82,97.02 127.85,97.02 127.32,97.55 121.2,97.55 119.67,99.08 v2(119.17,99.08)
  IN3 w0.127: 130.88,97.41 139.39,97.41 140.26,96.53 158.1,96.53 175.17,79.47 175.17,72.49 175.55,72.11 175.55,69.5 v2(176.34,68.72)
  BOTTOM w0.076: v2(119.17,99.08) 118.4,99.85 118.4,103.34 118.11,103.63 118.11,104.82 UC1.AY21
  BOTTOM w0.102: JDIMM2.174 174.65,67.03 v2(176.34,68.72)
DDR_B_D35: length 86.7
  IN3 w0.084: 131.24,97.77 130.46,97.77 130.41,97.82 127,97.82 126.96,97.77 122.12,97.77 122.08,97.72 121.27,97.72 120.49,98.51 120.49,99.62 120.38,99.73 v2(119.17,99.73)
  IN3 w0.127: v2(176.34,70.24) 176.04,70.24 175.91,70.37 175.91,72.26 175.53,72.64 175.53,75.58 175.66,75.71 175.77,75.71 175.89,75.84 175.89,76.1 175.77,76.23 175.66,76.23 175.53,76.36 175.53,76.61 175.66,76.74 175.77,76.74 175.89,76.87 175.89,77.13 175.77,77.26 175.66,77.26 175.53,77.39 175.53,77.64 175.66,77.77 175.77,77.77 175.89,77.9 175.89,78.16 175.77,78.29 175.66,78.29 175.53,78.42 175.53,79.69 158.32,96.9 140.41,96.9 139.54,97.77 131.24,97.77
  BOTTOM w0.076: UC1.AW21 117.99,105.36 118.28,105.06 118.28,103.7 118.57,103.4 118.57,100.33 v2(119.17,99.73)
  BOTTOM w0.102: JDIMM2.175 174.95,71.63 v2(176.34,70.24)
DDR_B_D36: length 87.5
  IN3 w0.084: 124.3,96.43 124.22,96.51 120.77,96.51 120.01,97.28 118.64,97.28 117.98,97.93 117.98,98.67 v2(117.57,99.08)
  IN3 w0.127: v2(172.63,70.24) 172.25,70.24 172.15,70.35 172.15,78.81 157.34,93.62 155.36,93.62 155.14,93.85 127.02,93.85 126.5,94.36 125.59,94.36 125.46,94.49 125.46,96 125.33,96.13 125.07,96.13 124.95,96 124.95,94.91 124.82,94.78 124.56,94.78 124.43,94.91 124.43,96.3 124.3,96.43
  BOTTOM w0.076: v2(117.57,99.08) 116.56,100.1 116.56,103.58 116.32,103.82 116.32,104.54 116.18,104.67 116.18,105.05 116.2,105.09 116.25,105.2 116.25,105.86 UC1.AV23
  BOTTOM w0.102: v2(172.63,70.24) 171.35,71.51 JDIMM2.163
DDR_B_D37: length 88.4
  IN3 w0.084: v2(117.57,100.88) 117.14,100.45 117.14,98.35 118.03,97.46 118.21,97.46 118.57,97.1 119.93,97.1 120.7,96.34 122.48,96.34 122.88,95.95
  IN3 w0.127: v2(172.63,68.72) 172.63,68.57 172.37,68.32 171.91,68.32 171.78,68.44 171.78,78.66 157.91,92.54 155.93,92.54 154.98,93.48 126.87,93.48 126.35,94 124.82,94 123.96,94.86 123.96,95.38 123.79,95.56 123.27,95.56 122.88,95.95
  BOTTOM w0.076: v2(117.57,100.88) 118.07,101.38 118.07,103.21 117.76,103.51 117.76,104.52 117.53,104.75 117.53,105.05 117.6,105.2 117.6,105.33 117.53,105.49 117.53,105.7 117.55,105.75 117.6,105.84 117.6,105.85 117.6,106.04 117.59,106.05 117.59,106.43 117.6,106.45 117.6,106.69 117.4,106.89 UC1.AU23
  BOTTOM w0.102: v2(172.63,68.72) 171.65,67.74 JDIMM2.164
DDR_B_D38: length 87.4
  IN3 w0.084: 129.99,96.51 127.97,96.51 127.1,97.38 121.13,97.38 120.07,98.43 v2(119.17,98.43)
  IN3 w0.127: 129.99,96.51 139.78,96.51 140.11,96.18 157.96,96.18 174.81,79.32 174.81,72.35 175.19,71.96 175.19,68.33 v2(176.34,67.19)
  BOTTOM w0.076: v2(119.17,98.43) 118.72,98.88 118.72,98.9 118.24,99.38 118.24,102.91 118.23,102.92 118.23,103.27 117.94,103.57 117.94,104.58 117.69,104.82 117.69,105.01 117.74,105.11 117.77,105.17 117.77,105.37 117.74,105.42 117.74,105.42 117.7,105.51 117.69,105.53 117.69,105.66 117.72,105.71 117.74,105.76 117.88,105.9 UC1.AV21
  BOTTOM w0.102: JDIMM2.176 175.25,66.37 176.07,67.19 v2(176.34,67.19)
DDR_B_D39: length 87.9
  IN3 w0.084: 131.57,98.14 130.95,98.14 130.1,98.99 121.88,98.99 121.69,99.18 121.69,100.3 121.31,100.68 119.47,100.68 v2(119.17,100.38)
  IN3 w0.127: 131.57,98.14 140.23,98.14 140.37,98 140.37,97.45 140.5,97.33 140.76,97.33 140.88,97.45 140.88,98 141.02,98.14 141.27,98.14 141.4,98 141.4,97.39 141.53,97.26 141.79,97.26 141.92,97.39 141.92,98 142.05,98.14 142.3,98.14 142.43,98 142.43,97.39 142.56,97.26 142.82,97.26 142.95,97.39 142.95,97.78 143.07,97.91 143.34,97.91 143.46,97.78 143.46,97.39 143.59,97.26 158.47,97.26 176.26,79.48 176.26,75.46 175.89,75.09 175.89,72.95 176.34,72.51 v2(176.34,71.76)
  BOTTOM w0.076: UC1.AU21 117.88,106.66 118.17,106.36 118.17,106.12 118.15,106.1 118.15,105.84 118.28,105.71 118.28,105.3 118.44,105.13 118.44,103.77 118.74,103.47 118.74,100.82 v2(119.17,100.38)
  BOTTOM w0.102: v2(176.34,71.76) 176.21,71.76 175.55,72.42 JDIMM2.177
DDR_B_D40: length 53.7
  IN1 w0.084: v2(119.17,101.68) 119.45,101.68 119.54,101.59 119.54,97.89 121.41,96.03 121.41,95.62
  IN1 w0.127: v2(132.07,70.05) 132.07,69.81 131.94,69.69 131.42,69.69 131.3,69.81 131.3,75.81 128.82,78.28 128.82,78.46 129.36,79 129.36,79.18 129.16,79.38 128.98,79.38 128.44,78.84 128.26,78.84 128.07,79.04 128.07,79.22 128.6,79.75 128.6,79.93 128.41,80.13 128.23,80.13 127.69,79.59 127.51,79.59 127.31,79.79 127.31,79.97 127.85,80.51 127.85,80.69 127.65,80.89 127.47,80.89 126.94,80.35 126.76,80.35 126.56,80.55 126.56,80.73 127.1,81.26 127.1,81.44 126.9,81.64 126.72,81.64 126.18,81.1 126,81.1 125.8,81.3 125.8,81.48 126.34,82.02 126.34,82.22 126.18,82.39 125.98,82.39 125.77,82.17 125.59,82.17 125.39,82.37 125.39,82.85 122.08,86.16 122.08,92.94 121.41,93.61 121.41,95.62
  BOTTOM w0.076: v2(119.17,101.68) 119.73,102.24 119.73,103.18 118.94,103.97 118.94,104.82 UC1.AY19
  BOTTOM w0.102: JDIMM2.39 131.75,72.25 131.66,72.17 131.66,70.46 v2(132.07,70.05)
DDR_B_D41: length 54.5
  IN1 w0.084: v2(119.17,102.33) 119.17,102.51 119.3,102.63 119.78,102.63 119.91,102.51 119.91,101.88 119.72,101.69 119.72,97.96 120.92,96.76 121.03,96.76 121.18,96.91 121.3,96.91 121.52,96.68 121.52,96.56 121.38,96.42 121.38,96.3 121.76,95.92 121.76,95.62
  IN1 w0.127: 121.76,95.62 121.76,93.76 122.44,93.08 122.44,86.29 122.74,85.99 123.09,85.99 123.28,85.81 123.28,85.45 123.49,85.24 123.84,85.24 124.03,85.05 124.03,84.7 124.24,84.48 124.6,84.48 124.79,84.3 124.79,83.94 125,83.73 125.33,83.73 125.54,83.52 125.54,83.19 125.77,82.95 126.11,82.95 129.91,79.16 129.91,78.98 129.35,78.42 129.35,78.24 129.55,78.04 129.73,78.04 130.3,78.61 130.47,78.61 130.67,78.41 130.67,78.23 130.11,77.66 130.11,77.48 130.3,77.29 130.48,77.29 131.05,77.85 131.23,77.85 131.43,77.66 131.43,77.48 130.86,76.91 130.86,76.73 131.06,76.53 131.24,76.53 131.8,77.09 131.97,77.09 132.12,76.95 132.12,76.49 131.99,76.37 131.79,76.37 131.66,76.24 131.66,75.93 131.79,75.81 132.02,75.81 132.15,75.68 132.15,75.43 132.02,75.31 131.77,75.31 131.64,75.18 131.64,74.56 131.77,74.44 132.03,74.44 132.16,74.31 132.16,74.06 132.03,73.93 131.78,73.93 131.65,73.8 131.65,73.55 131.78,73.42 132.03,73.42 132.16,73.29 132.16,73.04 132.03,72.91 131.78,72.91 131.65,72.79 131.65,71.34 131.77,71.21 131.95,71.21 132.07,71.34 v2(132.07,71.57)
  BOTTOM w0.076: UC1.AW19 119.07,105.36 118.77,105.06 118.77,103.9 119.57,103.11 119.57,102.31 119.44,102.18 119.3,102.18 119.17,102.31 v2(119.17,102.33)
  BOTTOM w0.102: JDIMM2.41 132.35,72.44 132.48,72.32 132.56,72.32 132.68,72.2 132.68,72 132.55,71.87 132.12,71.87 132,71.74 132,71.65 v2(132.07,71.57)
DDR_B_D42: length 53.2
  IN1 w0.084: v2(121.04,102.97) 121.32,102.97 121.62,102.68 121.62,99.7 125.06,96.25 125.06,95.62
  IN1 w0.127: v2(135.73,70.05) 136.15,69.63 136.15,68.83 136.03,68.7 135.74,68.7 135.61,68.57 135.61,68.29 135.74,68.17 136.03,68.17 136.15,68.04 136.15,67.18 136.28,67.06 136.57,67.06 136.69,67.18 136.69,69.81 136.49,70.02 136.49,77.25 126.99,86.75 126.99,92.65 126.56,93.08 125.89,93.08 125.74,93.23 125.74,94.45 125.06,95.13 125.06,95.62
  BOTTOM w0.076: UC1.AY17 120.42,104.62 120.4,104.61 120.4,103.78 121.04,103.14 v2(121.04,102.97)
  BOTTOM w0.102: v2(135.73,70.05) 136.17,70.49 136.17,71.74 135.95,71.97 JDIMM2.53
DDR_B_D43: length 54.4
  IN1 w0.084: 124.35,95.62 124.35,96.02 121.9,98.47 121.12,98.47 v2(121.09,98.43)
  IN1 w0.127: 124.35,95.62 124.35,94.83 125.03,94.16 125.03,91.42 125.72,90.73 125.72,89.5 126.28,88.94 126.28,86.46 134.74,78 134.74,76.26 135.27,75.73 135.27,67.43 135.53,67.16 135.53,65.96 135.58,65.91 135.58,62.53 v2(135.03,61.99)
  BOTTOM w0.076: v2(121.09,98.43) 121.11,98.43 121.44,98.98 121.44,103.12 120.58,103.98 120.58,104.69 120.71,104.82 120.71,105.01 120.68,105.08 UC1.AW17
  BOTTOM w0.102: v2(135.03,61.99) 135.04,61.99 135.65,62.97 JDIMM2.52
DDR_B_D44: length 55.1
  IN1 w0.084: v2(119.17,102.98) 119.79,102.98 120.08,102.69 120.08,101.81 119.89,101.61 119.89,98.04 120.81,97.12 121.34,97.12 122.12,96.34 122.12,95.62
  IN1 w0.127: 122.12,95.62 122.12,93.91 122.79,93.23 122.79,86.78 132.5,77.07 132.5,68.86 132.19,68.54 132.19,62.54 v2(132.74,61.99)
  BOTTOM w0.076: UC1.AV19 119.17,106.11 118.77,105.71 118.77,105.31 118.61,105.14 118.61,103.83 119.17,103.27 v2(119.17,102.98)
  BOTTOM w0.102: JDIMM2.42 132.65,64.27 133.2,63.72 133.2,62.44 v2(132.74,61.99)
DDR_B_D45: length 55.6
  IN1 w0.084: v2(121.05,101.73) 120.25,101.73 120.1,101.59 120.1,98.07 120.84,97.33 121.68,97.33 122.47,96.54 122.47,95.62
  IN1 w0.127: v2(132.74,63.51) 133.12,63.51 133.25,63.64 133.25,64.19 133.12,64.32 132.79,64.32 132.67,64.43 132.67,64.77 132.79,64.89 133.12,64.89 133.25,65.02 133.25,65.3 133.12,65.42 132.79,65.42 132.67,65.54 132.67,65.88 132.79,65.99 133.03,65.99 133.16,66.12 133.16,66.42 132.85,66.73 132.85,77.23 123.15,86.92 123.15,93.38 122.47,94.05 122.47,95.62
  BOTTOM w0.076: v2(121.05,101.73) 120.81,101.73 120.47,102.07 120.47,103.24 120.07,103.64 120.07,104.6 119.96,104.71 119.96,105.05 120.03,105.2 120.03,105.33 119.96,105.49 119.96,105.7 119.98,105.75 120.03,105.84 120.03,105.85 120.03,106.69 119.83,106.89 UC1.AU19
  BOTTOM w0.102: JDIMM2.40 132.05,64.22 132.74,63.53 v2(132.74,63.51)
DDR_B_D46: length 54.3
  IN1 w0.084: v2(121.03,102.36) 121.03,102.41 121.16,102.54 121.3,102.54 121.43,102.41 121.43,99.51 121.62,99.31 121.62,99.19 121.48,99.05 121.48,98.87 121.65,98.71 121.83,98.71 121.96,98.84 122.14,98.84 122.3,98.67 122.3,98.49 122.28,98.46 122.28,98.34 122.5,98.11 122.62,98.11 122.66,98.15 122.78,98.15 124.7,96.23 124.7,95.62
  IN1 w0.127: 124.7,95.62 124.7,94.98 125.38,94.3 125.38,92.72 125.51,92.59 126.51,92.59 126.63,92.46 126.63,92.21 126.51,92.08 125.5,92.08 125.37,91.95 125.37,91.7 125.5,91.57 126.51,91.57 126.63,91.45 126.63,91.19 126.51,91.07 126.2,91.07 126.08,90.94 126.08,90.68 126.2,90.56 126.51,90.56 126.63,90.43 126.63,90.18 126.51,90.05 126.2,90.05 126.08,89.92 126.08,89.67 126.2,89.54 126.51,89.54 126.63,89.41 126.63,86.6 135.08,78.16 135.08,77.5 135.21,77.37 135.73,77.37 135.86,77.25 135.86,76.99 135.73,76.86 135.21,76.86 135.08,76.74 135.08,76.48 135.21,76.36 136.01,76.36 136.13,76.23 136.13,75.98 136.01,75.85 135.79,75.85 135.66,75.72 135.66,75.47 135.79,75.34 136.01,75.34 136.13,75.21 136.13,74.54 136.01,74.41 135.74,74.41 135.61,74.28 135.61,74 135.74,73.87 136.02,73.87 136.15,73.75 136.15,73.47 136.02,73.34 135.74,73.34 135.61,73.21 135.61,72.94 135.74,72.81 136.02,72.81 136.15,72.68 136.15,71.69 136.03,71.57 v2(135.73,71.57)
  BOTTOM w0.076: v2(121.03,102.36) 120.63,102.76 120.63,103.31 120.24,103.71 120.24,104.66 120.13,104.78 120.13,105.01 120.17,105.11 120.2,105.17 120.2,105.37 120.17,105.42 120.17,105.42 120.13,105.51 120.13,105.53 120.13,105.66 120.18,105.76 120.42,106.01 UC1.AV17
  BOTTOM w0.102: v2(135.73,71.57) 135.03,71.57 134.9,71.7 134.9,71.93 135.03,72.06 135.22,72.06 135.35,72.19 JDIMM2.51
DDR_B_D47: length 55.3
  IN1 w0.084: 123.99,95.62 123.99,96.13 122.03,98.1 v2(121.69,98.1)
  IN1 w0.127: 123.99,95.62 123.99,94.69 124.67,94.01 124.67,91.29 125.38,90.59 125.38,89.36 125.92,88.81 125.92,86.31 134.39,77.84 134.39,76.12 134.9,75.61 134.9,69.61 134.77,69.49 134.51,69.49 134.38,69.36 134.38,69.11 134.51,68.98 134.77,68.98 134.9,68.85 134.9,68.6 134.77,68.47 134.2,68.47 134.08,68.34 134.08,68.09 134.2,67.96 134.77,67.96 134.9,67.84 134.9,67.62 134.9,67.62 134.9,67.58 134.78,67.45 134.14,67.45 134.01,67.33 134.01,66.75 134.14,66.62 135.06,66.62 135.19,66.49 135.19,63.67 v2(135.03,63.51)
  BOTTOM w0.076: UC1.AU17 120.71,106.6 120.71,105.85 120.8,105.76 120.8,105.2 120.85,105.1 120.87,105.04 120.87,104.75 120.78,104.66 120.78,104.02 121.61,103.19 121.61,102.62 121.69,102.53 v2(121.69,98.1)
  BOTTOM w0.102: JDIMM2.50 135.05,63.53 v2(135.03,63.51)
DDR_B_D48: length 92.9
  IN3 w0.084: v2(118.13,107.73) 118.13,107.58 118.71,107.01 119.43,107.01 124.22,102.22 124.22,101.32 125.16,100.39 126.08,100.39 127.34,101.65 130.33,101.65 130.4,101.58 131.57,101.58
  IN3 w0.127: 131.57,101.58 144.25,101.58 145.33,100.5 160.56,100.5 180.13,80.93 180.13,76.73 180.26,76.6 180.71,76.6 180.84,76.47 180.84,74.66 180.71,74.53 180.26,74.53 180.13,74.4 180.13,72.26 180.27,72.12 180.65,72.12 180.78,71.99 180.78,71.73 180.65,71.6 180.27,71.6 180.13,71.47 180.13,70.37 180.26,70.24 v2(181.2,70.24)
  BOTTOM w0.076: v2(118.13,107.73) 118.46,108.05 UC1.AR21
  BOTTOM w0.102: JDIMM2.191 179.75,71.69 v2(181.2,70.24)
DDR_B_D49: length 93.7
  IN3 w0.084: 131.57,99.86 131.45,99.86 131.35,99.76 123.45,99.76 122.43,100.78 122.43,103.12 121.69,103.86 119.55,103.86 118.78,104.64 118.78,104.75 119.2,105.17 119.2,105.29 118.99,105.5 118.87,105.5 118.45,105.08 118.33,105.08 117.18,106.23 v2(117.18,107.73)
  IN3 w0.127: 131.57,99.86 143.82,99.86 144.7,98.99 159.63,98.99 178.06,80.55 178.06,80.4 178.19,80.27 178.34,80.27 178.47,80.14 178.47,79.88 178.34,79.75 178.19,79.75 178.06,79.63 178.06,79.36 178.19,79.24 178.49,79.24 178.61,79.11 178.61,78.85 178.49,78.72 178.19,78.72 178.06,78.59 178.06,78.33 178.19,78.21 178.49,78.21 178.61,78.08 178.61,77.82 178.49,77.69 178.19,77.69 178.06,77.56 178.06,77.3 178.19,77.18 178.49,77.18 178.61,77.05 178.61,76.79 178.49,76.66 178.19,76.66 178.06,76.53 178.06,76.27 178.19,76.14 178.49,76.14 178.61,76.02 178.61,75.76 178.49,75.63 178.19,75.63 178.06,75.5 178.06,74.92 178.19,74.79 178.49,74.79 178.61,74.66 178.61,74.4 178.49,74.27 178.19,74.27 178.06,74.15 178.06,73.89 178.19,73.76 178.49,73.76 178.61,73.63 178.61,71.77 v2(178.62,71.76)
  BOTTOM w0.076: UC1.AR22 117.51,108.05 v2(117.18,107.73)
  BOTTOM w0.102: JDIMM2.183 177.35,71.43 177.48,71.3 177.89,71.3 178.02,71.43 178.02,71.64 178.15,71.76 v2(178.62,71.76)
DDR_B_D50: length 95.8
  IN3 w0.084: v2(118.13,110.33) 118.35,110.54 118.58,110.54 118.69,110.43 118.69,107.51 118.85,107.36 119.58,107.36 122.99,103.94 123.28,103.94 123.9,104.56 124.31,104.56 126.56,102.31 131.57,102.31
  IN3 w0.127: 131.57,102.31 144.55,102.31 145.63,101.23 160.86,101.23 180.86,81.23 180.86,80.57 180.99,80.44 181.5,80.44 181.62,80.32 181.62,68.82 181.52,68.72 v2(181.2,68.72)
  BOTTOM w0.076: UC1.AL21 118.46,110.65 v2(118.13,110.33)
  BOTTOM w0.102: v2(181.2,68.72) 181.77,68.15 181.77,66.92 181.63,66.79 180.81,66.79 180.65,66.62 JDIMM2.194
DDR_B_D51: length 96.1
  IN3 w0.084: v2(117.18,109.68) 116.46,109.68 115.95,109.17 115.95,106.98 119.41,103.52 121.54,103.52 122.08,102.98 122.08,100.64 123.39,99.33 130.24,99.33 130.43,99.14 131.57,99.14
  IN3 w0.127: 131.57,99.14 143.52,99.14 144.4,98.27 159.33,98.27 177.34,80.25 177.34,68.28 177.48,68.14 177.88,68.14 178.02,68.28 178.02,68.59 178.15,68.72 v2(178.62,68.72)
  BOTTOM w0.076: v2(117.18,109.68) 117.51,110 UC1.AM22
  BOTTOM w0.102: v2(178.62,68.72) 177.07,67.16 177.07,67.06 176.45,66.44 JDIMM2.180
DDR_B_D52: length 95.3
  IN3 w0.084: 131.57,99.5 123.46,99.5 122.25,100.71 122.25,103.05 121.61,103.69 119.48,103.69 116.79,106.38 116.79,108.95 116.87,109.03 v2(117.18,109.03)
  IN3 w0.127: 131.57,99.5 143.67,99.5 144.55,98.63 159.48,98.63 177.71,80.4 177.71,73.53 177.83,73.4 178.13,73.4 178.26,73.27 178.26,73.01 178.13,72.89 177.83,72.89 177.71,72.76 177.71,72.5 177.83,72.37 178.13,72.37 178.26,72.24 178.26,71.98 178.13,71.85 177.83,71.85 177.71,71.73 177.71,71.38 177.84,71.25 178.07,71.25 178.2,71.12 178.2,70.86 178.07,70.73 177.84,70.73 177.71,70.6 177.71,70.01 177.83,69.88 178.26,69.88 v2(178.62,70.24)
  BOTTOM w0.076: v2(117.18,109.03) 117.51,109.35 UC1.AN22
  BOTTOM w0.102: v2(178.62,70.24) 177.07,70.24 176.95,70.37 176.95,72.06 176.75,72.25 JDIMM2.181
DDR_B_D53: length 94
  IN3 w0.084: v2(118.13,108.38) 118.51,108.01 118.51,107.45 118.78,107.18 119.51,107.18 124.4,102.29 124.4,101.39 125.23,100.56 125.89,100.56 127.27,101.95 131.57,101.95
  IN3 w0.127: v2(181.2,71.76) 181.2,72.49 181.07,72.62 180.62,72.62 180.5,72.75 180.5,73.01 180.62,73.13 181.07,73.13 181.2,73.26 181.2,73.52 181.07,73.65 180.62,73.65 180.5,73.78 180.5,74.04 180.62,74.17 181.13,74.17 181.26,74.29 181.26,76.84 181.13,76.96 180.62,76.96 180.5,77.09 180.5,77.35 180.62,77.48 181.13,77.48 181.26,77.61 181.26,77.87 181.13,78 180.62,78 180.5,78.12 180.5,78.38 180.62,78.51 181.13,78.51 181.26,78.64 181.26,78.9 181.13,79.03 180.62,79.03 180.5,79.15 180.5,79.41 180.62,79.54 180.94,79.54 181.07,79.67 181.07,79.93 180.94,80.06 180.62,80.06 180.5,80.18 180.5,81.08 160.71,100.87 145.48,100.87 144.4,101.95 131.57,101.95
  BOTTOM w0.076: UC1.AP21 118.46,108.7 v2(118.13,108.38)
  BOTTOM w0.102: JDIMM2.193 180.35,72.21 180.79,71.76 v2(181.2,71.76)
DDR_B_D54: length 96.6
  IN3 w0.084: 131.57,102.67 126.45,102.67 124.39,104.73 122.45,104.73 119.53,107.64 119.53,111.3 119.41,111.43 118.23,111.43 118.11,111.3 v2(118.11,110.98)
  IN3 w0.127: v2(181.2,67.19) 181.79,67.19 181.99,67.39 181.99,80.62 161.01,101.59 145.78,101.59 144.7,102.67 131.57,102.67
  BOTTOM w0.076: v2(118.11,110.98) 118.43,111.31 UC1.AK21
  BOTTOM w0.102: v2(181.2,67.19) 180.64,67.19 180.05,66.6 JDIMM2.192
DDR_B_D55: length 96.8
  IN3 w0.084: v2(117.18,110.98) 116.91,110.98 116.79,110.86 116.79,110.25 115.78,109.24 115.78,106.91 118.92,103.76 119.34,103.35 121.47,103.35 121.91,102.91 121.91,100.56 123.31,99.16 130.17,99.16 130.55,98.78 131.57,98.78
  IN3 w0.127: 131.57,98.78 143.37,98.78 144.25,97.9 159.18,97.9 176.98,80.1 176.98,67.17 177.11,67.04 178.47,67.04 v2(178.62,67.19)
  BOTTOM w0.076: UC1.AK22 117.51,111.31 v2(117.18,110.98)
  BOTTOM w0.102: JDIMM2.182 177.05,66.46 177.79,67.19 v2(178.62,67.19)
DDR_B_D56: length 64.2
  IN1 w0.084: v2(119.09,109.03) 118.68,108.62 118.68,106.76 120.41,105.02 120.41,103.96 120.68,103.69 121.33,103.69 122.14,102.89 122.14,100.33 125.99,96.47 126.58,96.47 127.08,95.97 127.08,95.95
  IN1 w0.127: v2(138.3,69.97) 138.3,70.11 137.84,70.58 137.84,77.81 137.66,77.98 137.66,78.16 137.84,78.34 137.84,78.52 137.64,78.72 137.47,78.72 137.29,78.54 137.11,78.54 136.91,78.74 136.91,78.92 137.31,79.32 137.31,79.5 137.11,79.69 136.93,79.69 136.53,79.29 136.35,79.29 136.15,79.49 136.15,79.67 136.56,80.07 136.56,80.25 136.36,80.45 136.18,80.45 135.78,80.05 135.6,80.05 135.4,80.24 135.4,80.42 135.8,80.82 135.8,81 135.6,81.2 135.42,81.2 135.02,80.8 134.84,80.8 134.65,81 134.65,81.18 135.05,81.58 135.05,81.76 134.85,81.96 134.67,81.96 134.27,81.56 134.09,81.56 133.89,81.75 133.89,81.93 134.29,82.33 134.29,82.51 134.09,82.71 133.92,82.71 133.51,82.31 133.33,82.31 133.14,82.51 133.14,82.69 133.54,83.09 133.54,83.27 133.34,83.47 133.16,83.47 132.76,83.06 132.58,83.06 132.38,83.26 132.38,83.44 132.78,83.84 132.78,84.02 132.59,84.22 132.41,84.22 132,83.82 131.83,83.82 131.63,84.02 131.63,84.2 132.03,84.6 132.03,84.78 131.83,84.97 131.65,84.97 131.25,84.57 131.07,84.57 128.36,87.28 128.36,93.14 127.11,94.4 127.11,95.93 127.08,95.95
  BOTTOM w0.076: v2(119.09,109.03) 119.41,109.35 UC1.AN20
  BOTTOM w0.102: v2(138.3,69.97) 138.12,69.97 137.15,70.94 JDIMM2.57
DDR_B_D57: length 62.8
  IN1 w0.084: v2(119.09,107.73) 119.09,106.59 120.59,105.09 120.59,104.19 120.92,103.86 121.41,103.86 122.31,102.96 122.31,100.64 126.26,96.69 126.91,96.69 127.45,96.14 127.45,95.95
  IN1 w0.127: v2(138.3,71.49) 138.19,71.6 138.19,72.46 138.32,72.59 138.4,72.59 138.46,72.65 138.46,73 138.33,73.12 138.31,73.12 138.18,73.25 138.18,73.53 138.31,73.66 138.33,73.66 138.46,73.78 138.46,74.06 138.33,74.19 138.32,74.19 138.19,74.32 138.19,79.1 131.78,85.51 131.6,85.51 131.2,85.11 131.02,85.11 130.82,85.31 130.82,85.49 131.22,85.89 131.22,86.07 131.03,86.27 130.85,86.27 130.44,85.86 130.27,85.86 130.07,86.06 130.07,86.24 130.47,86.64 130.47,86.82 130.27,87.02 130.09,87.02 129.69,86.62 129.51,86.62 129.31,86.82 128.71,87.42 128.71,87.91 128.83,88.04 130.08,88.04 130.2,88.16 130.2,88.44 130.08,88.57 128.83,88.57 128.71,88.7 128.71,88.98 128.83,89.1 130.14,89.1 130.27,89.23 130.27,89.51 130.14,89.64 128.83,89.64 128.71,89.76 128.71,90.04 128.83,90.17 130.14,90.17 130.27,90.3 130.27,90.58 130.14,90.7 128.83,90.7 128.71,90.83 128.71,91.11 128.83,91.24 130.01,91.24 130.14,91.36 130.14,91.64 130.01,91.77 128.83,91.77 128.71,91.9 128.71,93.29 127.45,94.54 127.45,95.95
  BOTTOM w0.076: v2(119.09,107.73) 119.41,108.05 UC1.AR20
  BOTTOM w0.102: JDIMM2.59 137.75,71.86 138.12,71.49 v2(138.3,71.49)
DDR_B_D58: length 65.3
  IN1 w0.084: v2(120,110.94) 120.76,110.19 120.76,106.43 124.43,102.76 124.43,101.54 124.78,101.18 124.78,99.84 126.82,97.81 127.85,97.81 128.63,97.03 129.4,97.03 129.95,96.48
  IN1 w0.127: 129.95,96.48 130.04,96.39 130.04,95.61 132.82,92.83 132.82,88.16 141.31,79.67 141.31,79.11 141.45,78.96 142.86,78.96 143.28,78.54 143.28,74.42 143.16,74.29 141.74,74.29 141.61,74.17 141.61,73.9 141.74,73.77 143.16,73.77 143.28,73.65 143.28,73.38 143.16,73.25 141.75,73.25 141.62,73.12 141.62,72.86 141.75,72.73 142.9,72.73 143.03,72.6 143.03,72.34 142.9,72.21 141.77,72.21 141.63,72.07 141.63,69.78 141.5,69.65 140.94,69.65 140.81,69.78 v2(140.81,69.97)
  BOTTOM w0.076: v2(120,110.94) 120.36,111.31 UC1.AK18
  BOTTOM w0.102: JDIMM2.69 140.75,72.25 141.25,71.74 141.25,70.41 v2(140.81,69.97)
DDR_B_D59: length 65
  IN1 w0.084: 129.68,96.21 129.68,96.37 129.24,96.81 128.6,96.81 127.78,97.63 126.74,97.63 124.54,99.84 124.54,101.13 124.11,101.56 124.11,102.83 120.58,106.36 120.58,109.76 v2(120.01,110.33)
  IN1 w0.127: 129.68,96.21 129.68,95.47 132.48,92.67 132.48,88.01 140.79,79.7 140.79,78.75 140.91,78.62 142.59,78.62 142.71,78.49 142.71,78.21 142.59,78.09 140.91,78.09 140.79,77.96 140.79,77.68 140.91,77.55 142.59,77.55 142.71,77.42 142.71,77.15 142.59,77.02 140.91,77.02 140.79,76.89 140.79,76.61 140.91,76.48 142.59,76.48 142.71,76.36 142.71,76.08 142.59,75.95 141.19,75.95 141.07,75.82 141.07,75.35 141.19,75.22 142.4,75.22 142.52,75.1 142.52,74.78 142.4,74.65 141.35,74.65 141.22,74.52 141.22,73.92 141.09,73.79 140.81,73.79 140.69,73.66 140.69,73.38 140.81,73.26 141.09,73.26 141.22,73.13 141.22,71.91 v2(140.81,71.49)
  BOTTOM w0.076: UC1.AL18 120.34,110.65 v2(120.01,110.33)
  BOTTOM w0.102: v2(140.81,71.49) 140.15,72.15 JDIMM2.67
DDR_B_D60: length 65.6
  IN1 w0.084: 125.68,95.95 125.52,96.12 125.52,96.14 121.79,99.87 121.79,102.75 121.19,103.35 120.54,103.35 120.07,103.81 120.07,104.83 119.69,105.2 118.89,105.2 118.19,105.91 118.19,107.15 117.68,107.66 117.68,111.08 117.95,111.35 118.9,111.35 119.09,111.17 v2(119.09,110.98)
  IN1 w0.127: v2(137.32,61.99) 137.32,61.75 137.19,61.62 136.81,61.62 136.68,61.75 136.68,66.34 136.81,66.47 137.15,66.47 137.28,66.6 137.28,66.72 137.33,66.77 137.33,70.08 137.13,70.28 137.13,77.51 127.62,87.01 127.62,92.91 126.42,94.11 126.42,95.21 125.68,95.95
  BOTTOM w0.076: UC1.AK20 119.41,111.31 v2(119.09,110.98)
  BOTTOM w0.102: JDIMM2.58 137.45,64.05 137.72,63.78 137.72,62.39 v2(137.32,61.99)
DDR_B_D61: length 64.6
  IN1 w0.084: 126.17,95.95 121.96,100.16 121.96,102.82 121.26,103.52 120.61,103.52 120.24,103.88 120.24,104.95 119.58,105.61 119.46,105.61 119.23,105.38 119.05,105.38 118.88,105.54 118.88,105.72 119.12,105.96 119.12,106.07 118.51,106.68 118.51,109.55 118.63,109.68 v2(119.09,109.68)
  IN1 w0.127: 126.17,95.95 126.76,95.35 126.76,94.26 127.98,93.04 127.98,87.16 137.48,77.66 137.48,70.43 137.72,70.19 137.72,68.89 137.87,68.73 138.33,68.73 138.46,68.61 138.46,68.32 138.33,68.2 137.8,68.2 137.67,68.07 137.67,67.8 137.8,67.68 138.33,67.68 138.46,67.55 138.46,67.28 138.33,67.16 138.2,67.16 138.08,67.03 138.08,66.76 138.2,66.64 138.33,66.64 138.46,66.51 138.46,66.03 138.33,65.9 137.15,65.9 137.02,65.77 137.02,65.51 137.15,65.38 138.27,65.38 138.4,65.25 138.4,64.98 138.27,64.86 137.15,64.86 137.02,64.73 137.02,63.64 137.15,63.51 v2(137.32,63.51)
  BOTTOM w0.076: v2(119.09,109.68) 119.41,110 UC1.AM20
  BOTTOM w0.102: v2(137.32,63.51) 136.85,63.98 JDIMM2.56
DDR_B_D62: length 61.3
  IN1 w0.084: 128.97,95.95 128.97,96.25 128.76,96.47 128.46,96.47 127.63,97.29 126.6,97.29 124.11,99.78 124.11,100.97 123.73,101.35 123.73,102.72 120.04,106.41 v2(120.04,107.73)
  IN1 w0.127: 128.97,95.95 128.97,95.17 131.79,92.35 131.79,87.73 139.99,79.53 139.99,63.71 139.86,63.58 139.54,63.58 139.41,63.46 139.41,63.18 139.54,63.05 139.9,63.05 140.03,62.92 140.03,62.64 139.9,62.52 139.67,62.52 139.54,62.39 139.54,62.11 139.67,61.98 140.43,61.98 140.43,61.99 v2(140.81,61.99)
  BOTTOM w0.076: UC1.AR18 120.36,108.05 v2(120.04,107.73)
  BOTTOM w0.102: JDIMM2.70 141.05,64.07 141.25,63.87 141.25,62.43 v2(140.81,61.99)
DDR_B_D63: length 62.7
  IN1 w0.084: v2(120.04,108.38) 120.41,108.01 120.41,106.28 123.9,102.8 123.9,101.51 124.31,101.09 124.31,99.82 126.67,97.46 127.71,97.46 128.53,96.64 128.93,96.64 129.33,96.24 129.33,95.95
  IN1 w0.127: 129.33,95.95 129.33,95.32 132.13,92.51 132.13,87.87 140.34,79.66 140.34,72.87 140.46,72.75 140.72,72.75 140.85,72.62 140.85,72.36 140.72,72.23 140.55,72.23 140.39,72.07 140.39,68.87 140.6,68.66 141.19,68.66 141.32,68.53 141.32,68.27 141.21,68.16 140.55,68.16 140.43,68.05 140.43,67.62 140.56,67.49 141.08,67.49 141.23,67.34 141.23,66.28 141.1,66.16 140.46,66.16 140.33,66.03 140.33,65.75 140.46,65.62 141.17,65.62 141.23,65.57 141.23,65.22 141.1,65.09 140.46,65.09 140.33,64.96 140.33,64.68 140.46,64.56 141.1,64.56 141.23,64.43 141.23,64.12 141.1,64 140.87,64 140.74,63.87 140.74,63.57 v2(140.81,63.51)
  BOTTOM w0.076: UC1.AP18 120.36,108.7 v2(120.04,108.38)
  BOTTOM w0.102: v2(140.81,63.51) 140.45,63.87 JDIMM2.68
