# Allegro board LA9984PR10-0523.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 36
  TOP w0.102: CA38.2 19.64,27.51 v4(19.59,27.56) ; CA71.2 33.18,31.3 v4(33.38,31.5) ; CA63.1 v4(34.29,18.53)
  TOP w0.203: v2(37.05,20.83) 37.17,20.83 37.54,21.19 UA1.38 ; UA1.25 36.36,27.29 v2(36.54,27.47)
  TOP w0.508: CA38.2 v2(19,26.24) ; RA31.1 35.53,30.8 v2(34.83,30.1) 34.26,29.53 CA51.2 33.73,29.4 CA71.2 ; CA63.1 CA61.2 v2(35.78,16.32) ; CA23.1 CA62.1 32.16,27.48 31.65,26.98 v2(31.65,26.8) ; RA84.2 30.62,25.8 v2(31.27,25.15) 31.39,25.03 RA83.2 ; v2(19.14,22.99) 19.14,23.32 19.37,23.55 CA40.2 ; RA153.1 40.73,31.1 41.11,31.48 v2(41.75,31.48) ; v2(37.68,16.31) RA32.1 ; v2(30.76,20.51) CA39.2 ; v2(26.89,21.09) 26.89,21.08 27.34,20.64 CA33.2
  BOTTOM w0.381: CA2.2 27.26,28.75 27.02,28.52 QA5.1 ; QA5.4 v2(23.65,27.22) ; v2(14.7,22.71) QA6.1 ; QA6.4 18.08,24.01 18.32,24.25 18.32,24.5 18.11,24.7 v2(17.94,24.7)
  BOTTOM w0.508: 29.3,28.37 29.3,27.31 28.79,26.8 CA1.2 ; 29.3,28.37 28.92,28.75 CA2.2 ; 29.3,28.37 30.14,28.37 30.83,27.69 v2(30.83,26.74) ; RA30.1 27.46,15.69 v2(27.46,16) ; RA29.1 v2(17.36,12.39)
V5A_CPU: length 7.2
  BOTTOM w0.102: v1(88.29,132.64) 88.37,132.64 88.5,132.51 88.94,132.51 89.44,133.01 89.44,133.06 90.05,133.67 PC505.1
  BOTTOM w0.203: PU501.28 89.42,136.93 89.58,136.77 89.58,135.7 89.37,135.5 89.07,135.5 PR519.2
  BOTTOM w0.254: PR519.2 90.14,134.1 PC505.1
V18: length 3
  TOP w0.102: v1(173.38,24.91) CR4.2 UR1.24
VBAT_CPU: length 2.4
  BOTTOM w0.203: PR508.2 91.66,142.57 91.25,142.17 90.96,142.17 90.62,141.82 PU501.16
VCC:
  vias: v1(165.07,169.38)
VCCSENSE: length 17.5
  TOP w0.102: v2(93,138.23) 92.8,138.03 92.8,136.15 R1.2 92.46,135.8 92.46,134.69 92.74,134.41 92.74,131.5 v1(92.36,131.12) 91.21,129.97 91.21,127.31 90.48,126.57 v2(90.48,125.27)
  BOTTOM w0.102: v2(90.48,125.27) 90.65,125.09 91.49,125.09 UC1.E63 ; PU501.24 91.67,138.03 91.84,137.85 92.62,137.85 v2(93,138.23)
VCCSENSE_VGA: length 80.5
  TOP w0.102: v2(202.45,54.94) 202.45,54.96 v4(202.06,55.35)
  TOP w0.254: v2(171.98,117.16) 172.49,117.67 RV202.2
  IN3 w0.102: v2(171.98,117.16) 172.23,116.91 174.88,116.91 176.09,115.71 176.09,115.37 177.83,113.62 177.83,109.27 178.49,108.62 178.49,106.2 178.76,105.93
  IN3 w0.127: v2(202.45,54.94) 202.12,54.94 201.43,55.64 199.52,55.64 197.77,57.38 197.77,59.55 187.67,69.65 187.67,80.35 183.68,84.34 183.68,93.96 181.7,95.94 181.7,98.35 181.13,98.92 181.13,101.97 178.92,104.18 178.92,105.77 178.76,105.93
  BOTTOM w0.254: PR846.2 v2(202.45,54.94) ; UV1.AF28 172.44,116.7 v2(171.98,117.16)
VCCST_PG_EC: length 234.3
  TOP w0.089: v2(92.42,129.15) v1(92.42,128.19) 90.87,126.64 90.87,123.71 91.47,123.12 91.47,121.59 90.57,120.69 87.75,120.69 87.47,120.97 86.76,120.97
  TOP w0.102: v2(77.63,117.84) 79.25,119.47 82.91,119.47 84.41,120.97 86.76,120.97 ; UE1.123 180.44,41.32 180.04,41.72 178.39,41.72 178.18,41.94 175.61,41.94 CE35.1 174.4,40.76 DE1.2 172.51,41.69 170.16,44.04 170.16,53.37 v2(170.07,53.46)
  IN3 w0.127: v2(77.63,117.84) 76.91,118.56 69.42,118.56 62.51,111.65 62.51,110.18 61.94,109.6 61.94,105.03 62.94,104.04 62.94,101.41 64.35,100 64.35,99.06 63.37,98.09 63.37,94.47 62.52,93.62 62.52,80.87 68.56,74.83 68.56,57.88 72.97,53.47 105.25,53.47 106.29,54.51 138.96,54.51 139.41,54.07 169.46,54.07 v2(170.07,53.46)
  BOTTOM w0.076: UC1.B59 94.38,127.1 94.05,127.43 94.05,127.95 93.23,128.77
  BOTTOM w0.089: C79.1 92.04,129.53 v2(92.42,129.15) 92.8,128.77 93.23,128.77
  BOTTOM w0.102: C79.1 R286.2
VDD_1.35V: length 8.3
  BOTTOM w0.102: v1(158.47,21.31) 158.59,21.43 PR205.1
  BOTTOM w0.203: PU200.11 159.31,24.88 159.48,24.7 159.74,24.7 160.88,23.56 PC209.1
  BOTTOM w0.254: PR206.2 162.09,22.23 PC209.1 160.18,22.73 159.04,22.73 PR205.1
VDDCI_SEN: length 104.5
  TOP w0.102: v2(177.19,110.61) 178.19,109.6 RV215.2 ; v2(178.15,181.49) v4(177.42,181.49)
  IN1 w0.102: v2(171.83,115.9) 170.79,116.94 170.79,118.09 170.07,118.81 170.07,122.05 169.76,122.35 168.05,122.35 166.78,123.62 164.34,123.62
  IN1 w0.127: 164.34,123.62 162.37,123.62 158.69,127.31 156.3,127.31 155.98,127.62 155.98,128.89 157.42,130.33 157.42,134.98 160.79,138.35 160.79,155.14 159.35,156.58 v2(159.3,156.58)
  IN3 w0.102: v2(171.83,115.9) 174.31,115.9 174.72,115.49 175.68,115.49 176.81,114.35 176.81,111.43 177.19,111.05 v2(177.19,110.61)
  IN3 w0.254: v2(159.3,156.58) 159.49,156.58 165.1,162.19 169.38,162.19 171.48,164.29 171.48,174.25 178.15,180.91 v2(178.15,181.49)
  BOTTOM w0.102: v2(171.83,115.9) 172.04,115.7 UV1.AG28
  BOTTOM w0.254: v2(178.15,181.49) 178.27,181.36 178.27,181.27 178.95,180.6 PR1210.2
VIN: length 48.6
  TOP w0.508: v2(137.57,162.49) v4(142.59,162.49) 163.49,162.49 164.49,163.49 PR705.1 170.46,165.09 172.25,166.88 PR723.2
  IN1 w0.508: v2(139.28,171.5) 139.28,164.2 v2(137.57,162.49)
  vias: v2(139.28,172.14) v4(133.73,176.85) v4(133.91,173.5)
VSSSENSE: length 18.8
  TOP w0.089: RC163.1 89.58,125.58 v2(89.89,125.27)
  TOP w0.102: v2(92.42,138.26) 92.42,136.62 R2.1 92.1,135.83 92.1,134.55 92.38,134.27 v1(92.38,134.05) 92.38,131.65 90.83,130.1 90.83,127.56 89.58,126.3 RC163.1
  BOTTOM w0.102: v2(89.89,125.27) 90.27,124.88 90.61,124.88 90.62,124.9 91.19,124.9 91.56,124.53 91.81,124.53 92.17,124.89 UC1.E62 ; PU501.23 91.77,138.43 91.94,138.26 v2(92.42,138.26)
VSSSENSE_VGA: length 78
  TOP w0.102: v4(199.99,55.48) 200.36,55.11 v2(200.63,55.11)
  TOP w0.508: v2(172.98,115.21) 172.82,115.05 RV204.1
  IN3 w0.102: v2(172.98,115.21) 173.47,115.7 174.22,115.7 174.64,115.29 175.5,115.29 176.56,114.23 176.56,111.28 176.66,111.17 176.66,110.15 178.28,108.53 178.28,105.96 178.49,105.75
  IN3 w0.127: v2(200.63,55.11) 199.68,55.11 197.51,57.28 197.51,59.45 187.41,69.55 187.41,80.24 183.42,84.23 183.42,93.85 181.44,95.83 181.44,98.24 180.87,98.81 180.87,101.86 178.66,104.07 178.66,105.59 178.49,105.75
  BOTTOM w0.254: PR845.2 v2(200.63,55.11) ; v2(172.98,115.21) 172.36,115.21 171.66,114.51 UV1.AH29
65W#/90W: length 173.1
  TOP w0.102: PQ4.2 128.82,183.86 v1(128.07,184.61) ; v2(188.51,48.09) 185.99,48.09 183.23,45.32 183.23,44.12 182.82,43.72 UE1.117
  TOP w0.254: PQ4.2 v2(128.82,182.25)
  IN2 w0.254: v2(128.82,182.25) 128.82,170.66 131.94,167.54 131.94,148.33 139.09,141.18 139.09,139.98 149.48,129.59 149.48,122.14 150.41,121.21 150.41,120.78 149.84,120.2 149.84,119.46 152.4,116.9 152.4,114.03 153.58,112.85 153.58,111.02 153.99,110.61 153.99,110.19 158.77,105.41 159.72,105.41 161.31,103.81 161.87,103.81 162.67,103 162.67,102.15 182.6,82.22 183.05,82.22 187.6,77.67 187.6,68.31 188.75,67.16 188.75,51.55 188.23,51.03 188.23,48.37 v2(188.51,48.09)
62881_COMP: length 7.1
  BOTTOM w0.102: v1(207.7,53.79) 206.32,53.79 206.14,53.96 PC806.2
  BOTTOM w0.203: PU800.5 204.99,55.87 PC818.2
  BOTTOM w0.254: PC814.2 PC806.2 205.12,53.99 PR817.2 PC818.2
62881_FB: length 7.8
  BOTTOM w0.102: v1(206.02,52.42) 204.89,52.42 PC814.1
  BOTTOM w0.203: PU800.6 204.59,56.91 204.52,56.84 204.52,56.82 204.24,56.54 PR821.1 203.67,55.18 203.67,55.17
  BOTTOM w0.254: PC814.1 PR818.1 PR813.1 203.67,54.27 203.67,55.17
62881_RBIAS: length 3.3
  TOP w0.102: v1(207.04,55.06) 206.72,55.37 PR815.1
  TOP w0.254: PR815.1 206.1,56.36 v2(206.06,56.4)
  BOTTOM w0.203: PU800.3 205.79,56.68 v2(206.06,56.4)
62881_VCCP: length 5.2
  BOTTOM w0.102: v1(208.47,64.25) 207.96,63.74 PC803.1
  BOTTOM w0.203: PU800.19 205.79,62.04 205.85,62.09 205.85,62.1 205.87,62.12 205.87,63.72 PR814.1
  BOTTOM w0.254: PC803.1 PR814.1
62881_VDD: length 5.7
  TOP w0.102: PC811.1 204.7,60.78 v1(204.88,60.78)
  TOP w0.254: PC811.1 203.27,59.35 v2(202.53,59.35)
  BOTTOM w0.203: PU800.11 202.59,59.42 202.53,59.36 202.53,59.36 v2(202.53,59.35)
  BOTTOM w0.254: PR822.1 201.51,60.37 202.03,59.85 202.03,59.75 202.1,59.68 202.1,59.67 202.42,59.35 v2(202.53,59.35)
62881_VID0: length 6.8
  BOTTOM w0.102: PR811.2 208.99,63.91 209.66,64.57 210.19,64.57 v1(210.46,64.3)
  BOTTOM w0.203: PU800.20 206.19,61.97 206.2,61.99 206.2,62.71 206.61,63.12
  BOTTOM w0.254: 206.61,63.12 207.94,63.12 208.18,63.36 PR811.2
62881_VID1: length 3.4
  BOTTOM w0.203: 206.96,62.59 206.59,62.21 PU800.21
  BOTTOM w0.254: 206.96,62.59 v1(207.67,62.59) 208.88,62.59 PR810.2
62881_VID2: length 2.2
  BOTTOM w0.203: PU800.22 208.05,60.62 208.37,60.94 208.37,61.14 208.82,61.58 PR812.2
62881_VID3: length 1.9
  BOTTOM w0.203: PR807.2 208.65,60.69 208.18,60.22 PU800.23
62881_VID4: length 1.7
  BOTTOM w0.203: PR809.2 208.98,59.82 PU800.24
62881_VID5: length 1.9
  BOTTOM w0.203: PU800.25 208.49,59.42 PR806.2
62881_VID6: length 3.2
  TOP w0.102: v1(208.42,60.23) 207.62,59.43 PR804.2
  TOP w0.254: v2(208.28,58.89) 208.07,59.11 PR804.2
  BOTTOM w0.203: PU800.26 208.18,59.02 208.28,58.92 v2(208.28,58.89)
62881_VIN: length 4.5
  TOP w0.102: v1(203.05,60.81) 203.05,60.47 v2(202.52,59.93)
  TOP w0.254: PR823.1 PC810.1 201.82,59.49 202.26,59.93 v2(202.52,59.93)
  BOTTOM w0.203: PU800.12 202.64,59.82 202.52,59.95 v2(202.52,59.93)
62881_VR_ON: length 4.1
  TOP w0.102: PC869.1 207.62,57.52 v1(208.25,56.9)
  TOP w0.254: v2(208.24,58.31) 208.15,58.22 PC869.1
  BOTTOM w0.203: PU800.27 207.9,58.62 208.22,58.31 v2(208.24,58.31)
  BOTTOM w0.254: v2(208.24,58.31) 208.52,58.03 PR803.2
62881_VW: length 4.1
  BOTTOM w0.102: PR817.1 206.59,54.85 v1(207.03,55.29)
  BOTTOM w0.203: PU800.4 205.39,56.57 205.45,56.5
  BOTTOM w0.254: PR817.1 PC818.1 205.45,56.33 205.45,56.5
+BIF_VDDC: length 37.6
  TOP w0.508: RV245.2 153.22,116.24 152.47,116.99 152.47,125.63 153.51,126.67 154.65,126.67 154.78,126.8 v1(160.29,126.8) 165,126.8 165.32,127.11 165.32,127.83 165.26,127.89 RV234.1 166.25,128.51 CV97.1 RV103.2 168.3,127.94 168.88,127.37 172.75,127.37 v2(172.88,127.25) ; v2(173.9,126.17) 174.25,126.53 CV195.1 CV196.1 174.42,125.64 v2(173.94,125.16)
  BOTTOM w0.381: UV1.T27 173.48,124.7 v2(173.94,125.16) ; v2(173.9,126.17) 173.46,126.61 UV1.N27 172.92,127.24 172.88,127.24 v2(172.88,127.25)
+CHGRTC: length 1.7
  BOTTOM w0.102: DC1.3 112.18,15.3 v1(112.93,16.04)
+CODEC_AVDD2: length 7.5
  TOP w0.102: CA61.1 37.18,16.41 v1(36.54,15.78)
  TOP w0.203: RA9.2 36.85,19.7 37,19.85 37.71,19.85 38.19,20.34 38.19,20.92 38.34,21.06 UA1.40
  TOP w0.508: CA61.1 37.18,17.57 36.85,17.9 RA8.2 RA9.2
+CPU_CORE: length 52.2
  BOTTOM w0.089: UC1.G57 95.33,124.3 95.33,124.42 ; 117.3,123.09 117.3,123.26 UC1.H23 117.3,123.53 117.3,123.72 ; 107.84,124.42 107.84,124.32 UC1.G37 107.9,123.98 107.9,123.85 ; 102.88,123.85 102.88,123.98 UC1.G45 102.88,124.26 102.88,124.42 ; 99.58,124.42 99.58,124.31 UC1.G51 99.52,123.99 99.52,123.85 ; 112.09,123.85 112.09,123.96 UC1.G31 112.16,124.35 ; 115.39,123.85 115.39,123.95 UC1.G25 115.39,124.29 115.39,124.48 ; 107.14,124.34 UC1.G39 107.08,123.96 107.08,123.85 ; 97.87,123.85 97.87,123.98 UC1.G53 97.8,124.33 97.8,124.42 ; 104.54,123.85 104.54,123.99 UC1.G43 104.6,124.31 104.6,124.42 ; 110.38,123.85 110.38,123.95 UC1.G33 110.38,124.29 110.38,124.42 ; 116.73,121.63 116.87,121.77 UC1.K23 ; 114.57,123.85 114.57,123.99 UC1.G27 114.63,124.32 114.63,124.48 ; UC1.J23 117.16,122.59 116.92,122.83 ; UC1.J23 117.3,122.72 117.3,122.9 ; UC1.J23 117.03,122.45 116.79,122.45 ; 97.04,124.42 97.04,124.28 UC1.G55 97.04,123.96 97.04,123.85 ; 100.34,124.48 100.34,124.29 UC1.G49 100.34,123.95 100.34,123.85 ; UC1.M23 116.82,120.96 116.79,120.99 ; UC1.M23 117.26,120.96 UC1.L22 117.26,121.77 UC1.K23 ; UC1.M23 117.16,121.3 ; 109.62,124.42 109.62,124.31 UC1.G35 109.55,123.99 109.55,123.85 ; 105.36,124.42 105.36,124.29 UC1.G41 105.36,123.95 105.36,123.85 ; 112.92,123.85 112.92,123.98 UC1.G29 112.85,124.32 112.85,124.42 ; 117.16,121.44 UC1.K23
  BOTTOM w0.203: 103.42,124.15 UC1.F44 ; UC1.F44 104.01,124.15 ; UC1.F44 103.42,124.74 ; UC1.F44 104.01,124.74 ; 115.96,124.15 UC1.F24 ; UC1.F24 116.55,124.74 ; UC1.F24 116.55,124.15 ; UC1.F24 115.96,124.74 ; UC1.G23 117.24,123.83 ; UC1.G23 116.65,123.83 ; UC1.G23 116.65,124.41 ; 95.9,124.15 UC1.F56 ; UC1.F56 96.49,124.74 ; UC1.F56 96.49,124.15 ; UC1.F56 95.9,124.74 ; 109.13,124.41 UC1.G35 109.13,123.83 ; UC1.F52 99,124.74 ; UC1.F52 98.41,124.15 ; UC1.F52 99,124.15 ; UC1.F52 98.41,124.74 ; 105.83,124.41 UC1.G41 105.83,123.83 ; UC1.F28 114.04,124.74 ; UC1.F28 113.45,124.15 ; UC1.F28 113.45,124.74 ; UC1.F28 114.04,124.15 ; 116.87,123.1 UC1.H23 116.87,123.69 ; 111.64,124.41 UC1.G31 111.64,123.83 ; 105.93,124.15 UC1.F40 ; UC1.F40 106.52,124.74 ; UC1.F40 106.52,124.15 ; UC1.F40 105.93,124.74 ; 104.11,123.83 UC1.G43 104.11,124.41 ; 101.61,123.83 UC1.G47 101.61,124.41 ; 108.34,124.41 UC1.G37 108.34,123.83 ; 100.81,123.83 UC1.G49 100.81,124.41 ; 106.62,124.41 UC1.G39 106.62,123.83 ; 98.31,123.83 UC1.G53 98.31,124.41 ; UC1.F48 101.5,124.74 ; UC1.F48 101.5,124.15 ; UC1.F48 100.92,124.15 ; UC1.F48 100.92,124.74 ; 114.14,124.41 UC1.G27 114.14,123.83 ; 110.84,123.83 UC1.G33 110.84,124.41 ; 113.35,124.41 UC1.G29 113.35,123.83 ; 96.59,123.83 UC1.G55 96.59,124.41 ; 115.86,123.83 UC1.G25 115.86,124.41 ; 99.1,123.83 UC1.G51 99.1,124.41 ; 110.95,124.74 UC1.F32 ; UC1.F32 111.53,124.15 ; UC1.F32 110.95,124.15 ; UC1.F32 111.53,124.74 ; UC1.F36 109.03,124.74 ; UC1.F36 108.44,124.74 ; UC1.F36 108.44,124.15 ; UC1.F36 109.03,124.15 ; 95.8,123.83 UC1.G57 95.8,124.41 ; 103.32,124.41 UC1.G45 103.32,123.83
  BOTTOM w0.254: UC1.AD57 95.85,114.29 96.1,114.04 96.1,113.75 v2(96.1,113.75) ; UC1.U57 v2(95.77,118.19) ; UC1.AB57 v2(95.77,115.59) ; UC1.P57 v2(95.77,119.49) ; UC1.W57 v2(95.77,116.89) ; UC1.F59 94.25,124.21 v2(93.95,124.51) ; UC1.M57 v2(95.77,120.79) ; UC1.K57 v2(95.85,122.09)
  vias: v2(94.39,138.36) v2(94.45,136.96) v2(95.28,141.15) v2(95.34,139.88) v2(95.47,143.69) v2(95.53,142.42) v2(95.72,136.96) v2(95.79,138.42) v2(95.81,123.51) v2(96.33,125.05) v2(96.36,139.31) v2(96.87,138.42) v2(96.87,123.5) v2(97.12,144.58) v2(97.69,139.5) v2(97.88,138.42) v2(98.01,123.51) v2(98.14,135.88) v2(98.84,125.05) v2(98.96,139.5) v2(99.41,144.58) v2(99.39,123.51) v2(100.17,140.64) v2(100.17,138.42) v2(100.23,134.86) v2(100.52,123.51) v2(101.18,140.64) v2(101.18,138.42) v2(101.25,134.86) v2(101.34,125.05) v2(101.57,135.82) v2(101.9,123.51) v2(103.03,123.51) v2(103.53,140.64) v2(103.53,138.42) v2(103.6,134.86) v2(103.85,125.05) v2(104.41,123.51) v2(104.49,140.64) v2(104.49,138.42) v2(104.87,136.2) v2(105.53,123.51) v2(106.36,125.05) v2(106.84,138.42) v2(106.9,134.86) v2(106.91,123.51) v2(107.85,138.42) v2(107.92,134.86) v2(108.04,123.51) v2(108.3,136.2) v2(108.87,125.05) v2(109.42,123.51) v2(110.2,140.58) v2(110.2,138.42) v2(110.33,134.86) v2(110.55,123.51) v2(111.22,140.58) v2(111.22,138.42) v2(111.34,134.86) v2(111.37,125.05) v2(111.6,136.26) v2(111.93,123.51) v2(113.06,123.51) v2(113.88,125.05) v2(114.44,123.51) v2(115.56,123.51) v4(101.83,119.42)
+DIMM1_VREF_DQ:
  vias: v1(41.15,75.3) v2(40.67,75.53) v2(40.67,74.93)
+DIMM2_VREF_DQ:
  vias: v1(118.91,74.07) v2(119.13,75.02) v2(119.56,74.59)
+DPAB_VDD10: length 14.2
  TOP w0.508: RV120.1 157.45,108 CV116.1 158.6,107.92 CV115.1 CV114.1 v1(165.8,107.92) 167.53,107.92 168.49,108.88
  BOTTOM w0.254: UV1.AP31 169.87,109.71 169.45,109.71 UV1.AP32 168.87,109.51 v2(168.87,109.46) ; UV1.AN33 168.46,110.69 v2(168.87,110.28) 168.49,109.9 UV1.AP33
+DPAB_VDD18: length 17.3
  TOP w0.508: RV118.1 161.05,106.43 161.13,106.34 CV110.1 162.4,105.65 170.17,105.65 170.69,106.16 171.87,106.16 172.18,106.47 v2(172.18,106.98)
  BOTTOM w0.254: UV1.AU28 172.26,108.3 UV1.AV29 171.86,107.29 v2(172.18,106.98) ; UV1.AP25 174.86,109.75 v2(175.16,109.46) 175.6,109.9 UV1.AP24 ; v2(173.64,109.46) 174.06,109.88 UV1.AP26 ; UV1.AN24 175.13,110.7 v2(174.91,110.47)
  vias: v1(174.25,109.93)
+DPCD_VDD10:
  vias: v1(186.02,105.25)
+DPCD_VDD18:
  vias: v1(180.97,105.77)
+DPEF_VDD10: length 19.1
  TOP w0.508: RV126.2 158.19,103.25 158.21,103.23 CV123.1 CV125.1 CV124.1 161.26,103.23 161.42,103.39 v1(162.31,103.39) 163.27,103.39 v2(164.83,104.95)
  IN1 w0.508: v2(168.86,111.89) 168,111.03 168,108.77 164.83,105.6 v2(164.83,104.95)
  BOTTOM w0.254: UV1.AK34 UV1.AK33 ; UV1.AL33 168.48,112.3 v2(168.87,112.69)
  BOTTOM w0.305: v2(168.87,112.69) 168.47,113.1 UV1.AK33 ; v2(168.86,111.89) 168.47,111.5 UV1.AM33
+DPEF_VDD18: length 18.8
  TOP w0.102: v2(162.86,107.17) v1(163.67,107.17)
  TOP w0.508: RV124.2 156.58,106.41 CV120.1 158.26,106.41 158.3,106.44 CV122.1 CV121.1 159.61,106.92 159.86,107.17 v2(162.86,107.17)
  IN1 w0.508: v2(165.06,112.5) 165.06,110.83 164.14,109.9 164.14,108.44 v2(162.86,107.17)
  IN3 w0.508: v2(165.06,112.5) 165.95,112.5 167.16,113.71 v2(167.16,114.35)
  BOTTOM w0.254: UV1.AM37 165.66,112.1 UV1.AL38 v2(165.06,112.5)
+DPLL_PVDD: length 15.3
  TOP w0.102: v2(164.75,109.65) 164.55,109.65 v1(164.15,109.25)
  TOP w0.508: RV246.2 CV84.1 CV83.1 169.8,110.98 v2(169.67,111.1)
  IN3 w0.508: v2(164.75,109.65) 164.75,109.84 165.29,110.38 167.57,110.38 168.28,111.1 v2(169.67,111.1)
  BOTTOM w0.254: UV1.AM32 169.28,111.5 v2(169.67,111.1)
  BOTTOM w0.508: v2(164.75,109.65) 164.75,109.27 163.48,108 162.78,108 162.14,107.36 CV82.1 160.86,108.2 LV14.1
+DPLL_VDDC: length 14.5
  TOP w0.508: v2(170.46,110.28) 170.57,110.17 CV88.1 CV87.1 170.57,107.13 169.72,106.28 v1(169.36,106.28) 163.61,106.28 v2(163.41,106.48)
  BOTTOM w0.254: v2(170.46,110.28) 170.06,110.68 UV1.AN31
  BOTTOM w0.508: v2(163.41,106.48) 163.28,106.34 CV86.1 161.05,106.34 LV15.1
+EC_VCCA: length 39.2
  TOP w0.203: v2(195.42,52.12) 195.17,52.12 194.79,52.5 UE1.67
  TOP w0.508: v2(197.39,36.5) 197.86,36.03 v4(199.44,36.03) 200.14,36.03 CE7.1 200.61,36.87 201.12,37.38 LE1.2
  IN2 w0.508: v2(195.42,52.12) 195.42,50.57 197.39,48.6 v2(197.39,36.5)
  IN3 w0.508: v2(195.42,52.12) 195.42,51.12 193.93,49.63 190.04,49.63 189.6,50.06 188.34,50.06 187.1,48.82 v2(183.42,48.82)
  BOTTOM w0.508: PR24.2 182.22,47.94 183.1,48.82 v2(183.42,48.82)
+FAN_POWER: length 1
  TOP w0.102: v4(49.42,108.26) 48.78,108.89 v2(48.78,108.97)
+INV_PWR_SRC:
  vias: v1(232.74,176.19) v2(231.79,177.28) v2(231.79,176.7) v2(232.44,177.28) v2(232.44,176.7)
+LAN_IO: length 75.8
  TOP w0.203: UG1.8 65.69,45.46
  TOP w0.508: v2(66.73,46.22) CG3.1 65.69,45.46
  IN2 w0.508: v2(34.57,84.95) 34.57,91.05 v2(37.05,93.52)
  IN3 w0.508: v2(66.73,46.22) 62.87,46.22 61.73,47.36 54.88,47.36 44.21,58.03 44.21,68.07 44.92,68.79 44.92,86.17 v2(43.78,87.32)
  BOTTOM w0.203: 34.19,83.95 34.65,84.41 34.68,84.41 35.08,84.81 35.08,85.24 35.27,85.43 36.12,85.43 36.35,85.66 UL1.32
  BOTTOM w0.457: v2(34.57,84.95) 34.19,84.57 CL15.1
  BOTTOM w0.508: v2(40.66,83.73) 40.73,83.8 40.73,83.87 41.19,84.33 RL38.2 ; RL37.2 v2(37.05,93.52)
  vias: v1(42.7,85.61) v2(43.24,86.79)
+LAN_VDD: length 7.4
  IN2 w0.762: 35.72,89.65 35.72,85.52 35.78,85.46
  BOTTOM w0.203: CL20.1 36.17,83.95 36.55,84.33 36.55,84.71 37.15,85.3 UL1.30
  BOTTOM w0.508: CL20.1 v2(35.97,84.57)
  vias: v1(34.55,90.31) v2(35.53,90.29) v2(36.03,90.73)
+LCDVDD: length 3.4
  TOP w0.254: v2(220.26,172.66) 220.26,172.18 220.44,172 221.63,172 v4(222.67,173.04)
  vias: v2(219.29,172.21) v2(219.29,171.52) v2(219.68,172.66)
+LCDVDD_CONN:
  vias: v1(223.74,173.28)
+MIC2-VREFO: length 14.1
  TOP w0.102: v1(25.94,24.58) RA1109.2
  TOP w0.203: v2(34.83,25.77) 35.08,25.77 35.29,25.56 35.73,25.56 35.87,25.42 UA1.29
  TOP w0.508: RA1109.2 RA53.2 v2(25.87,25.47)
  IN1 w0.508: v2(25.87,25.47) 26.57,25.47 27.21,26.1 34.5,26.1 v2(34.83,25.77)
+MPV18: length 28.7
  TOP w0.102: v2(189.26,130.7) 189.32,130.7 v1(189.74,130.28)
  TOP w0.508: v2(201.78,146.48) 202.75,147.45 CV199.1 CV198.1 202.39,148.96 CV197.1 202.22,149.78 LV21.2
  IN3 w0.508: v2(201.78,146.48) 200.75,146.48 190.38,136.11 190.38,133.06 190.02,132.7 190.02,131.43 189.87,131.28 189.84,131.28 189.84,131.26 189.5,130.92 189.5,130.92 189.5,130.91 189.28,130.7 v2(189.26,130.7)
  BOTTOM w0.254: UV1.H7 189.66,131.09 v2(189.26,130.7) 188.86,131.1 UV1.H8
+PCH_VCCDSW: length 14.2
  TOP w0.241: v2(119.34,112.41) 118.95,112.02 118.95,111.52 118.61,111.18 118.61,107.27 118.08,106.74 v1(118.08,105.67) 118.08,104.15
  TOP w0.508: 118.08,104.15 118.59,103.65 118.59,100.46 R265.1
  BOTTOM w0.254: UC1.AG20 118.97,112.78 v2(119.34,112.41) 119.72,112.78 UC1.AG19
+PCH_VCCDSW_R: length 2
  TOP w0.254: R265.2 C64.1 118.84,97.92 v1(119.28,97.92)
+PCIE_PVDD: length 9.9
  BOTTOM w0.254: 164.25,119.64 164.45,119.64 164.94,120.12 165.46,120.12 165.89,119.7 UV1.AB37
  BOTTOM w0.508: 164.25,119.64 v1(163.28,118.67) 162.56,117.95 CV133.1 CV132.1 161.17,117.91 161.17,117.17 160.63,116.63 CV134.1 159.16,116.63 159.03,116.76 LV18.2
+PCIE_VDDR: length 1.6
  TOP w0.102: v1(157.48,116.89) 156.83,116.24 CV129.1
  vias: v2(156.16,115.63) v2(156.58,115.22) v2(168.97,119.63) v2(169.61,119.65) v2(170.46,121.9)
+RTCBATT: length 63.9
  TOP w0.508: v2(76.51,45.6) v4(73.4,48.71) 72.6,49.51 RG1.1
  IN2 w0.508: v2(76.51,45.6) 78.03,45.6 82.13,41.49 83.02,41.49 84.17,40.34 84.17,39.4 105.29,18.29 v2(110.9,18.29)
  BOTTOM w0.508: RC10.2 111.61,17.58 v2(110.9,18.29) JRTC.1
+RTCVCC: length 244.1
  TOP w0.508: RG2.1 v2(60.44,49.43) ; v2(138.46,95.11) 137.34,95.11 136.72,94.49 v1(135.56,94.49) 131.09,94.49 130.34,95.24 RC5.1 RC6.1
  IN1 w0.381: v2(124.23,112.38) 124.23,110.54 124.48,110.3 124.48,105.72 124.8,105.4 124.82,105.4 126.33,103.88 129.2,103.88 129.51,104.19 131.85,104.19 132.73,103.32 133.77,103.32 136.81,100.28 v2(136.96,100.28)
  IN1 w0.508: v2(18.61,28.26) 18.61,28.56 20.53,30.48 24.19,30.48 28.57,34.86 38.1,34.86 53.18,49.94 v2(54.69,49.94)
  IN2 w0.508: v2(54.69,49.94) 59.93,49.94 v2(60.44,49.43) 60.44,48.58 62.53,46.5 64.6,46.5 65.6,45.49 68.74,45.49 69.74,46.5 80.85,46.5 93.06,34.29 101.31,34.29 ; 101.31,34.29 112.93,45.91 112.93,71.19 115.79,74.04 115.79,77.92 133.19,95.32 138.25,95.32 v2(138.46,95.11) ; 101.31,34.29 101.31,24.01 106.18,19.14 111.1,19.14 111.57,18.67 111.57,14.37 v2(110.66,13.45)
  BOTTOM w0.254: UC1.AG10 124.63,112.78 v2(124.23,112.38)
  BOTTOM w0.508: RA5.1 17.85,27.5 v2(18.61,28.26) ; v2(110.66,13.45) 111.33,12.78 DC1.1
+SM_VREF_CA: length 15.3
  IN2 w0.508: v2(97.97,98.86) 98.52,98.86 101.77,102.11 101.77,103.8 100.99,104.57 100.99,106.81 100.08,107.72 v2(100.08,108.4)
  BOTTOM w0.254: UC1.AP49 100.22,108.4 v2(100.08,108.4)
  BOTTOM w0.508: v2(97.97,98.86) 97.05,97.94 CC8.1 97.07,97.53 RC17.2
+SM_VREF_CA_DIMM: length 147.6
  TOP w0.508: v2(112.17,54.03) 94.26,54.03 91.98,56.31 v1(91.98,57.41) 91.98,64.38 90.9,65.46 RD4.2 ; RD10.2 v2(162.98,63.73)
  IN1 w0.508: v2(162.78,53.62) 162.78,63.53 v2(162.98,63.73)
  IN3 w0.508: v2(112.17,54.03) 138.81,54.03 139.22,53.62 v2(162.78,53.62)
  BOTTOM w0.254: RC17.1 97.07,95.67
  BOTTOM w0.508: v2(112.17,54.03) 112.17,74.79 98.77,88.19 98.77,93.59 98.36,94 RC14.2 97.44,94 97.05,94.38 RC20.1 97.07,94.89 97.07,95.67
+SM_VREF_DQ0: length 13.4
  IN2 w0.508: v2(99.13,107.73) 99.13,104.55 99.78,103.9 99.78,103.41 99.22,102.85 99.22,101.54 v2(96.19,98.52)
  BOTTOM w0.254: UC1.AR51 99.19,107.73 v2(99.13,107.73)
  BOTTOM w0.508: RC19.2 96.18,97.53 CC10.1 v2(96.19,98.52)
+SM_VREF_DQ0_DIMM1: length 65.3
  TOP w0.508: v2(46.63,77.85) v1(45.42,76.65) RD1.1
  IN2 w0.508: v2(95.41,92.44) 93.44,94.41 61.81,94.41 46.63,79.23 v2(46.63,77.85)
  BOTTOM w0.508: RC19.1 96.18,94.89 RC22.1 96.36,94.71 96.36,92.73 RC16.2 95.42,92.45 v2(95.41,92.44)
+SM_VREF_DQ1: length 14.3
  IN2 w0.508: v2(99.13,108.38) 98.93,108.38 98.31,107.75 98.31,104.28 98.31,104.28 98.31,102.77 94.41,98.87 v2(94.41,98.35)
  BOTTOM w0.254: v2(99.13,108.38) 99.45,108.7 UC1.AP51
  BOTTOM w0.508: RC18.2 94.4,97.53 CC9.1 v2(94.41,98.35)
+SM_VREF_DQ1_DIMM2: length 60.8
  TOP w0.508: RD8.1 121.48,72.6 121.48,68.61 119.6,66.73 v1(119.6,65.56) 119.6,62.85 118.71,61.96 v2(111.53,61.96)
  BOTTOM w0.508: RC18.1 94.4,95.29 94.41,95.28 RC21.1 94.41,94.65 94.59,94.48 RC15.2 94.35,94 93.82,93.46 93.82,91.24 111.53,73.52 v2(111.53,61.96)
+SPV10: length 19.4
  TOP w0.102: v2(188.24,105.08) v1(188.97,105.08)
  IN1 w0.508: v2(188.24,105.08) 188.93,105.08 190.97,103.04 192.62,103.04 194.09,101.58 v2(194.09,100.63)
  BOTTOM w0.254: UV1.AN9 188.09,110.7 188.46,110.33 188.46,109.55 188.24,109.34 188.24,108.86 188.24,108.86 188.24,108.54 188.24,108.06 188.24,108.06 188.24,107.74 v2(188.24,105.08)
  BOTTOM w0.508: LV23.2 194.21,96.84 194.59,97.23 CV215.1 194.59,98.32 194.28,98.64 CV216.1 CV217.1 194.09,100.01 v2(194.09,100.63)
+SPV18: length 17.1
  TOP w0.102: v2(190.89,101.2) v1(190.89,101.81)
  IN3 w0.508: v2(187.66,111.06) 187.66,110.61 190.08,108.19 190.08,103.99 190.89,103.18 v2(190.89,101.2)
  BOTTOM w0.254: v2(187.66,111.06) 187.26,111.45 UV1.AM10
  BOTTOM w0.508: LV22.2 190.83,97.19 190.78,97.24 CV200.1 190.78,98.37 191.14,98.73 CV202.1 CV201.1 191.14,100.95 v2(190.89,101.2)
+SW_LX: length 6.5
  TOP w0.102: v1(201.46,163.83) 201.46,165.02 LX9.2
  TOP w0.203: 202.68,167.46 203.11,167.89 203.29,167.89 203.71,168.32 203.71,169.34 UX4.17
  TOP w0.889: 202.68,167.46 LX9.2
+SWR_V12: length 7.8
  TOP w0.102: CX47.1 v1(199.74,162.42)
  TOP w0.203: v2(202.56,168.3) 202.56,168.53 202.92,168.9 UX4.15 ; v2(200.26,169.78) 200.45,169.97 200.45,170.22 200.82,170.59 UX4.11 ; UX4.43 204.12,176.28 204.04,176.36 204.04,177.27 CX37.1
  TOP w0.508: v2(200.26,169.78) 200.11,169.62 CX32.1 ; CX37.1 203.88,177.47 203.86,177.49 v2(203.55,177.49)
  vias: v2(200.02,165.15) v2(200.69,165.15)
+TSVDD: length 17.1
  TOP w0.508: v2(159.36,109.47) v1(162.13,109.47) 163.25,109.47 164.16,110.38 165.87,110.38 166.47,110.99 166.47,112.54 168.48,114.55 v2(168.86,114.55)
  BOTTOM w0.254: UV1.AJ32 169.26,114.15 v2(168.86,114.55)
  BOTTOM w0.508: LV16.2 159.23,108.5 CV93.1 ; CV92.1 CV93.1 ; CV93.1 158.52,108.58 CV91.1 159.25,109.58 v2(159.36,109.47)
+VCHGR:
  vias: v3(143.41,184.33) v3(144.17,184.52) v3(145,184.52) v3(145,183.63) v3(145,182.74) v3(145,181.85) v3(145.7,184.9) v3(145.7,184.14) v3(145.7,183.38) v3(145.7,182.61) v3(145.7,181.85) v3(145.7,181.09) v4(144.15,183.54)
+VDISPLAY_VCC:
  vias: v1(13.16,109.69) v2(13.36,111.37) v2(13.36,110.73)
+VGA_CORE: length 132.6
  TOP w0.254: PR820.2 203.91,54.59 203.61,54.28 201.96,54.28 v2(201.39,54.85)
  TOP w0.508: v2(175.94,122.12) 175.43,122.62 PC853.1 ; v2(177.96,124.2) 177.97,124.21 PC856.1 ; PC855.1 175.43,124.58 v2(174.97,125.04) ; PC840.1 181.44,124.6 v2(180.94,125.09) ; v2(178.96,122.13) 179.28,122.45 PC859.1 ; PC857.1 179.34,125.81 v2(178.91,126.24) ; PC844.1 177.88,119.25 v2(177.96,119.34) ; PC860.1 181.44,122.61 v2(180.96,122.14) ; PC845.1 177.34,120.49 v2(176.96,120.11) ; v2(180.96,120.26) 181.5,119.72 PC841.1 ; v2(175.96,123.26) 176.36,123.66 PC864.1 ; v2(180.96,126.26) 181.44,125.79 PC858.1
  IN1 w0.254: v2(201.39,54.85) 201.39,62.09 200.18,63.3 200.18,82.16 198.91,83.43 196.56,83.43 196.05,83.94 196.05,86.16 v3(196.37,86.48)
  BOTTOM w0.254: PL802.2 210.72,83 210.98,82.74 210.98,81.66 210.47,81.16 207.88,81.16 206.15,79.43 204.28,79.43 200.82,75.97 200.82,66.22 198.4,63.81 198.4,63.25 PR830.1 ; UV1.T24 175.31,124.7 v2(174.97,125.04) 174.46,125.55 UV1.R26
  BOTTOM w0.381: v2(177.95,117.05) 177.6,116.7 UV1.AF22 ; UV1.R21 178.46,125.73 178.91,126.18 v2(178.91,126.24) ; v2(180.94,125.09) 181.34,124.7 UV1.T17 ; UV1.U16 182.29,123.7 v2(181.96,123.37) ; UV1.R18 180.96,126.2 v2(180.96,126.26) ; v2(178.96,125.07) 179.33,124.7 UV1.T20 ; UV1.AD21 178.46,117.78 178.97,118.29 ; v2(176.94,122.06) 177.46,122.58 UV1.V22 ; UV1.AD18 180.59,117.7 v2(180.94,117.35) ; UV1.AC17 181.4,118.7 v2(180.96,119.14) 180.46,119.64 UV1.AB18 ; UV1.AC22 177.32,118.7 v2(176.98,118.36) ; UV1.U26 v2(173.96,123.2) UV1.V27 ; UV1.R23 176.46,125.77 v2(176.94,126.24) ; v2(180.96,122.14) 181.46,122.64 UV1.V17 ; UV1.AG16 182.48,115.68 182.59,115.68 v2(183.11,116.2) ; v2(178.97,118.33) 178.97,118.29 ; 178.97,118.29 179.38,118.7 UV1.AC20 ; UV1.Y18 UV1.AA20 179.42,120.7 179.08,120.36 v2(178.96,120.36) ; UV1.AA15 v2(182.96,120.2) UV1.AB16 182.46,119.81 v2(181.95,120.31) ; v2(176.95,117.1) 176.95,117.21 176.46,117.7 UV1.AD23 ; UV1.AD26 174.46,117.79 174.97,118.3 v2(174.97,118.36) 175.1,118.36 175.44,118.7 UV1.AC24 UV1.AB26 ; UV1.AA27 173.46,120.77 v2(172.94,121.29) 172.53,121.7 UV1.Y28 ; UV1.AA22 177.46,120.61 v2(176.96,120.11) 176.55,119.7 UV1.AB23 ; UV1.V20 178.96,122.2 v2(178.96,122.13) 178.53,121.7 UV1.Y21 ; v2(178.02,115.25) 178.46,115.69 UV1.AG21 UV1.AF20 ; v2(180.96,120.26) 181.4,120.7 UV1.AA17 UV1.Y16 ; v2(179.96,123.37) 180.13,123.37 UV1.U18 ; UV1.U21 v2(177.96,124.2) UV1.T22 ; v2(177.96,119.34) 178.32,119.7 UV1.AB21 ; UV1.Y23 176.04,122.12 v2(175.94,122.12) 175.94,122.23 UV1.V24 ; UV1.M26 174.5,127.7 174.91,127.29 v2(174.91,127.18) 175.39,126.7 UV1.N24 175.46,126.66 175.89,126.24 v2(176.04,126.24) ; UV1.AB28 172.46,119.61 v2(172.88,119.19) 173.37,118.7 UV1.AC27 ; v2(175.96,123.26) 176.4,123.7 UV1.U23 ; UV1.Y26 174.82,121.34 v2(174.96,121.34) 175.46,120.84 UV1.AA24 ; UV1.AF20 179.27,116.7 178.98,117 v2(178.98,117.06) ; UV1.AF20 179.46,116.64 v2(179.96,116.14) ; UV1.AF17 181.46,116.6 v2(180.94,116.08) 180.57,115.7 UV1.AG18 ; UV1.AH28 172.55,114.61 173.27,114.61 173.35,114.7 UV1.AH27 173.56,114.7 v2(173.9,114.36)
  BOTTOM w0.508: v2(178.02,115.25) 177.47,114.7 UV1.AH22 ; v2(173.38,105.53) 173.38,105.21 173.88,104.72 PC849.1
  vias: v2(159.48,131.74) v2(159.79,131.17) v2(159.79,130.54) v2(159.79,129.71) v2(160.43,129.71) v2(161.06,129.71) v2(161.57,128.54) v2(162.21,128.54) v2(162.21,127.77) v2(162.84,127.77) v2(192.44,97.01) v3(189.26,88.57) v3(189.77,89.46) v3(189.83,87.68) v3(189.83,86.41) v3(190.59,88.57) v3(191.16,89.46) v3(191.23,87.56) v3(191.23,86.22) v3(191.23,85.02) v3(192.05,89.52) v3(192.43,85.02) v3(193.01,89.52) v3(193.13,88.57) v3(193.45,90.22) v3(193.7,84.95) v3(194.4,89.52) v3(194.53,88.57) v3(194.85,90.22) v3(194.91,84.95) v3(195.23,86.48) v3(195.35,87.68) v3(195.74,89.52) v3(195.86,88.57) v3(196.18,90.22) v3(196.75,84.82) v3(196.88,89.52) v3(197.32,90.22) v3(197.26,88.57) v3(197.89,89.59) v3(197.89,84.82) v3(198.53,90.22) v3(198.59,88.57) v3(199.04,84.89) v3(199.29,89.59) v3(199.67,90.22) v3(199.74,88.57) v3(200.18,84.89) v3(200.31,87.05) v3(200.31,85.97) v3(200.56,89.46) v3(200.94,88.57) v3(201.07,90.29) v3(201.96,89.46) v3(202.09,88.57) v3(202.15,87.44) v3(202.15,86.55) v3(202.15,85.66) v3(202.47,90.29) v3(203.29,89.46) v3(203.61,85.92) v3(203.8,90.29) v3(203.99,88.83) v3(203.99,84.78) v3(204.69,89.46) v3(204.75,85.92) v3(205.13,84.78) v3(205.2,90.29) v3(205.45,88.83) v3(206.02,89.46) v3(205.96,85.85) v3(206.21,88.13) v3(206.21,87.24) v3(206.4,84.84) v3(206.53,90.29) v3(206.91,85.85) v3(207.1,88.13) v3(207.1,87.24) v3(207.17,89.46) v3(207.55,84.84) v3(207.67,90.29) v3(208.05,85.85) v4(162.27,135.24)
+VGA_PCIE: length 87.2
  TOP w0.508: v2(171.73,126.73) 171.84,126.62 CV148.1 CV147.1 ; RV198.2 171.32,122.46 171.66,122.46 171.81,122.61 CV146.1 172.16,123.84 v2(171.71,124.3) ; v2(165.49,103.68) 163.16,101.34 163.16,100.08 ; 163.16,100.08 RV203.2 ; 163.16,100.08 158.63,100.08 157.57,101.14 RV126.1 156.25,102.34 155.41,103.18 155.41,106.41 155.92,106.92 155.92,108.38 156.44,108.9 RV120.2 ; CV150.1 171.01,130.41 v2(171.29,130.69) 171.73,130.24 CV149.1 171.66,129.47 CV151.1 170.09,129.47 169.95,129.6 169.21,129.6 168.94,129.87 RV103.1
  IN1 w0.508: v2(165.49,103.68) 165.21,103.68 161.7,107.19 161.7,111.42 157.76,115.36 v2(157.76,115.94) ; v2(195.29,95.94) 194.72,95.94 192.1,98.56 187.99,98.56 v2(187.19,99.37) v2(179.99,99.37)
  IN3 w0.508: 162.59,124.13 162.59,117.52 161.45,116.38 158.21,116.38 v2(157.76,115.94)
  BOTTOM w0.102: UV1.T28 172.12,124.7
  BOTTOM w0.508: LV15.2 160.55,104.69 161.12,104.13 162.97,104.13 163.6,103.49 165.31,103.49 v2(165.49,103.68) ; LV23.1 194.41,94.93 195.29,95.81 v2(195.29,95.94) ; RV121.1 186.86,99.69 v2(187.19,99.37)
  vias: v2(193.07,78.79) v2(193.07,78.16) v2(193.7,78.79) v2(193.7,78.16) v2(194.34,78.79) v2(194.34,78.16) v4(193.15,80.32)
+VGA_PCIEP: length 13.6
  TOP w0.254: 199.9,75.64 200.22,75.64 200.56,75.3 200.56,66.68 199.42,65.53 PC1306.1 PR1302.1
  vias: v1(199.58,77.46) v2(193.26,74.6) v2(193.89,74.6) v2(195.29,74.6) v2(195.93,74.6) v2(197.01,74.6) v2(197.64,74.6) v2(198.66,74.6)
+VREFG_GPU: length 13.8
  TOP w0.102: v1(185.47,113.91) 184.97,114.42 v2(184.97,114.47)
  IN1 w0.508: v2(184.97,114.47) 185.39,114.05 185.39,112.89 185.08,112.58 185.08,111.13 185.23,110.98 v2(185.23,105.21)
  BOTTOM w0.254: v2(184.97,114.47) 184.74,114.7 UV1.AH13
  BOTTOM w0.508: v2(185.23,105.21) 185.01,105 CV81.1 RV95.1 RV93.1
/BATDRV: length 34.2
  TOP w0.254: v2(145.76,185.92) 146.08,186.23 v1(151.25,186.23) 152.23,186.23 155.78,182.69 159.88,182.69 163.64,178.93 169.07,178.93 169.38,178.61 169.38,177.28 170.46,176.2 170.46,174.99 169.42,173.95 169.29,173.95 168.99,173.65 PU701.11
  BOTTOM w0.254: PR706.2 v2(145.76,185.92)
AC_BATT: length 24.2
  TOP w0.102: RV85.2 189.05,108.84 v1(189.51,108.37) v2(190.72,107.17)
  IN3 w0.102: v2(190.72,107.17) 190.72,108.19 188.65,110.25 188.65,110.83 188.05,111.43 188.05,112.87 187.82,113.1 187.5,113.1 187.27,113.34 187.27,113.7 186.34,114.63 186.34,115.33 186.09,115.58 184.67,115.58 183.83,114.73 182.4,114.73 v2(182.01,114.34)
  BOTTOM w0.102: UV1.AH17 181.64,114.7 v2(182.01,114.34) ; v2(190.72,107.17) 189.94,106.4 RV73.2 189.78,104.09 QV14.3
AC_PRESENT: length 33.8
  IN3 w0.084: v2(125.18,112.4) 125.18,112.96 124.62,113.53 124.62,119.43 125.5,120.32 129.12,120.32 130.46,120.32 131.66,121.53 135.41,121.53 135.54,121.4 v2(137.51,121.4)
  BOTTOM w0.089: v2(137.51,121.4) 137.51,121.59 137.92,122.01 ; UC1.AJ8 125.65,111.71 125.18,112.18 v2(125.18,112.4)
  BOTTOM w0.102: 137.92,122.01 137.99,122.08 139.71,122.08 139.98,122.35 141.15,122.35 142.42,121.08 v1(142.65,121.08) 142.93,121.08 143.16,120.85 143.41,120.85 143.54,120.73 143.54,119.17 144.25,118.46 DH1.2 144.25,116.91 144.38,116.78 RC32.2
ACDET: length 4.6
  TOP w0.102: PR723.1 v1(171.34,167.26)
  TOP w0.254: PR723.1 PR711.2 PC711.2 171.01,170.44 PU701.6
ACDRV: length 28.2
  TOP w0.102: v2(144.48,165.9) v1(144.48,165.27)
  TOP w0.254: PU701.4 168.49,169.08 168.66,168.91 168.66,168.86 v2(168.88,168.64)
  IN3 w0.254: v2(144.48,165.9) 166.32,165.9 168.88,168.45 v2(168.88,168.64)
  BOTTOM w0.254: v2(144.48,165.9) PR703.2
ACIN: length 255.9
  TOP w0.102: v4(170.29,88.66) 170.76,89.14 v2(171.31,89.14) ; v2(192.5,48.63) 192.43,48.56 186.14,48.56 184.1,46.52 UE1.110 180.72,46.52 180.39,46.85 CE18.2
  TOP w0.254: v2(129.63,162.55) 127.85,162.55 126.13,164.28 126.13,172.32 127.19,173.38 127.7,173.38 128.18,172.9 PR1.1 ; PU701.5 168.99,169.22 169.36,168.84 169.75,168.84 v2(169.89,168.71) 170.02,168.58 PR712.1 PR707.2
  IN1 w0.127: v2(192.5,48.63) 192.67,48.79 192.67,52.46 192.81,52.61 192.81,56.41 192.12,57.11 192.12,58.13 190.62,59.63 190.62,66.66 189.55,67.74 189.55,77.77 182.8,84.52 178.78,84.52 174.17,89.14 v2(171.31,89.14) 167.99,89.14 164.99,92.14 164.99,93.94 154.46,104.47 154.46,106.29 153.39,107.37 153.39,110.21 144.57,119.03 v2(144.57,120.47)
  IN2 w0.254: v2(129.63,162.55) 131.35,160.84 131.35,146.95 137.7,140.6 137.7,139.19 144.57,132.33 v2(144.57,120.47)
  IN3 w0.254: v2(169.89,168.71) 164.75,163.56 157.7,163.56 157.19,163.06 132.49,163.06 131.98,162.55 v2(129.63,162.55)
  BOTTOM w0.102: RV250.1 188.16,103.66 188.05,103.55 188.05,99.66 189.98,97.73 189.98,93.81 188.33,92.15 185.22,92.15 184.39,91.33 179.25,91.33 178.15,90.22 174.91,90.22 173.82,89.14 v2(171.31,89.14) ; v2(144.57,120.47) 144.25,120.15 DH1.1
ACIN_65W: length 82.2
  TOP w0.102: UE1.108 180.27,47.32 v2(180.18,47.41)
  IN1 w0.127: v2(190.08,79.52) 190.08,79.49 190.91,78.67 190.91,68.17 191.98,67.11 191.98,60.07 194.56,57.48 194.56,56.29 195.41,55.44 195.41,54.41 194.97,53.98 194.97,51.93 195.52,51.39 195.52,48.5 v2(195.14,48.12)
  IN3 w0.127: v2(190.08,79.52) 190.08,80.85 185.58,85.36 185.58,91.43 v2(185.74,91.6)
  BOTTOM w0.102: v2(180.18,47.41) 181.24,46.34 184.18,46.34 184.88,47.04 189.36,47.04 190.44,48.12 v1(194.36,48.12) v2(195.14,48.12) ; v2(185.74,91.6) 188.1,91.6 190.21,93.71 190.21,98.79 190.4,98.98 190.4,101.71 189.13,102.98 QV14.2 189.13,104.2 RV250.2
ACOFF: length 160.9
  TOP w0.102: UE1.27 193.59,39.29 v2(193.45,39.42)
  TOP w0.254: PQ706.2 v1(135.14,166.92) v2(134.52,166.3)
  IN2 w0.254: v2(134.52,166.3) 133.67,165.44 133.67,163.61 133.09,163.02 133.09,148.81 140.24,141.66 140.24,140.45 150.62,130.06 150.62,122.61 153.55,119.69 153.55,114.51 155.63,112.43 155.63,111.22 161.44,105.41 163.13,105.41 163.82,104.72 163.82,102.62 168.38,98.06 172.19,98.06 173.93,96.32 173.93,95.2 175.35,93.78 176.47,93.78 177.63,92.62 177.63,90.81 183.92,84.52 183.92,82.96 189.89,76.99 189.89,57.14 191.27,55.76 191.27,54.27 190.74,53.73 190.74,50.97 191.16,50.55 191.16,45.6 192.81,43.94 192.81,40.37 193.45,39.74 v2(193.45,39.42)
AD_BID0: length 12.5
  TOP w0.102: RE5.2 CE8.1 RE3.1 v1(197.2,54.78) 197.2,52.88 196.55,52.24 196.21,52.24 195.02,51.04 194.54,51.04 193.84,51.74 192.33,51.74 191.59,52.48 UE1.75
ADBIA0: length 32
  TOP w0.102: UV5.J4 168.7,152.46 v2(169.09,152.07)
  IN3 w0.102: 177.56,137.4 177.56,137.19 177.53,137.15 177.53,134.02 177.32,133.81 177.32,132.68 177.6,132.4 177.6,130.64 v2(177.19,130.24) ; v2(169.09,152.07) 170.14,152.07 170.53,152.46 174.14,152.46 174.34,152.26
  IN3 w0.157: 177.56,137.4 177.56,150.63 175.93,152.26 174.34,152.26
  BOTTOM w0.102: v2(177.19,130.24) 177.8,130.24 UV1.J21 ; UV5.J4 168.7,152.46 v2(169.09,152.07)
ADBIA1: length 29.4
  TOP w0.102: v2(189.6,152.01) 189.21,152.39 UV3.J4
  IN3 w0.102: v2(179.67,131.65) 180.05,132.03 180.05,135.49 181.81,137.26 181.81,137.4 ; v2(189.6,152.01) 188.82,152.01 187.04,150.23 183.16,150.23 182.13,149.2
  IN3 w0.157: 182.13,149.2 181.32,148.38 181.32,139.12 181.81,138.62 181.81,137.4
  BOTTOM w0.102: UV1.G19 179.92,131.9 v2(179.67,131.65) ; UV3.J4 189.21,152.39 v2(189.6,152.01)
ADBIB0: length 33.9
  TOP w0.102: UV7.J4 212.76,135.1 v2(212.37,134.72)
  IN3 w0.102: v2(189.26,124.45) 189.64,124.45 190.48,125.28 191.12,125.28 191.13,125.27 191.13,125.27 191.51,124.9 194.02,124.9 194.17,125.04 194.39,125.04 ; v2(212.37,134.72) 212.37,133.66 212.76,133.27 212.76,129.78 212.56,129.58 212.56,127.96
  IN3 w0.157: 212.56,127.96 212.56,127.88 210.93,126.24 201.91,126.24 200.71,125.04 194.39,125.04
  BOTTOM w0.102: v2(212.37,134.72) 212.76,135.1 UV7.J4 ; UV1.T7 189.66,124.85 v2(189.26,124.45)
ADBIB1: length 32.1
  TOP w0.102: v2(212.98,114.32) 212.58,114.72 UV9.J4
  IN3 w0.102: 194.39,121.24 193.24,121.24 193.15,121.34 192.75,121.34 192.43,121.65 192.43,121.94 192.21,122.16 191.84,122.16 191.02,121.35 190.75,121.35 v2(190.32,121.78) ; 209.37,121.79 210.4,120.75 210.4,116.88 212.98,114.3 v2(212.98,114.32)
  IN3 w0.157: 194.39,121.24 201.81,121.24 203.06,122.49 208.66,122.49 209.37,121.79
  BOTTOM w0.102: UV9.J4 212.58,114.72 v2(212.98,114.32) ; v2(190.32,121.78) 189.66,122.44 UV1.W7
ADP_I: length 250.9
  TOP w0.102: v2(196.24,52.67) 196.04,52.47 195.7,52.47 195.59,52.58 UE1.65
  TOP w0.254: PR23.2 132.87,181.92 v1(135.66,184.7) 136.17,185.22 136.17,186.11 137.63,187.57 140.89,187.57 141.91,188.58 150.96,188.58 156.1,183.45 160.2,183.45 163.4,180.24 171.82,180.24 172.94,179.12 172.94,176.7 174.08,175.55 174.08,173.93 173.51,173.36 173.51,171.76 173.13,171.38 v2(172.94,171.38) 172.93,171.38 172.49,170.94 PU701.7
  IN2 w0.127: v2(172.94,171.38) 172.49,170.93 172.49,165.59 174.19,163.9 179.57,163.9 181.15,165.48 188.58,165.48 190.19,167.1 193.84,167.1 199.06,161.88 209.11,161.88 223.31,147.68 223.31,126.89 222.53,126.12 222.53,125.97 222.53,93.43 219.19,90.08 219.19,80.71 220.75,79.14 220.75,62.7 214.28,56.22 214.28,53.58 214.73,53.13 v2(214.7,53.13)
  BOTTOM w0.102: v2(214.7,53.13) 214.7,52.68 212.77,50.75 204.09,50.75 203.93,50.92 198,50.92 v2(196.24,52.67) 196.1,52.81 PC720.2
ADPIN:
  vias: v3(138.59,179.63) v3(138.59,179) v3(138.65,174.61) v3(138.65,173.98) v3(139.22,179.63) v3(139.22,179) v3(139.28,174.61) v3(139.28,173.98) v4(137.37,178.74) v4(138.65,175.21) v4(139.44,178.03)
AUD_HP_OUT_L_CN: length 36.3
  TOP w0.254: LA8.1 29.51,20.84 CA39.1 v2(30.1,19.59) 30.76,19.59 31.07,19.28 v1(31.08,19.28) 31.08,18.2 30.39,17.52 DA10.3
  IN1 w0.254: v2(30.1,19.59) 30.1,19.15 29.43,18.48 27.27,18.48 24.79,20.96 17.49,20.96 14.76,18.23 14.76,10.99 13.76,9.98 JHP.1
AUD_HP_OUT_R_CN: length 30.2
  TOP w0.254: LA9.1 28.25,21.39 CA33.1 v2(28.25,19.62) 28.25,19.61 v1(27.7,19.07) 27.7,18.51 28.46,17.74 DA10.2
  IN1 w0.254: JHP.2 7.47,21.02 16.22,21.02 16.79,21.59 25.11,21.59 27.08,19.62 v2(28.25,19.62)
B+: length 349
  TOP w2.54: 223.49,100.89 223.49,121.29 222.74,122.04 222.74,126.68 225.14,129.08 ; 141.32,171.63 141.32,165.91 139.54,164.14 136.24,164.14 135.54,163.44
  IN1 w2.159: 181.13,179.58 175.48,179.58 173.7,181.36 170.02,181.36
  IN1 w2.54: 225.14,127.56 222.53,124.96 222.53,114.02 223.46,113.09 223.46,93.06 221.14,90.73 218.28,90.73 217.26,89.71
  IN2 w2.159: 169.76,181.3 173.45,181.3 175.1,179.64 180.5,179.64
  IN3 w2.54: 145.57,178.55 146.62,178.55 147.34,179.26 156.89,179.26 158.72,181.09 163.99,181.09
  IN3 w3.048: 222.47,20.07 222.47,14.42 220.95,12.89 220.95,5.91 218.85,3.81 201.51,3.81 200.18,5.15 174.78,5.15 168.43,11.5 168.43,18.35
  BOTTOM w2.54: 147.16,178.49 157.89,178.49 160.13,180.72 164.35,180.72
  BOTTOM w3.048: 222.91,25.53 222.91,36.13 223.93,37.15 223.93,48.5 221.83,50.6 221.83,59.06 220.06,60.84 220.06,73.43 220.06,74.58 220.06,74.58 220.06,78.28 218.17,80.17 218.17,85.97
  BOTTOM w4.572: 193.77,174.11 193.77,164.64 197.7,160.71 204.75,160.71 208.28,157.18 217.04,157.18 220.31,153.91 220.31,150.42 226.41,144.32 226.41,135.82
  vias: v2(168.18,22.74) v2(168.18,22.1) v2(168.18,21.47) v2(168.94,22.74) v2(168.94,22.1) v2(168.94,21.47) v2(214.59,87.38) v2(215.05,88.76) v2(215.05,87.86) v2(215.04,86.93) v2(215.5,88.31) v2(215.5,87.41) v2(215.48,86.43) v2(215.95,87.86) v2(215.95,86.96) v2(216.4,87.41) v2(222.66,23.82) v2(222.66,23.18) v2(222.66,22.55) v2(223.42,23.82) v2(223.42,23.18) v2(223.42,22.55) v2(226.91,177.92) v2(227.37,130.46) v2(227.37,129.82) v2(227.87,177.85) v2(228.01,130.46) v2(228.01,129.82) v2(228.01,129.19) v2(228.01,128.55) v2(228.44,177.73) v2(228.5,177.13) v2(228.64,130.46) v2(228.64,129.82) v2(228.64,129.19) v2(228.64,128.55) v3(135.41,161.15) v3(135.41,160.14) v3(135.41,159.12) v3(136.05,160.14) v3(136.05,159.12) v3(142.4,177.85) v3(142.4,176.84) v3(142.4,175.82) v3(142.4,174.8) v3(143.16,177.85) v3(143.16,176.84) v3(143.16,175.82) v3(143.16,174.8) v3(143.16,173.79) v3(143.16,172.77) v3(143.79,177.85) v3(143.79,176.84) v3(143.79,175.82) v3(143.79,174.8) v3(143.79,173.79) v3(143.79,172.77) v3(166.59,182.3) v3(166.59,181.66) v3(166.59,181.03) v3(167.22,182.3) v3(167.22,181.66) v3(167.22,181.03) v3(167.86,182.3) v3(167.86,181.66) v3(167.86,181.03) v3(193.26,178.93) v3(193.26,178.3) v3(193.26,177.66) v3(193.89,178.93) v3(193.89,178.3) v3(193.89,177.66) v3(194.53,178.93) v3(194.53,178.3) v3(194.53,177.66) v4(141.41,176.98)
B+_1.05V:
  vias: v1(140.52,161.53)
B+_VDDCI: length 3.1
  BOTTOM w0.102: PL1201.2 191.51,175.72 v1(190.92,175.14)
B-RAMP: length 5.6
  TOP w0.102: v1(88.85,144.71) 88.85,144.58 87.79,143.51 v2(87.79,142.61)
  TOP w0.254: v2(87.79,142.61) 87.6,142.42 PR509.2
  BOTTOM w0.203: PU501.11 88.62,141.96 87.96,142.61 v2(87.79,142.61)
  BOTTOM w0.254: v2(87.79,142.61) 87.72,142.67 PR507.1
BAT_ALERT: length 24.7
  BOTTOM w0.254: PBATT.3 159.16,188.79 154.52,188.79 154.33,188.6 v1(144.29,188.6) 143.16,188.6 143.03,188.72 PD2.2 142.07,188.34 141.13,187.39 141.13,185.79 140.49,185.16 PD1.4
BATT+: length 0.7
  TOP w0.102: v2(154.13,181.1) v1(154.13,180.41)
BATT++:
  vias: v1(159.92,185.64) v3(157.25,185.93) v3(157.57,186.57) v3(157.89,185.93) v3(158.21,186.57) v3(158.52,185.93) v3(171.48,188.98) v3(171.8,189.61) v3(172.11,188.98) v3(172.43,189.61) v3(172.75,188.98)
BATT_CHG_LED#: length 181.5
  TOP w0.102: v1(183.24,35.66) 183.72,35.18 v2(183.91,35.18) ; UE1.90 185.59,52.02 184.51,50.95 v2(184.14,50.95) ; RD16.1 v2(42.22,14.82)
  IN1 w0.127: v2(183.91,35.18) 183.27,35.18 182.62,35.83 166.87,35.83 160.16,42.53 136.62,42.53 133.25,45.9 106.51,45.9 81.99,21.38 63.2,21.38 56.64,14.82 v2(42.22,14.82)
  IN2 w0.127: v2(183.91,35.18) 183.27,35.18 182.11,36.34 182.11,48.92 v2(184.14,50.95)
BATT_LOW_LED#: length 182.9
  TOP w0.102: RD17.1 v2(41.33,14.82) ; UE1.93 184.39,54.3 v2(183.99,54.69) 183.99,54.72 v1(184.6,55.32)
  IN1 w0.127: v2(41.33,14.82) 41.75,14.4 56.58,14.4 63.3,21.13 82.1,21.13 106.62,45.65 133.15,45.65 136.51,42.28 160.06,42.28 166.83,35.51 182.34,35.51 v2(182.78,35.07)
  IN2 w0.127: v2(182.78,35.07) 181.85,36 181.85,51.07 183.99,53.2 v2(183.99,54.69)
BATT_PRS: length 55.4
  TOP w0.254: PC14.1 v2(133.57,166.5) ; v2(138.26,189.47) 138.42,189.31 v1(140.78,189.31) 141.06,189.6 151.38,189.6 153.02,187.96 162.33,187.96 PBATT.5
  IN1 w0.254: v2(133.57,166.5) 133.57,178.8 137.98,183.21 137.98,185.53 v2(138.54,186.08)
  BOTTOM w0.254: v2(138.26,189.47) PR17.2 138.26,187.96 138.54,187.68 PR15.1 v2(138.54,186.08)
BATT_TEMP: length 212.7
  TOP w0.102: v2(191.23,51.94) 191.23,51.93 193.13,50.03 194.97,50.03 196.26,51.32 UE1.63 199.49,51.32 CE9.2
  TOP w0.254: v2(137.63,186.17) v1(138.31,186.85) 138.65,187.19 141.05,187.19 142.07,188.2 150.8,188.2 155.94,183.07 160.04,183.07 163.75,179.35 170.17,179.35 170.4,179.12 PC723.2
  IN2 w0.254: v2(191.23,51.94) 191.23,51.93 191.66,52.36 191.66,55.92 190.27,57.3 190.27,77.15 184.31,83.12 184.31,84.67 178.01,90.97 178.01,92.78 172.34,98.44 168.54,98.44 164.2,102.78 164.2,104.88 163.29,105.79 161.59,105.79 156.01,111.38 156.01,112.58 153.93,114.66 153.93,119.85 151.95,121.83 151.95,129.28 140.62,140.61 140.62,141.82 133.63,148.8 133.63,163.03 134.05,163.45 134.05,165.06 135.47,166.49 135.47,184.01 v2(137.63,186.17)
  BOTTOM w0.254: PR16.1 PR15.2 137.63,186.95 v2(137.63,186.17)
BBS_BIT: length 14.1
  BOTTOM w0.076: UC1.L8 126.05,121.59 128.87,121.59 129.31,121.15 129.31,120.96 129.46,120.81 130.82,120.81 131.83,121.82 132.49,121.82 132.59,121.72 133.11,121.72 RC123.1
  BOTTOM w0.089: RC123.1 134.08,122.68 134.57,122.68 134.81,122.45 134.81,120.98 RC119.2 135.94,119.84 v1(135.94,119.48)
BEEP#: length 165.7
  TOP w0.102: v2(178.21,37.28) 178.21,36.45 181.29,33.38 190.96,33.38 v1(191.22,33.63) 192.24,34.66 192.24,36.5 191.99,36.76 UE1.23 ; DA8.2 51.35,32.6 v2(50.29,33.66)
  IN1 w0.127: v2(50.29,33.66) 50.29,41.31 57.32,48.34 64.88,48.34 65.26,48.72 138.88,48.72 143.98,43.61 160.68,43.61 167.01,37.28 v2(178.21,37.28)
BKOFF#: length 164.1
  TOP w0.102: v2(183.42,48.12) 183.02,48.52 UE1.105 ; v2(211.28,163.23) v1(210.63,163.23)
  IN3 w0.127: v2(183.42,48.12) 187.21,48.12 188.12,49.03 192.39,49.03 192.4,49.05 193.97,49.05 194.95,50.03 197.53,50.03 198.88,51.38 210.85,51.38 212.18,52.71 217.65,52.71 219.06,54.12 219.06,63.58 219.7,64.22 219.7,74.49 216.63,77.57 216.63,86.17 217.38,86.92 217.38,88.76 215.66,90.47 214.82,90.47 213.08,92.21 213.08,95.16 213.22,95.29 213.22,103.12 218.08,107.98 218.08,124.27 218.2,124.39 218.2,139.19 220.12,141.11 220.12,152.83 211.28,161.67 v2(211.28,163.23)
  BOTTOM w0.102: RX50.1 213.58,164.01 212.06,164.01 v2(211.28,163.23) 211.26,163.25 UX2.1
BOOT_1.35V: length 4.9
  BOTTOM w0.102: v1(153.15,30.1) 153.8,29.45 153.8,26.71 154.16,26.35 PR200.2
BST: length 0.6
  BOTTOM w0.102: v2(164.98,172.07) v1(164.38,172.07)
BST_1.05V: length 2.8
  BOTTOM w0.102: v1(147.91,161.29) 147.91,159.86 147.04,158.99 PR303.1
BST_1.35V: length 1.4
  BOTTOM w0.102: PC200.1 v1(154.91,22.32)
BST_3V: length 2.2
  TOP w0.203: 207.61,18.12 207.55,18.18 PU100.9
  TOP w0.254: 207.61,18.12 207.75,17.97 v1(207.75,17.45) PR103.2
BST_5V: length 5
  TOP w0.102: PR111.1 208.75,23.93 208.96,24.13 208.96,25.83 v1(208.87,25.92)
  TOP w0.203: PR111.1 208.36,23.01 207.55,22.2 PU100.17
BST_+1.2VSP: length 1.6
  TOP w0.102: PR1101.1 v1(185.07,169.59)
BST_CHGA: length 2.7
  TOP w0.102: v1(162.58,175.75) 162.53,175.7 PD701.1
BST_VDDCI: length 2.8
  TOP w0.102: v2(186.32,179.65) v1(186.32,178.75)
  TOP w0.508: v2(186.32,179.65) 186.89,180.22 PR1200.1
  BOTTOM w0.254: PU1200.6 186.72,180.04 v2(186.32,179.65)
BST_VGA_CORE: length 1.6
  BOTTOM w0.102: v1(202.8,62.49) 202.4,62.09 PR802.1
BT_LED#: length 211.7
  TOP w0.102: QD19.3 53.92,16.97 54.18,17.24 RD47.2 54.18,19.78 RD49.1 54.19,20.64 v1(54.35,20.79) 56.54,20.79 56.72,20.61 UD1.2 57.66,20.61 v2(57.83,20.45)
  IN2 w0.127: v2(49.81,24.56) 49.09,25.29 49.09,50.18 29.32,69.95 29.32,101.61 47.28,119.57 63.37,119.57 81.55,137.75 81.55,138.28 82.62,139.35 82.62,140.25 84.03,141.66 84.03,142.7 84.86,143.54 84.86,145.86 87.39,148.38 96.4,148.38 96.57,148.2 99.41,148.2 100.59,149.38 112.75,149.38 113.12,149.01 v2(113.12,148.92)
  BOTTOM w0.102: v2(57.83,20.45) 55.6,20.45 51.49,24.56 v2(49.81,24.56) ; v2(113.12,148.92) 113.5,149.3 JMINI.46
BT_ON#: length 58.2
  TOP w0.089: v2(134.27,115.75) 134.27,116.08 v1(133.86,116.49) 132.83,116.49 132.68,116.64 RP54.2
  TOP w0.102: v2(114.58,148.86) 114.98,149.26 RM13.2
  IN1 w0.084: v2(134.27,115.75) 133.35,114.83 127.99,114.83 v2(127.78,115.04)
  IN2 w0.089: v2(127.78,115.04) 127.33,115.5 125.7,115.5 124.93,116.26 124.93,129.95 124.11,130.77 124.11,133.59 122.97,134.74 122.97,135.15
  IN2 w0.127: 122.97,135.15 122.97,137.02 125.12,139.18 125.12,146.23 121.97,149.38 115.1,149.38 v2(114.58,148.86)
  BOTTOM w0.089: v2(127.78,115.04) 127.64,114.9 UC1.AD5
CAPS_LED: length 156.4
  TOP w0.102: v4(216.96,51.69) 216.77,51.88 v2(216.22,51.88) ; UE1.91 185.19,51.94 184.77,51.53 v2(184.13,51.53) ; JKB.1 v2(225.52,161.83)
  IN2 w0.127: v2(216.22,51.88) 216.78,51.88 223.17,58.26 223.17,80.14 221.6,81.71 221.6,88.97 224.95,92.32 224.95,122.35 226.69,124.09 226.69,154.2 225.52,155.37 v2(225.52,161.83)
  BOTTOM w0.102: v2(184.13,51.53) 184.73,50.93 192.42,50.93 193.12,50.23 203.64,50.23 203.81,50.06 214.41,50.06 v2(216.22,51.88)
CASA0#: length 34.6
  TOP w0.102: UV5.G3 169.86,152.84 v2(169.86,152.84)
  IN3 w0.102: v2(169.86,152.84) 171.39,154.36 174.46,154.36 175.04,153.78 ; v2(178.53,129.91) 178.01,130.43 178.01,132.57 177.73,132.84 177.73,133.64 177.93,133.85 177.93,136.57 178.76,137.4
  IN3 w0.157: 175.04,153.78 175.84,153.78 178.76,150.87 178.76,137.4
  BOTTOM w0.102: UV5.G3 169.86,152.84 v2(169.86,152.84) ; UV1.K20 178.94,129.5 v2(178.53,129.91)
CASA1#: length 31.9
  TOP w0.102: UV3.G3 190.37,152.77 v2(190.37,152.77)
  IN3 w0.102: 184.29,137.4 184.29,137.19 183.75,136.65 183.75,134.17 183.51,133.94 182.61,133.94 182.29,133.62 182.29,133.01 182.07,132.79 182.05,132.79 181.72,132.46 181.72,131.54 181.28,131.09 181.28,130.16 v2(180.91,129.8) ; v2(190.37,152.77) 190.78,152.37 190.78,149.91 190,149.12 186.19,149.12 185.21,148.15 185.21,144.39 184.78,143.95 184.78,143.66 184.41,143.3
  IN3 w0.157: 184.29,137.4 184.29,143.17 184.41,143.3
  BOTTOM w0.102: v2(190.37,152.77) 190.37,152.77 UV3.G3 ; v2(180.91,129.8) 181.21,129.5 UV1.K17
