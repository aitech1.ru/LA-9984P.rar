# Allegro board LA9984PR10-0523.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VS on TOP (solid shape): outline of 3434 points within 119.26,114.56 148.66,152.1
+3VS on BOTTOM (solid shape): 132.24,134.01 132.24,133.05 132,132.82 130.48,132.82 130.31,132.99 130.31,134.09 130.42,134.21 132.04,134.21
+3VS on BOTTOM (solid shape): 203.36,166.74 203.36,164.72 203.27,164.63 201.65,164.63 201.5,164.79 201.5,166.86 201.58,166.93 203.17,166.93
+3VS on BOTTOM (solid shape): 70.58,110.63 70.58,109.59 70.37,109.38 67.53,109.38 67.38,109.53 67.38,110.44 67.63,110.69 70.52,110.69
+3VS on BOTTOM (solid shape): 84.97,139.37 84.97,138.36 84.97,138.36 84.93,138.36 84.93,138.32 84.61,138 84.61,137.42 84.54,137.34 83.67,137.34 83.53,137.49 83.53,139.49 83.62,139.59 84.75,139.59
+3VS on BOTTOM (solid shape): 187.19,95.08 187.19,93.58 186.3,92.69 184.81,92.69 184.5,92.38 183.16,92.38 182.93,92.61 182.93,93.89 183.16,94.12 184.47,94.12 185.71,95.37 186.91,95.37
+3VS on BOTTOM (solid shape): 140.49,118.26 140.49,117.66 140.55,117.6 140.55,116.44 140.44,116.33 139.3,116.33 139.19,116.43 139.19,116.66 139.2,116.73 139.79,117.33 139.79,118.23 139.92,118.35 140.4,118.35
+3VS on BOTTOM (solid shape): 103.79,74.35 103.79,72.51 104,72.3 104.09,72.3 104.13,72.29 104.31,72.11 104.31,71.27 104.28,71.24 103.67,71.24 103.24,71.67 103.24,72.16 103.39,72.3 103.39,74.32 103.51,74.43 103.71,74.43
+3VS on BOTTOM (solid shape): 225.92,177.47 225.92,176.68 225.8,176.56 225.26,176.56 225.17,176.48 225.17,175.13 225.09,175.04 224.93,175.04 224.83,175.14 224.83,176.28 224.84,176.28 224.84,176.51 224.77,176.58 224.77,177.42 224.95,177.6 225.79,177.6
+3VS on BOTTOM (solid shape): 28.67,116.71 28.67,115.93 26.47,113.73 22.57,113.73 22.3,113.46 22.3,111.86 22.58,111.59 23.21,111.59 23.34,111.46 23.34,110.13 23.21,110 22.6,110 21.83,109.23 20.6,109.23 20.43,109.4 20.43,110.08 20.71,110.37 20.71,111.98 20.18,112.51 18.22,112.51 17.86,112.88 16.68,112.88 16.18,112.38 16.18,111.53 16.09,111.43 15.58,111.43 15.44,111.57 15.44,111.57 14.74,112.27 14.74,112.82 14.86,112.95 15.39,112.95 15.86,113.41 15.86,115.49 16.27,115.91 25.72,115.91 26.72,116.9 28.47,116.9
+3VS on BOTTOM (solid shape): 139.09,126.04 144.05,126.04 144.36,125.72 144.36,121.59 144.11,121.34 143.41,121.34 143.22,121.53 143.22,122.16 142.99,122.4 142.96,122.51 143.06,122.57 143.31,122.57 143.55,122.73 143.49,123 143.46,123.08 143.49,123.15 143.55,123.42 143.31,123.58 142.9,123.58 142.85,123.57 142.8,123.55 142.7,123.56 142.65,123.65 142.65,124.58 142.3,124.92 139.76,124.92 139.47,124.64 139.47,122.48 139.25,122.26 137.92,122.26 137.8,122.13 137.77,122.1 137.38,121.71 137.37,121.7 137.18,121.38 137.41,121.09 137.44,121.07 137.44,120.19 137.38,120.13 136.05,120.13 135.92,120.26 135.92,121.59 136.36,122.04 136.36,123.31 135.92,123.75 135.92,124.51 136.35,124.94 136.35,127.19 136.34,127.19 135.92,127.61 135.92,128.14 136.03,128.25 136.88,128.25
+3VS on IN1 (solid shape): 180.87,21.65 180.87,20.2 180.8,20.13 178.34,20.13 177.96,20.51 177.96,21.63 178.13,21.8 180.72,21.8
+3VS on IN1 (solid shape): 229.51,44.34 229.51,40.02 228.82,39.33 227.95,39.33 227.37,39.91 227.37,40.15 227.77,40.54 227.77,44.35 227.85,44.44 229.41,44.44
+3VS on IN1 (solid shape): 215.48,41.4 215.48,39.69 215.17,39.37 214.85,39.37 213.96,40.26 212.13,40.26 211.94,40.07 211.94,39.71 211.84,39.62 210.46,39.62 210.34,39.74 210.34,41.66 210.65,41.98 214.91,41.98
+3VS on VCC (solid shape): outline of 57679 points within 22,1.02 236.38,192.08
+3VS on IN2 (solid shape): 105.55,72.61 105.55,71.45 105.3,71.2 103.14,71.2 102.89,71.45 102.89,72.69 103.11,72.91 105.25,72.91
+3VS on IN2 (solid shape): 110.36,55.48 110.36,53.31 110.12,53.07 108.88,53.07 108.65,53.29 108.65,55.42 108.96,55.72 110.12,55.72
+3VS on IN2 (solid shape): 221.45,145.72 221.45,144.01 221.26,143.82 220.5,143.82 220.12,143.44 220.12,142.48 219.87,142.23 218.66,142.23 218.09,142.8 218.09,145.78 218.28,145.98 221.2,145.98
+3VS on IN2 (solid shape): 214.28,102.16 214.28,98.54 213.2,97.46 211.29,97.46 211.04,97.72 211.04,100.47 211.51,100.47 211.51,100.42 211.52,100.37 211.53,100.32 211.56,100.27 211.59,100.22 211.62,100.18 211.66,100.15 211.71,100.12 211.76,100.1 211.81,100.09 211.86,100.09 211.92,100.09 211.97,100.1 212.02,100.12 212.07,100.15 212.11,100.18 212.14,100.22 212.17,100.27 212.2,100.32 212.21,100.37 212.22,100.42 212.22,100.47 212.21,100.52 212.2,100.58 212.17,100.62 212.14,100.67 212.11,100.71 212.07,100.74 212.02,100.77 211.97,100.79 211.92,100.8 211.86,100.8 211.81,100.8 211.76,100.79 211.71,100.77 211.66,100.74 211.62,100.71 211.59,100.67 211.56,100.62 211.53,100.58 211.52,100.52 211.51,100.47 211.04,100.47 211.04,101.97 211.61,102.54 213.9,102.54
+3VS on IN2 (solid shape): outline of 325 points within 176.58,56.03 185.07,72.01
+3VS_RT on BOTTOM (solid shape): 200.93,167.87 200.93,165.59 200.83,165.48 200.82,165.48 200.69,165.51 200.57,165.49 200.56,165.48 200.15,165.48 200.08,165.5 200.01,165.51 199.99,165.51 199.9,165.6 199.9,166.98 199.52,167.36 198.85,167.36 198.82,167.39 198.82,168.76 198.89,168.82 199.98,168.82
+3VS_RT on IN1 (solid shape): outline of 576 points within 193.14,160.12 213.78,175.57
+5V_HDD on TOP (solid shape): 228.41,53.88 228.41,53.87 228.6,53.56 228.92,53.4 228.97,53.39 229.03,53.38 229.1,53.35 229.13,53.28 229.13,49.72 228.57,49.72 226.03,52.26 224.39,52.26 223.87,52.79 221.31,52.79 220.88,53.22 220.88,55.44 221.13,55.69 226.6,55.69
+5V_PVDD on TOP (solid shape): 43.91,19.5 43.91,15.99 43.82,15.9 43.24,15.9 43.15,16 43.15,17.34 42.7,17.78 42.13,17.78 41.94,17.97 41.94,19.43 42.13,19.62 43.78,19.62
+5V_USB_PWR1 on TOP (solid shape): 28.91,71.66 28.91,69.79 28.72,69.6 27.07,69.6 26.63,69.16 26.63,67.39 26.34,67.1 24.63,67.1 24.43,67.3 24.43,71.64 24.66,71.87 28.69,71.87
+5V_USB_PWR1 on BOTTOM (solid shape): 27.22,69.34 27.22,65.59 26.87,65.24 21.57,65.24 21.16,65.65 16.79,65.65 14.95,67.49 14.32,67.49 13.16,68.65 12.49,68.65 12.05,69.09 11.97,69.09 11.97,69.33 12.35,69.71 26.85,69.71
+5V_USB_PWR2 on TOP (solid shape): 29.03,56.64 29.03,54.1 28.84,53.91 26.18,53.91 25.99,54.1 25.99,56.52 26.43,56.96 28.72,56.96
+5V_USB_PWR2 on BOTTOM (solid shape): 27.29,55.71 27.29,51.6 26.76,51.07 25.91,51.07 25.38,51.61 24.97,51.61 24.72,51.36 19.38,51.36 18.99,51.76 16.56,51.76 15.83,51.03 15.69,50.89 14.97,50.89 14.94,50.92 14.01,50.92 13.98,50.89 12.67,50.89 12.09,51.46 12.09,53.39 14.19,55.49 19.48,55.49 20.75,54.22 22.86,54.22 24.86,56.23 26.77,56.23
+5V_USB_PWR3 on TOP (solid shape): 16.86,34.28 16.86,32.69 16.6,32.44 13.94,32.44 13.74,32.63 13.74,33.96 14.25,34.47 16.67,34.47
+5V_USB_PWR3 on BOTTOM (solid shape): outline of 153 points within 9.44,32.34 27.4,37.34
+5V_USB_PWR4 on TOP (solid shape): 211.8,40.63 211.8,38.82 211.41,38.43 209.11,38.43 208.73,38.8 208.73,39.16 208.46,39.44 208.46,41.07 208.74,41.35 211.08,41.35
+5V_USB_PWR4 on BOTTOM (solid shape): 211.63,40.91 211.63,39.38 211.56,39.3 208.39,39.3 208.31,39.38 208.31,40.87 208.46,41.02 211.52,41.02
+5VALW on TOP (solid shape): 29.03,51.06 29.03,49.66 29.29,49.41 30.11,49.41 30.24,49.28 30.24,48.45 29.86,48.07 29.86,47.56 29.73,47.44 29.16,47.44 28.84,47.75 27.7,47.75 27.45,48.01 27.45,49.09 27.95,49.6 27.95,51.12 28.08,51.25 28.84,51.25
+5VALW on TOP (solid shape): 28.97,66.8 28.97,65.34 29.19,65.12 29.72,65.12 29.86,64.98 29.86,59.36 29.58,59.08 27.24,59.08 26.96,59.37 26.96,63.14 27.89,64.07 27.89,66.87 27.95,66.93 28.84,66.93
+5VALW on TOP (solid shape): 23.49,36.02 23.49,34.71 23.15,34.36 23.15,32.72 23.38,32.49 23.38,31.47 23.37,31.46 23.37,31.15 23.14,30.93 21.62,30.93 21.4,31.15 21.4,33.35 21.3,33.45 19.65,33.45 19.59,33.52 19.59,34.28 19.78,34.47 21.11,34.47 21.87,35.23 21.87,35.93 22.13,36.18 23.33,36.18
+5VALW on TOP (solid shape): outline of 119 points within 189.7,19.75 196.5,27.24
+5VALW on BOTTOM (solid shape): 217.9,41.44 217.9,39.12 218.41,38.61 218.41,38.29 218.15,38.04 216.18,38.04 216.06,38.17 216.06,39.12 216.06,39.13 215.93,39.26 214.33,39.26 214.08,39.51 214.08,40.13 214.33,40.38 215.93,40.38 216.31,40.75 216.31,41.49 216.41,41.59 217.75,41.59
+5VALW on BOTTOM (solid shape): 200.69,32.45 200.69,32.07 200.5,31.88 200.12,31.88 200.12,29.97 200.31,29.78 200.56,29.78 200.75,29.59 200.75,26.8 200.63,26.67 200.24,26.67 200.12,26.55 200.12,24.64 200.24,24.51 200.63,24.51 200.75,24.39 200.75,23.37 200.69,23.31 194.15,23.31 193.64,23.82 193.64,29.47 195,29.47 195,29.42 195.01,29.36 195.02,29.31 195.05,29.27 195.08,29.22 195.11,29.18 195.15,29.15 195.2,29.12 195.25,29.1 195.3,29.09 195.35,29.09 195.41,29.09 195.46,29.1 195.51,29.12 195.56,29.15 195.6,29.18 195.63,29.22 195.66,29.27 195.69,29.31 195.7,29.36 195.71,29.42 195.71,29.47 195.7,29.52 195.69,29.57 195.66,29.62 195.63,29.67 195.6,29.71 195.56,29.74 195.51,29.77 195.46,29.78 195.41,29.8 195.35,29.8 195.3,29.8 195.25,29.78 195.2,29.77 195.15,29.74 195.11,29.71 195.08,29.67 195.05,29.62 195.02,29.57 195.01,29.52 195,29.47 193.64,29.47 193.64,30.8 195.55,32.71 200.43,32.71
+5VALW on IN1 (solid shape): 198.78,26.55 198.78,24.39 197.89,23.5 194.34,23.5 193.96,23.88 193.96,26.55 194.59,27.18 198.15,27.18
+5VALW on IN1 (solid shape): 218.53,38.48 218.53,36.77 217.9,36.13 215.8,36.13 215.36,36.58 215.36,38.42 215.74,38.8 218.21,38.8
+5VALW on IN3 (solid shape): outline of 284 points within 158.78,23.74 196.56,33.52
+5VALW on VCC: outline of 253 points within 19.08,10.29 196.75,65.58
+5VALWP on BOTTOM (solid shape): 214.34,33.4 214.34,29.85 214.28,29.78 209.83,29.78 208.82,28.77 205.45,28.77 204.31,27.63 204.31,24.58 203.61,23.88 201.07,23.88 200.88,24.07 200.88,27.37 200.94,27.43 201.58,27.43 201.83,27.69 201.83,28.2 201.64,28.39 201.07,28.39 200.88,28.58 200.88,29.44 206.14,29.44 206.14,29.39 206.15,29.34 206.16,29.29 206.18,29.24 206.21,29.19 206.25,29.15 206.29,29.12 206.34,29.09 206.39,29.08 206.44,29.06 206.49,29.06 206.55,29.06 206.6,29.08 206.65,29.09 206.69,29.12 206.74,29.15 206.77,29.19 206.8,29.24 206.82,29.29 206.84,29.34 206.85,29.39 206.85,29.44 206.84,29.49 206.82,29.55 206.8,29.59 206.77,29.64 206.74,29.68 206.69,29.71 206.65,29.74 206.6,29.76 206.55,29.77 206.49,29.77 206.44,29.77 206.39,29.76 206.34,29.74 206.29,29.71 206.25,29.68 206.21,29.64 206.18,29.59 206.16,29.55 206.15,29.49 206.14,29.44 200.88,29.44 200.88,33.02 201.77,33.91 213.83,33.91
+5VS on TOP (solid shape): 30.2,13.1 30.2,11.52 30.12,11.44 29.11,11.44 28.98,11.57 28.98,13.03 29.15,13.19 30.11,13.19
+5VS on TOP (solid shape): 199.99,22.74 199.99,20.01 199.86,19.88 197.83,19.88 197.45,20.26 197.45,22.86 197.51,22.93 199.8,22.93
+5VS on TOP (solid shape): 45.62,17.26 45.62,12.78 45.37,12.53 44.53,12.53 44.35,12.71 44.35,16.27 44.67,16.59 44.67,17.26 44.8,17.39 45.49,17.39
+5VS on TOP (solid shape): 32.48,44.11 32.48,29.64 32.35,29.52 31.46,29.52 31.15,29.82 31.15,40.55 31.16,40.56 31.16,43.94 31.56,44.35 32.24,44.35
+5VS on TOP (solid shape): 23.49,113.16 23.49,112.11 23.05,111.68 19.15,111.68 18.85,111.98 16.44,111.98 16.28,112.13 15.52,112.13 15.28,111.89 15.28,111.63 14.56,110.91 13.76,110.91 13.73,110.94 13.73,111.59 14.65,112.51 14.65,113.52 14.88,113.75 22.9,113.75
+5VS on TOP (solid shape): 221.87,52.42 221.87,52.03 221.92,51.98 223.24,51.98 223.28,52.02 223.28,52.34 223.27,52.35 223.27,52.48 223.35,52.56 223.64,52.56 224.37,51.82 225.83,51.82 227.61,50.04 227.61,44.26 226.6,43.25 223.93,43.25 220.88,46.29 220.88,52.12 221.31,52.56 221.73,52.56
+5VS on TOP (solid shape): outline of 103 points within 26.45,103.13 45.18,107.04
+5VS on BOTTOM (solid shape): 17.61,112.48 17.61,110.08 17.5,109.98 16.62,109.98 16.41,110.18 16.41,112.38 16.62,112.58 17.51,112.58
+5VS on BOTTOM (solid shape): 47.97,106.22 47.97,104.13 47.65,103.81 44.16,103.81 43.84,104.13 43.84,106.16 44.08,106.4 47.79,106.4
+5VS on BOTTOM (solid shape): 89.5,134.23 89.5,133.38 89.26,133.13 89.26,133.08 89.15,132.97 88.58,132.97 88.29,133.26 88.29,134.23 88.42,134.35 89.37,134.35
+5VS on BOTTOM (solid shape): 222.22,123.69 222.22,120.19 221.58,119.56 221.14,119.56 220.64,119.05 220.54,119.05 220.43,118.94 220.43,118.49 220.43,118.39 220.91,118.39 220.95,118.35 220.95,118.16 220.89,118.1 220.51,118.1 220.51,118.1 220.44,118.1 220.43,118.09 220.37,118.04 220.37,117.59 220.44,117.53 220.95,117.53 220.95,117.4 220.88,117.34 220.44,117.34 220.41,117.31 220.41,117.22 220.41,116.85 220.4,116.83 220.21,116.83 220.14,116.91 220.14,117.24 220.07,117.31 219.3,117.31 219.11,117.5 219.11,120.41 219.12,120.43 219.12,122.94 220.02,123.85 222.06,123.85
+5VS on IN1 (solid shape): 31.24,13.43 31.24,12.63 31,12.39 29.19,12.39 29.02,12.57 29.02,13.47 29.19,13.65 31.02,13.65
+5VS on IN1 (solid shape): 45.71,13.21 45.71,12.4 45.47,12.17 43.66,12.17 43.48,12.34 43.48,13.37 43.54,13.42 45.49,13.42
+5VS on IN1 (solid shape): 222.47,158.48 222.47,156.45 219.99,153.98 219.99,124.5 220.83,123.67 220.83,119.15 220.63,118.95 220.09,118.95 218.09,120.96 218.09,135.27 218.09,135.28 218.09,135.59 218.09,135.6 218.09,139.34 218.09,139.35 218.09,139.65 218.09,139.66 218.09,154.93 220.31,157.15 220.31,158.23 221.07,158.99 221.96,158.99
+5VS on VCC (solid shape): outline of 2293 points within 219.87,19.81 233.88,122.94
+5VS on IN2 (solid shape): 45.34,106 45.34,105.27 45.11,105.04 42.55,105.04 42.3,105.29 42.3,106.01 42.62,106.33 45.01,106.33
+5VS on IN2 (solid shape): 201.01,27.5 201.01,20.13 200.43,19.56 197.39,19.56 197.13,19.81 197.13,27.56 197.83,28.26 200.24,28.26
+5VS on IN2 (solid shape): 227.77,37.79 227.77,34.88 227.44,34.55 224.5,34.55 223.87,35.18 223.87,37.79 224.25,38.17 227.4,38.17
+5VS on IN3 (solid shape): 46.15,13.62 46.15,13.35 45.02,12.22 44.6,12.22 44.27,12.56 44.27,13.19 45.33,14.26 45.52,14.26
+5VS on IN3 (solid shape): 52.86,39.63 52.86,37.8 52.73,37.67 51.83,37.67 51.64,37.86 51.64,39.69 51.71,39.76 52.73,39.76
+5VS on IN3 (solid shape): 201.01,27.5 201.01,20.13 200.43,19.56 197.39,19.56 197.13,19.81 197.13,27.56 197.83,28.26 200.24,28.26
+5VS on IN3 (solid shape): 227.77,37.79 227.77,34.88 227.44,34.55 224.5,34.55 223.87,35.18 223.87,37.79 224.25,38.17 227.4,38.17
+5VS on VCC: outline of 312 points within 21.05,19.81 207.61,116.96
+5VS_KBL on TOP (solid shape): 42.25,114.37 42.25,107.83 41.73,107.31 37.22,107.31 36.99,107.54 36.99,108.48 37.86,109.35 37.86,112.16 37.99,112.29 39.08,112.29 39.88,113.09 39.88,114.42 40.1,114.64 41.98,114.64
+5VS_ODD on BOTTOM (solid shape): 224.72,121.17 224.72,112.98 225.31,112.39 233.32,112.39 233.45,112.27 233.45,111.5 233.26,111.32 230.17,111.32 229.41,110.55 225.34,110.55 224.94,110.95 222.79,110.95 222.53,111.21 222.53,113.91 222.81,114.18 222.81,115.87 222.8,115.87 222.65,116.03 220.92,116.03 220.54,116.41 220.54,117.16 220.57,117.19 221.08,117.19 221.11,117.22 221.11,117.7 221.08,117.73 220.56,117.73 220.55,117.74 220.55,117.96 220.56,117.97 221.03,117.97 221.09,117.97 221.11,117.99 221.11,118.51 221.09,118.53 220.55,118.53 220.55,118.86 220.56,118.87 220.64,118.87 221.19,119.43 222.27,119.43 222.47,119.63 222.47,121.33 222.57,121.43 224.45,121.43
+DVCC33 on TOP (solid shape): 199.29,179.06 199.29,176.36 198.83,175.9 198.83,174.89 198.7,174.75 197.93,174.75 197.77,174.92 197.77,175.23 197.58,175.42 197.58,178.17 198.59,179.19 199.16,179.19
+DVCC33 on TOP (solid shape): 204.28,168.11 204.56,167.96 204.85,168.09 204.86,168.11 204.91,168.11 205.25,167.77 205.33,167.77 205.76,167.61 205.99,168 206.02,168.08 206.1,168.11 207.27,168.11 207.41,167.97 207.41,164.36 207.32,164.26 205.1,164.26 204.94,164.1 204.94,163.55 204.85,163.46 204.21,163.46 204.1,163.57 204.1,164.47 204.36,164.72 204.36,165.28 204.48,165.41 205.56,165.41 206.25,166.1 206.25,166.77 206.21,166.82 204.88,166.82 204.66,167.03 203.56,167.03 203.38,167.2 203.38,167.37 203.39,167.38 203.47,167.55 203.48,167.74 203.48,167.76 203.83,168.11
+DVCC33 on IN3 (solid shape): outline of 604 points within 196.37,165.31 207.8,175.41
+VCC_PWR_SRC on TOP (solid shape): 117.63,145.67 118.22,145.67 118.27,145.62 118.27,144.41 118.01,144.15 116.49,144.15 116.34,144.3 116.34,145.45 116.56,145.67 117.63,145.67
+VCC_PWR_SRC on BOTTOM (solid shape): 137.95,149.72 137.95,144.2 137.51,143.75 126.52,143.75 125.02,145.25 120.63,145.25 120.21,144.83 120.21,143.98 119.58,143.35 118.9,143.35 118.43,142.88 116.57,142.88 116.36,142.67 115.92,142.67 114.89,142.67 114.89,145.73 114.75,145.87 114.09,145.87 114.06,145.9 114.06,146.43 114.11,146.48 116.32,146.48 116.4,146.4 116.4,145.83 116.53,145.7 118.92,145.7 120.57,147.35 122.55,147.35 122.84,147.64 122.84,148.52 125,150.67 137,150.67
+VDD_MEM15_REFDA on IN3 (solid shape): outline of 342 points within 172.82,126.5 181.21,129.48
+VDD_MEM15_REFDB on IN3 (solid shape): outline of 804 points within 183.63,104.83 195.96,122.64
+VDDCI on TOP (solid shape): 196.24,182.16 196.24,180.65 195.92,180.33 192.86,180.33 192.76,180.43 192.76,182.21 192.91,182.36 196.04,182.36
+VDDCI on TOP (solid shape): outline of 892 points within 176.58,109.03 186.28,128.87
+VDDCI on BOTTOM (solid shape): outline of 300 points within 176.19,116.91 186.24,128.04
+VDDCI on IN1 (solid shape): outline of 592 points within 176.62,116.69 186.42,127.81
+VDDCI on VCC (solid shape): outline of 6295 points within 156.75,114.35 195.99,184.84
+VDDCIP on TOP (solid shape): 195.39,189.55 196.94,189.55 197.07,189.42 197.07,183.52 196.75,183.2 193,183.2 192.96,183.23 192.96,183.55 193.64,184.23 193.64,189.23 194.07,189.66 195.28,189.66
+VDDCIP on BOTTOM (solid shape): 196.91,189.26 196.91,183.08 196.57,182.74 194.13,182.74 193.58,183.29 193.58,189.17 193.96,189.55 196.62,189.55
+VDDR4 on TOP (solid shape): 186.55,116.97 186.55,116.96 186.63,116.84 186.75,116.76 186.84,116.73 186.91,116.67 186.91,115.49 186.84,115.42 186.27,115.42 186,115.7 185.07,115.7 184.68,116.09 184.68,117.28 184.85,117.45 186.07,117.45
+VDDR4 on BOTTOM (solid shape): 186.08,117.65 186.09,117.64 186.16,117.47 186.31,117.35 186.32,117.35 186.52,117.15 186.52,117.12 186.57,116.92 186.72,116.77 186.73,116.77 186.75,116.74 186.75,115.64 186.63,115.52 186.23,115.52 185.84,115.92 185.73,115.92 185.71,115.92 185.7,115.93 185.46,116.03 185.23,115.93 185.2,115.92 185.16,115.92 184.63,115.39 183.33,115.39 183.31,115.39 183.3,115.4 183.21,115.47 183.11,115.5 183.11,115.51 183.11,115.76 183.12,115.78 183.13,115.8 183.15,115.82 183.16,115.82 183.49,116.2 183.16,116.58 183.13,116.6 183.11,116.63 183.11,116.83 183.13,116.85 183.14,116.86 183.26,116.96 183.34,117.09 183.35,117.12 183.38,117.13 183.62,117.13 183.63,117.12 183.63,117.09 183.99,116.83 184.34,117.1 184.34,117.12 184.56,117.33 184.57,117.34 184.73,117.43 184.83,117.59 184.83,117.6 185.09,117.86 185.11,117.87 185.2,117.91 185.28,117.96 185.77,117.96
GND on TOP (solid shape): 44.8,75.89 44.8,74.49 44.67,74.36 43.02,74.36 42.95,74.42 42.95,76.01 43.08,76.14 44.54,76.14
GND on TOP (solid shape): 99.79,138.48 99.79,136.7 99.66,136.58 98.39,136.58 98.26,136.7 98.26,138.48 98.39,138.61 99.66,138.61
GND on TOP (solid shape): 103.15,140.77 103.15,136.83 102.9,136.58 101.82,136.58 101.63,136.77 101.63,140.83 101.69,140.9 103.03,140.9
GND on TOP (solid shape): 104.35,67.96 104.35,64.6 104.25,64.5 102.8,64.5 102.22,65.08 102.22,68 102.45,68.23 104.08,68.23
GND on TOP (solid shape): 106.45,140.64 106.45,136.77 106.26,136.58 105.12,136.58 104.93,136.77 104.93,140.77 105.06,140.9 106.2,140.9
GND on TOP (solid shape): 109.82,140.64 109.82,136.83 109.63,136.64 108.49,136.64 108.3,136.83 108.3,140.51 108.61,140.83 109.63,140.83
GND on TOP (solid shape): 113.19,140.64 113.19,136.89 112.93,136.64 111.85,136.64 111.66,136.83 111.66,140.7 111.73,140.77 113.06,140.77
GND on TOP (solid shape): 118.9,147.07 118.9,145.99 118.77,145.86 116.36,145.86 116.23,145.99 116.23,147.45 116.3,147.51 118.46,147.51
GND on TOP (solid shape): 130.3,178.77 130.3,176.7 130.1,176.5 129.44,176.5 129.33,176.6 129.33,178.85 129.44,178.96 130.11,178.96
GND on TOP (solid shape): 149.44,185.73 149.44,181.15 149.19,180.9 147.98,180.9 147.79,181.09 147.79,185.79 147.86,185.85 149.32,185.85
GND on TOP (solid shape): 158.55,160.89 158.55,158.17 158.2,157.82 155.53,157.82 155.21,158.14 155.21,160.81 155.48,161.07 158.37,161.07
GND on TOP (solid shape): 159.99,191.46 159.99,189.36 159.67,189.04 153.57,189.04 153,189.61 153,191.52 153.25,191.77 159.67,191.77
GND on TOP (solid shape): 161.38,85.02 161.38,80.57 160.94,80.13 157.95,80.13 157.76,80.32 157.76,85.08 158.02,85.33 161.06,85.33
GND on TOP (solid shape): 187.48,20.2 187.48,18.61 187.1,18.23 186.21,18.23 186.08,18.35 186.08,20.32 186.21,20.45 187.23,20.45
GND on TOP (solid shape): 201.83,22.61 201.83,17.85 201.32,17.34 200.5,17.34 200.24,17.59 200.24,22.61 200.43,22.8 201.64,22.8
GND on TOP (solid shape): 220.69,100.83 220.69,97.78 220.37,97.46 219.23,97.46 219.14,97.56 219.14,100.92 219.17,100.95 220.56,100.95
GND on TOP (solid shape): 31.86,64.98 31.86,59.45 31.44,59.03 30.21,59.03 30.09,59.16 30.09,64.94 30.26,65.12 31.72,65.12
GND on TOP (solid shape): 144.21,32.35 144.21,30.58 144.52,30.26 144.52,28.87 144.27,28.62 143.32,28.62 143.01,28.94 143.01,32.61 143.21,32.82 143.73,32.82
GND on TOP (solid shape): 158.84,136.44 158.84,128.32 158.78,128.25 158.08,128.25 156.49,129.84 153.7,129.84 153.25,130.28 153.25,135.74 154.08,136.57 158.71,136.57
GND on TOP (solid shape): 198.63,93.77 198.63,92.21 198.43,92.01 192.42,92.01 192.31,92.12 192.31,92.98 192.4,93.07 192.73,93.07 193.71,94.05 198.35,94.05
GND on TOP (solid shape): 199.86,74.03 199.86,72.14 199.62,71.89 193.18,71.89 192.75,72.32 192.75,73.9 192.94,74.09 199.8,74.09
GND on TOP (solid shape): 26.29,34.23 26.29,32.02 26.08,31.82 23.66,31.82 23.6,31.87 23.6,32.56 23.35,32.81 23.35,34.27 23.64,34.56 25.96,34.56
GND on TOP (solid shape): 148.11,147.44 148.11,145.78 147.92,145.59 140.36,145.59 140.11,145.85 140.11,147.25 140.3,147.44 140.81,147.44 141.19,147.82 147.73,147.82
GND on TOP (solid shape): 149.44,178.49 149.44,175.95 149,175.5 147.22,175.5 147.16,175.57 147.16,178.68 147.29,178.8 149.13,178.8
GND on TOP (solid shape): 145.06,26.74 145.06,22.55 144.87,22.35 143.86,22.35 143.73,22.48 143.73,25.91 143.41,26.23 140.68,26.23 140.43,26.48 140.43,26.93 140.62,27.12 144.68,27.12
GND on TOP (solid shape): 161.03,179.11 161.51,179.11 161.89,178.73 161.89,178.33 161.74,178.18 159.11,178.18 158.97,178.31 158.97,179.82 159.16,180.01 160.13,180.01
GND on TOP (solid shape): 210.62,83.27 210.62,80.18 210.4,79.97 198.18,79.97 197.01,81.14 193.7,81.14 193.51,81.33 193.51,82.48 193.89,82.86 194.78,82.86 195.74,83.81 210.09,83.81
GND on TOP (solid shape): 104.74,76.06 104.74,72.51 104.69,72.46 104.06,72.46 103.98,72.54 103.98,73.14 103.72,73.39 103.19,73.39 103.18,73.39 102.32,73.39 102.27,73.44 102.27,76.64 102.39,76.76 104.04,76.76
GND on TOP (solid shape): 167.67,174.3 167.67,173.98 167.61,173.92 167.61,172.71 167.54,172.65 167.41,172.65 167.35,172.71 167.35,173.79 167.16,173.98 167.16,174.04 166.84,174.36 166.84,174.68 166.97,174.8 167.16,174.8
GND on TOP (solid shape): 174.99,160.57 174.99,159.28 174.82,159.11 171.52,159.11 171.17,158.77 161.93,158.77 161.87,158.83 161.87,159.52 161.97,159.61 162.23,159.61 162.55,159.93 162.55,161.3 163.08,161.84 173.73,161.84
GND on TOP (solid shape): 182.44,160.67 182.44,159.96 182.34,159.86 181.44,159.86 181.08,159.5 181.08,159.17 180.8,158.9 177.76,158.9 177.61,159.05 177.61,160.04 177.98,160.41 180.36,160.41 180.75,160.79 182.32,160.79
GND on TOP (solid shape): 182.89,66.94 182.89,65.84 182.98,65.74 182.98,63.79 182.68,63.48 181.08,63.48 180.88,63.68 180.88,65.9 181.27,66.29 181.79,66.29 181.99,66.5 181.99,66.99 182.06,67.05 182.78,67.05
GND on TOP (solid shape): 187.43,160.16 193.67,160.16 193.95,160.44 198.08,160.44 198.25,160.28 198.25,159.6 197.87,159.21 193.64,159.21 193.29,158.86 183.02,158.86 182.85,159.02 182.85,161.06 183.03,161.24 186.35,161.24
GND on TOP (solid shape): 189.96,21.53 189.96,19.8 189.96,19.75 190.53,19.18 190.53,18.04 189.89,17.4 189.32,17.4 189.26,17.47 189.26,19.37 188.62,20.01 188.62,21.97 188.81,22.16 189.32,22.16
GND on TOP (solid shape): 91.47,141.21 91.47,138.23 91.21,137.97 88.48,137.97 88.17,137.66 88.17,137.15 88.1,137.09 87.6,137.09 87.47,137.21 87.47,140.26 87.15,140.58 85.5,140.58 85.37,140.7 85.37,141.15 85.56,141.34 91.34,141.34
GND on TOP (solid shape): 183.04,76.95 183.04,73.17 182.97,73.11 182.43,73.11 182.34,73.2 182.34,74.66 182.15,74.86 182.07,74.86 180.51,74.86 180.5,74.86 180.31,74.66 179.86,74.66 179.67,74.86 179.67,77.08 179.8,77.2 182.78,77.2
GND on TOP (solid shape): 162.27,176.39 162.27,173.85 161.76,173.34 161.76,168.77 162.08,168.45 162.78,168.45 162.97,168.26 162.97,164.2 162.46,163.69 159.41,163.69 158.65,164.45 158.65,171.76 158.91,172.01 158.91,175.82 159.22,176.14 160.24,176.14 160.56,176.46 162.21,176.46
GND on TOP (solid shape): 130.91,168.63 130.91,167.82 131.05,167.67 131.05,166.15 130.92,166.02 129.86,166.02 129.74,165.9 129.74,165.55 129.59,165.4 128.3,165.4 128.12,165.58 128.12,165.81 127.93,166 127.42,166 127.18,166.24 127.18,166.82 127.22,166.86 127.83,166.86 128.17,167.2 128.76,167.2 129.08,167.51 129.08,168.43 129.37,168.72 130.81,168.72
GND on TOP (solid shape): 221.77,133.66 221.77,128.57 220.97,127.77 220.97,122.86 220.59,122.48 220.06,122.48 219.75,122.17 219.75,121.01 219.61,120.88 219.17,120.88 219.05,121 219.05,122.67 219.39,123.02 219.39,127.94 219.47,128.02 219.9,128.02 219.92,128.04 220.01,128.04 220.17,128.21 220.17,129.6 219.58,130.2 219.58,135.17 219.74,135.32 220.11,135.32
GND on TOP (solid shape): 12.35,58.11 12.35,55.44 11.9,54.99 10.19,54.99 10.13,55 10.07,55 0.3,55 0.27,55.02 0.25,55.05 0.25,58.55 0.27,58.58 0.3,58.6 10.07,58.6 10.13,58.6 10.19,58.61 11.85,58.61
GND on TOP (solid shape): 196.98,190.67 196.98,189.84 196.85,189.71 195.41,189.71 195.32,189.81 193.71,189.81 193.51,189.61 193.51,184.55 192.59,183.63 192.59,182.45 192.26,182.13 189.85,182.13 189.55,182.43 189.55,183.27 190.31,184.03 190.31,189.14 190.08,189.36 189.7,189.36 189.58,189.49 189.58,190.44 189.86,190.73 196.93,190.73
GND on TOP (solid shape): 182.2,177.29 183.76,177.29 184.18,176.88 184.18,176.88 184.18,176.14 184.05,176.01 183.23,176.01 182.97,175.76 182.97,174.49 181.77,173.28 181.77,172.77 181.7,172.71 181.19,172.71 181,172.9 181,174.55 180.75,174.8 179.42,174.8 179.16,175.06 179.16,176.46 179.35,176.65 179.92,176.65 180.05,176.77 180.05,178.23 180.15,178.33 181.16,178.33
GND on TOP (solid shape): 207.05,60.18 207.05,56.89 206.98,56.82 202.47,56.82 201.96,56.31 201.26,56.31 201.2,56.38 201.2,57.01 201.13,57.08 200.56,57.08 200.43,57.2 200.43,57.77 200.5,57.84 201.9,57.84 202.09,57.65 202.53,57.65 202.79,57.91 202.79,58.49 203.04,58.74 203.99,58.74 204.24,58.99 204.24,60 204.58,60.34 206.89,60.34
GND on TOP (solid shape): 12.35,24.77 12.35,23.24 10.76,21.66 0.25,21.66 0.25,23.3 0.27,23.34 0.3,23.35 7.12,23.35 7.85,23.96 7.4,24.8 7.38,24.82 7.37,24.85 7.37,25.34 11.78,25.34
GND on TOP (solid shape): 11.78,97.22 11.78,94.17 12.25,93.7 12.5,93.7 13.24,93.46 13.7,92.82 13.15,92.82 12.87,93.1 12.5,93.19 0.3,93.19 0.27,93.21 0.25,93.24 0.25,97.6 0.27,97.63 0.3,97.65 11.35,97.65
GND on TOP (solid shape): 13.73,76.9 13.5,76.39 13.07,76.03 12.54,75.5 12.54,73.03 11.52,72.01 10.81,72.01 10.54,72.44 10.07,72.6 0.3,72.6 0.27,72.62 0.25,72.65 0.25,76.36 0.27,76.39 0.3,76.41 12.5,76.41 12.93,76.54 13.21,76.9
GND on TOP (solid shape): 12.41,40.52 12.41,37.15 11.27,36.01 8.17,36.01 8.06,35.87 7.94,35.75 7.37,35.75 7.37,35.96 7.38,35.99 7.4,36.01 7.85,36.85 7.12,37.46 0.3,37.46 0.27,37.47 0.25,37.51 0.25,40.95 0.27,40.98 0.3,41 10.07,41 10.15,41 10.23,41.01 11.91,41.01
GND on TOP (solid shape): 116.81,143.63 116.81,140.9 116.36,140.45 114.27,140.45 113.73,140.99 115.05,140.99 115.05,140.93 115.06,140.88 115.08,140.83 115.1,140.78 115.13,140.74 115.17,140.7 115.21,140.66 115.25,140.64 115.3,140.62 115.36,140.61 115.41,140.6 115.46,140.61 115.51,140.62 115.56,140.64 115.61,140.66 115.65,140.7 115.69,140.74 115.72,140.78 115.74,140.83 115.76,140.88 115.76,140.93 115.76,140.99 115.76,141.04 115.74,141.09 115.72,141.14 115.69,141.18 115.65,141.22 115.61,141.25 115.56,141.28 115.51,141.3 115.46,141.31 115.41,141.32 115.36,141.31 115.3,141.3 115.25,141.28 115.21,141.25 115.17,141.22 115.13,141.18 115.1,141.14 115.08,141.09 115.06,141.04 115.05,140.99 113.73,140.99 113.38,141.34 112.74,141.34 112.36,141.72 112.36,143.24 112.04,143.56 110.65,143.56 110.58,143.63 110.58,146.04 110.71,146.17 111.92,146.17 112.55,146.8 113.63,146.8
GND on TOP (solid shape): outline of 83 points within 214.02,65.16 218.12,76.8
GND on TOP (solid shape): outline of 87 points within 216.12,101.89 221.18,118.92
GND on TOP (solid shape): outline of 101 points within 137.57,149.85 146.71,161.53
GND on TOP (solid shape): outline of 265 points within 112.98,95.72 114.63,104.61
GND on TOP (solid shape): outline of 493 points within 115.98,59.63 237.15,192.85
GND on TOP (solid shape): outline of 477 points within 63.47,74.53 91.02,111.83
GND on TOP (solid shape): outline of 600 points within 55.08,73.79 71.28,107.64
GND on TOP (solid shape): outline of 619 points within 0.25,106.97 91.34,161.55
GND on TOP (solid shape): outline of 886 points within 16.22,0.25 230.15,48.2
GND on BOTTOM (solid shape): 28.48,59.44 28.48,57.34 27.78,56.64 25.87,56.64 25.49,57.03 25.49,59.63 25.94,60.07 27.84,60.07
GND on BOTTOM (solid shape): 109.82,136.45 109.82,134.62 109.69,134.5 108.8,134.5 108.74,134.56 108.74,136.64 109.63,136.64
GND on BOTTOM (solid shape): 111.29,26 111.29,24.82 111.24,24.77 109.9,24.77 109.84,24.82 109.84,26.03 110.06,26.24 111.05,26.24
GND on BOTTOM (solid shape): 113.14,28.81 113.14,27.68 113.04,27.58 111.63,27.58 111.48,27.72 111.48,28.97 111.53,29.02 112.92,29.02
GND on BOTTOM (solid shape): 131.03,168.52 131.03,166.04 130.71,165.72 127.92,165.72 127.79,165.85 127.79,168.77 127.92,168.9 130.65,168.9
GND on BOTTOM (solid shape): 143.74,160.95 143.74,159.94 142.21,159.94 142.21,161.02 142.34,161.14 143.54,161.14
GND on BOTTOM (solid shape): 153.71,25.59 153.71,21.91 153.26,21.46 150.4,21.46 150.09,21.78 150.09,25.59 150.59,26.1 153.2,26.1
GND on BOTTOM (solid shape): 155.61,28.32 155.61,27.19 155.41,26.99 154.28,26.99 154.15,27.12 154.15,28.32 154.34,28.51 155.42,28.51
GND on BOTTOM (solid shape): 159.99,191.46 159.99,190.12 158.91,189.04 153.57,189.04 153,189.61 153,191.52 153.25,191.77 159.67,191.77
GND on BOTTOM (solid shape): 199.74,81.46 199.74,79.36 199.55,79.17 191.8,79.17 191.67,79.3 191.67,82.16 191.99,82.48 198.72,82.48
GND on BOTTOM (solid shape): 29.44,74.72 29.44,71.02 29.1,70.68 24.77,70.68 24.45,71 24.45,74.59 24.81,74.95 29.21,74.95
GND on BOTTOM (solid shape): 103.18,136.39 103.18,134.62 102.99,134.43 101.76,134.43 101.7,134.5 101.7,135.14 102.01,135.45 102.01,136.64 102.93,136.64
GND on BOTTOM (solid shape): 106.49,136.42 106.49,134.69 106.36,134.56 105.13,134.56 105,134.69 105,135.14 105.38,135.51 105.38,136.64 106.26,136.64
GND on BOTTOM (solid shape): 187.61,176.02 187.61,172.9 187.42,172.71 186.27,172.71 186.08,172.9 186.08,175.86 186.38,176.15 187.48,176.15
GND on BOTTOM (solid shape): 27.97,41.33 27.97,39.1 27.27,38.41 24.48,38.41 23.97,38.91 23.97,41.96 24.22,42.22 27.08,42.22
GND on BOTTOM (solid shape): 42.32,26.6 42.32,22.66 41.81,22.15 38.89,22.15 38.7,22.34 38.7,23.04 37.24,24.5 37.24,26.53 37.62,26.91 42,26.91
GND on BOTTOM (solid shape): 99.82,136.42 99.82,134.81 99.57,134.56 98.52,134.56 98.33,134.75 98.33,135.14 98.64,135.45 98.64,136.64 98.71,136.7 99.53,136.7
GND on BOTTOM (solid shape): 113.12,136.45 113.12,134.81 112.93,134.62 111.92,134.62 111.79,134.75 111.79,135.19 112.11,135.51 112.11,136.58 112.17,136.64 112.93,136.64
GND on BOTTOM (solid shape): 174.13,159.95 174.13,159.45 173.79,159.11 171.96,159.11 171.61,158.77 162.42,158.77 162.25,158.94 162.25,160.07 162.84,160.67 173.41,160.67
GND on BOTTOM (solid shape): 189.96,170.74 189.96,168.64 189.64,168.33 186.97,168.33 186.46,168.84 186.46,170.74 186.97,171.25 189.45,171.25
GND on BOTTOM (solid shape): 208.63,15.31 208.63,12.64 208.31,12.32 205.45,12.32 204.94,12.83 204.94,15.37 205.45,15.88 208.05,15.88
GND on BOTTOM (solid shape): 209.26,28.01 209.26,25.4 208.44,24.58 205.51,24.58 205.13,24.96 205.13,27.69 205.77,28.32 208.94,28.32
GND on BOTTOM (solid shape): 220.25,41.15 220.25,40.26 219.04,39.06 218.23,39.06 218.04,39.25 218.04,41.41 218.21,41.57 219.82,41.57
GND on BOTTOM (solid shape): 158.21,25.71 158.21,24.7 158.34,24.58 158.34,23.69 158.21,23.56 157.96,23.56 157.83,23.69 157.83,24.58 158.02,24.77 158.02,25.71 158.08,25.77 158.15,25.77
GND on BOTTOM (solid shape): 158.27,110.47 158.27,110.29 157.98,110 157.98,107.16 157.91,107.09 157.22,107.09 156.11,108.2 156.11,110.54 156.22,110.65 158.09,110.65
GND on BOTTOM (solid shape): 176.79,185.79 176.79,182.85 175.33,181.39 173.98,181.39 173.91,181.47 173.91,182.79 174.03,182.92 175.42,182.92 175.65,183.14 175.65,185.84 175.72,185.92 176.66,185.92
GND on BOTTOM (solid shape): 183.29,176.85 183.29,173.99 182.97,173.68 181.32,173.68 181.19,173.8 181.19,174.95 180.79,175.34 179.89,175.34 179.8,175.44 179.8,177.04 179.92,177.17 182.97,177.17
GND on BOTTOM (solid shape): 189.86,160.3 193.03,160.3 193.4,159.93 194.85,159.93 195.2,159.58 195.2,158.88 195.01,158.7 185.03,158.7 183.96,159.76 183.96,160.52 184.14,160.69 189.46,160.69
GND on BOTTOM (solid shape): 137.95,141.59 137.95,139.18 137.13,138.36 129.31,138.36 128.69,137.73 128.69,135.83 128.57,135.7 127.19,135.7 127,135.89 127,140.91 128.57,142.48 137.06,142.48
GND on BOTTOM (solid shape): 159,31.28 159,29.94 158.85,29.78 158.4,29.78 157.83,29.21 157.83,27.94 157.77,27.88 157.64,27.88 157.58,27.94 157.58,30.04 157.52,30.1 157.52,31.18 157.64,31.31 158.98,31.31
GND on BOTTOM (solid shape): 222.55,115.8 222.55,114.23 222.34,114.02 222.34,109.78 221.19,108.63 219.02,108.63 218.84,108.81 218.84,115.43 219.27,115.86 222.49,115.86
GND on BOTTOM (solid shape): 137.43,98.48 137.43,96.84 137.25,96.65 133.17,96.65 132.81,97.02 132.81,97.78 133,97.97 133.57,97.97 133.76,98.16 133.76,98.67 133.82,98.73 137.18,98.73
GND on BOTTOM (solid shape): 161.39,22.29 161.39,21.08 161.13,20.83 159.1,20.83 159.04,20.89 159.04,21.34 159.17,21.46 159.17,22.04 159.23,22.1 159.23,22.42 161.26,22.42
GND on BOTTOM (solid shape): 196.43,66.41 196.43,65.46 196.12,65.14 193.45,65.14 193.2,64.89 193.2,63.93 193.7,63.43 193.7,62.09 193.58,61.96 192.88,61.96 192.75,62.09 192.12,62.09 191.86,62.35 191.86,66.47 192.24,66.85 195.99,66.85
GND on BOTTOM (solid shape): 158.59,28.83 158.59,27.88 158.72,27.75 159.36,27.75 159.36,26.04 157.64,26.04 157.64,27.75 158.34,27.75 158.4,27.81 158.4,28.83 158.47,28.89 158.53,28.89
GND on BOTTOM (solid shape): 188.12,178.5 188.12,177.29 188.24,177.17 190.08,177.17 190.15,177.1 190.15,176.6 189.96,176.41 184.18,176.41 183.99,176.6 183.99,177.42 184.05,177.49 186.21,177.49 186.53,177.8 186.53,178.76 186.59,178.82 187.8,178.82
GND on BOTTOM (solid shape): 220.04,143.46 220.78,143.46 220.94,143.3 220.94,141.7 220.45,141.2 220.45,138.33 222.52,136.25 222.52,128.82 222.24,128.54 220.36,128.54 219.82,129.08 219.82,129.71 219.73,129.8 219.19,129.8 219.1,129.88 219.1,143.62 219.2,143.72 219.78,143.72
GND on BOTTOM (solid shape): 221.02,128.15 221.02,127.97 220.62,127.57 220.62,126.97 220.99,126.6 220.99,124.85 220.69,124.55 219.14,124.55 219.06,124.63 219.06,127.74 219.21,127.88 219.7,127.88 219.7,127.88 220.1,128.28 220.89,128.28
GND on BOTTOM (solid shape): 124.52,139.84 124.52,136.71 124.26,136.46 124.26,134.71 124.18,134.62 122.14,134.62 121.69,135.07 121.69,137.35 121.82,137.48 122.57,137.48 122.95,137.86 122.95,139.74 123.12,139.91 124.45,139.91
GND on BOTTOM (solid shape): 182.42,160.61 182.42,160.16 181.89,159.63 181.89,158.87 181.77,158.75 179.78,158.75 179.55,158.98 177.69,158.98 177.59,159.09 177.59,159.59 177.68,159.68 178.19,159.68 178.34,159.84 178.34,160.46 178.4,160.52 180.49,160.52 180.81,160.84 182.19,160.84
GND on BOTTOM (solid shape): 162.33,178.04 162.33,173.92 161.76,173.34 161.76,168.77 162.08,168.45 163.41,168.45 163.67,168.2 163.67,164.14 163.29,163.76 160.37,163.76 159.16,164.96 159.16,167.44 158.91,167.69 158.91,176.65 160.87,178.61 161.76,178.61
GND on BOTTOM (solid shape): 41.61,85.59 41.82,85.59 44.16,85.59 44.22,85.52 44.22,84.89 44.16,84.83 43.47,84.83 43.41,84.76 43.34,84.76 43.21,84.63 43.21,82.86 43.02,82.67 42.07,82.67 41.94,82.79 41.94,84.7 41.88,84.76 40.58,84.76 40.39,84.95 40.39,85.91 40.52,86.04 41.16,86.04
GND on BOTTOM (solid shape): 108.89,18.9 108.89,17.1 108.8,17.01 107.51,17.01 107.37,16.88 107.37,16.02 107.28,15.92 104.61,15.92 104.45,16.09 104.45,17.29 104.5,17.33 105.8,17.33 105.91,17.45 105.91,18.3 105.93,18.32 106.76,18.32 107.2,17.87 108.57,17.87 108.62,17.92 108.62,18.88 108.68,18.95 108.84,18.95
GND on BOTTOM (solid shape): 162.4,16.99 162.4,16.5 162.47,16.44 164.05,16.44 164.56,15.93 164.56,11.93 164.49,11.86 163.35,11.86 163.16,12.05 163.16,13.7 162.84,14.02 158.14,14.02 157.83,14.34 157.83,14.78 157.64,14.97 156.62,14.97 156.56,15.04 156.56,16.88 156.81,17.13 162.27,17.13
GND on BOTTOM (solid shape): 145.04,155.11 144.79,155.11 144.79,156.38 143.16,156.38 143.16,155.11 141.08,153.02 140.17,153.02 139.73,153.47 138.9,153.47 138.78,153.6 138.78,154.85 138.78,154.86 138.78,156.27 139.03,156.52 142.06,156.52 142.59,157.04 145.04,157.04
GND on BOTTOM (solid shape): 217.99,94.87 217.99,93.97 218.24,93.71 220.12,93.71 220.18,93.65 220.18,92.95 220.06,92.83 218.79,92.83 218.72,92.76 218.72,91.81 218.66,91.75 218.47,91.75 218.28,91.94 218.28,92.25 217.43,93.1 215.89,93.1 215.81,93.17 215.81,94.02 215.96,94.17 217.07,94.17 217.17,94.27 217.17,94.91 217.26,95.01 217.85,95.01
GND on BOTTOM (solid shape): 12.35,58.11 12.35,55.44 11.9,54.99 10.19,54.99 10.13,55 10.07,55 0.3,55 0.27,55.02 0.25,55.05 0.25,58.55 0.27,58.58 0.3,58.6 10.07,58.6 10.13,58.6 10.19,58.61 11.85,58.61
GND on BOTTOM (solid shape): 195.55,190.5 195.55,189.87 195.48,189.8 193.89,189.8 192.98,188.89 192.98,181.83 192.78,181.63 192.23,181.63 191.8,182.06 190.14,182.06 189.88,181.8 189.88,180.97 189.79,180.88 187.42,180.88 187.36,180.94 187.36,181.46 187.44,181.54 187.92,181.54 187.92,181.54 189.03,181.54 189.2,181.71 189.2,183.58 191.04,185.42 191.04,190.12 191.74,190.82 195.23,190.82
GND on BOTTOM (solid shape): 118.95,146.79 118.95,146 118.8,145.85 116.68,145.85 116.54,145.99 116.54,146.64 116.5,146.67 114.03,146.67 113.91,146.56 113.91,145.82 114,145.74 114.63,145.74 114.75,145.62 114.75,145.28 114.76,145.26 114.76,141.2 114.71,141.15 112.66,141.15 112.55,141.26 112.55,145.08 112.42,145.2 112.42,146.67 113.1,147.35 118.39,147.35
GND on BOTTOM (solid shape): 217.83,75.3 217.83,63.43 217.26,62.85 215.17,62.85 214.91,63.11 214.91,64.76 215.04,64.89 215.42,64.89 215.67,65.14 215.67,66.35 215.48,66.54 213.64,66.54 213.33,66.85 213.33,69.71 213.64,70.03 214.72,70.03 214.91,70.22 214.91,70.85 215.17,71.11 215.61,71.11 215.8,71.3 215.8,72.32 215.55,72.57 214.85,72.57 214.6,72.32 213.58,72.32 213.33,72.57 213.33,75.49 214.16,76.32 216.81,76.32
GND on BOTTOM (solid shape): 215.8,24.39 215.8,22.8 215.48,22.48 215.48,19.12 215.67,18.93 215.67,18.23 215.48,18.04 214.98,18.04 214.79,17.85 214.79,16.96 214.66,16.83 212.88,16.83 212.69,17.02 212.69,17.78 212.44,18.04 211.74,18.04 211.55,18.23 211.55,19.37 211.99,19.81 211.99,22.23 211.74,22.48 211.23,22.48 211.17,22.55 211.17,23.43 211.36,23.62 213.16,23.62 213.17,23.62 213.29,23.6 213.41,23.62 213.42,23.62 213.52,23.62 213.71,23.82 213.71,24.64 213.83,24.77 215.42,24.77
GND on BOTTOM (solid shape): 109.44,98.3 109.44,96.06 108.43,95.06 99.47,95.06 98.89,94.48 97.76,94.48 97.63,94.6 97.63,95.94 97.76,96.06 98.36,96.06 98.68,96.38 98.72,96.4 98.75,96.38 99.18,96.48 98.89,96.81 98.81,96.81 98.81,97.93 99.2,98.32 109.41,98.32
GND on BOTTOM (solid shape): 12.35,24.77 12.35,23.24 10.76,21.66 0.25,21.66 0.25,23.3 0.27,23.34 0.3,23.35 7.12,23.35 7.85,23.96 7.4,24.8 7.38,24.82 7.37,24.85 7.37,25.34 11.78,25.34
GND on BOTTOM (solid shape): 11.78,97.22 11.78,94.17 12.25,93.7 12.5,93.7 13.24,93.46 13.7,92.82 13.15,92.82 12.87,93.1 12.5,93.19 0.3,93.19 0.27,93.21 0.25,93.24 0.25,97.6 0.27,97.63 0.3,97.65 11.35,97.65
GND on BOTTOM (solid shape): 13.73,76.9 13.5,76.39 13.07,76.03 12.54,75.5 12.54,73.03 11.52,72.01 10.81,72.01 10.54,72.44 10.07,72.6 0.3,72.6 0.27,72.62 0.25,72.65 0.25,76.36 0.27,76.39 0.3,76.41 12.5,76.41 12.93,76.54 13.21,76.9
GND on BOTTOM (solid shape): 12.41,40.52 12.41,37.15 11.27,36.01 8.17,36.01 8.06,35.87 7.94,35.75 7.37,35.75 7.37,35.96 7.38,35.99 7.4,36.01 7.85,36.85 7.12,37.46 0.3,37.46 0.27,37.47 0.25,37.51 0.25,40.95 0.27,40.98 0.3,41 10.07,41 10.15,41 10.23,41.01 11.91,41.01
GND on BOTTOM (solid shape): outline of 147 points within 115.09,10.8 137.57,38.74
GND on BOTTOM (solid shape): outline of 184 points within 165.76,0.38 230.09,21.4
GND on BOTTOM (solid shape): outline of 92 points within 16.22,0.25 230.15,26.04
GND on BOTTOM (solid shape): outline of 141 points within 115.98,64.52 237.15,192.85
GND on BOTTOM (solid shape): outline of 90 points within 0.25,113.66 91.34,161.55
GND on BOTTOM (solid shape): outline of 446 points within 95.31,124.74 117.08,127.43
GND on IN1 (solid shape): 114.65,146.23 114.65,141.66 114.46,141.47 112.42,141.47 112.04,141.85 112.04,146.36 112.68,146.99 113.88,146.99
GND on IN1 (solid shape): 159.99,191.46 159.99,189.36 159.67,189.04 153.57,189.04 153,189.61 153,191.52 153.25,191.77 159.67,191.77
GND on IN1 (solid shape): 163.73,169.22 163.73,164.14 163.41,163.82 159.29,163.82 158.84,164.26 158.84,168.96 159.48,169.6 163.35,169.6
GND on IN1 (solid shape): 218.21,77.97 218.21,63.93 217.2,62.92 214.91,62.92 214.53,63.3 214.53,64.7 214.91,65.08 215.67,65.08 215.8,65.2 215.8,66.54 215.61,66.73 214.66,66.73 214.47,66.92 214.47,70.98 214.6,71.11 215.61,71.11 215.8,71.3 215.8,72.38 215.61,72.57 214.66,72.57 214.4,72.82 214.4,78.35 214.66,78.6 217.58,78.6
GND on IN1 (solid shape): 12.35,58.11 12.35,55.44 11.9,54.99 10.19,54.99 10.13,55 10.07,55 0.3,55 0.27,55.02 0.25,55.05 0.25,58.55 0.27,58.58 0.3,58.6 10.07,58.6 10.13,58.6 10.19,58.61 11.85,58.61
GND on IN1 (solid shape): 12.35,24.77 12.35,23.24 10.76,21.66 0.25,21.66 0.25,23.3 0.27,23.34 0.3,23.35 7.12,23.35 7.85,23.96 7.4,24.8 7.38,24.82 7.37,24.85 7.37,25.34 11.78,25.34
GND on IN1 (solid shape): 11.78,97.22 11.78,94.17 12.25,93.7 12.5,93.7 13.24,93.46 13.7,92.82 13.15,92.82 12.87,93.1 12.5,93.19 0.3,93.19 0.27,93.21 0.25,93.24 0.25,97.6 0.27,97.63 0.3,97.65 11.35,97.65
GND on IN1 (solid shape): 13.73,76.9 13.5,76.39 13.07,76.03 12.54,75.5 12.54,73.03 11.52,72.01 10.81,72.01 10.54,72.44 10.07,72.6 0.3,72.6 0.27,72.62 0.25,72.65 0.25,76.36 0.27,76.39 0.3,76.41 12.5,76.41 12.93,76.54 13.21,76.9
GND on IN1 (solid shape): 12.41,40.52 12.41,37.15 11.27,36.01 8.17,36.01 8.07,35.88 7.96,35.76 7.37,35.76 7.37,35.96 7.38,35.99 7.4,36.01 7.85,36.85 7.12,37.46 0.3,37.46 0.27,37.47 0.25,37.51 0.25,40.95 0.27,40.98 0.3,41 10.07,41 10.15,41 10.23,41.01 11.91,41.01
GND on IN1 (solid shape): 145.32,161.09 145.32,156.77 143.79,155.25 143.79,154.84 143.79,154.82 143.79,154.77 143.79,154.72 143.79,154.61 143.85,154.55 143.87,154.52 143.92,154.47 143.95,154.45 144.05,154.36 145.76,154.36 146.71,153.4 146.71,150.42 146.14,149.85 141.89,149.85 137.57,154.17 137.57,160.35 144.14,160.35 144.14,160.3 144.14,160.25 144.16,160.2 144.18,160.15 144.21,160.1 144.25,160.06 144.29,160.03 144.34,160 144.39,159.99 144.44,159.97 144.49,159.97 144.54,159.97 144.6,159.99 144.65,160 144.69,160.03 144.73,160.06 144.77,160.1 144.8,160.15 144.82,160.2 144.84,160.25 144.85,160.3 144.85,160.35 144.84,160.41 144.82,160.46 144.8,160.5 144.77,160.55 144.73,160.59 144.69,160.62 144.65,160.65 144.6,160.67 144.54,160.68 144.49,160.68 144.44,160.68 144.39,160.67 144.34,160.65 144.29,160.62 144.25,160.59 144.21,160.55 144.18,160.5 144.16,160.46 144.14,160.41 144.14,160.35 137.57,160.35 137.57,161.22 137.89,161.53 144.87,161.53
GND on IN1 (solid shape): outline of 378 points within 16.22,0.25 230.15,26.04
GND on IN1 (solid shape): outline of 149 points within 115.98,64.52 237.15,192.85
GND on IN1 (solid shape): 88.62,161.55 88.66,161.53 88.67,161.5 88.67,155.52 89.19,154.28 90.43,153.77 91.34,153.77 91.34,153.26 90.43,153.26 88.83,153.92 88.17,155.52 88.17,156.72 88.29,156.85 88.29,158.05 88.17,158.18 88.17,158.56 87.91,158.82 86.2,158.82 85.75,158.36 85.03,152 83.25,145.86 83.24,145.72 83.31,145.59 83.83,144.66 83.72,143.59 82.05,140.26 80.07,137.09 79.44,136.54 78.62,136.34 78.02,136.34 77.91,136.31 77.83,136.25 64.61,125.49 48,121.64 41.94,121.64 39.3,119 28.03,119 22.25,113.22 13.24,113.22 12.79,113.67 6,113.67 5.99,113.66 0.3,113.66 0.27,113.67 0.25,113.71 0.25,122.1 0.27,122.13 0.3,122.15 24.38,122.15 27.18,123.84 29.61,121.65 30.05,120.93 30.84,120.65 37,120.65 37.89,121.01 38.25,121.9 38.25,122.1 38.27,122.13 38.3,122.15 48,122.15 64.38,125.94 77.43,136.56 77.69,136.77 78.02,136.85 78.62,136.85 79.2,136.99 79.65,137.38 81.61,140.5 83.26,143.8 83.34,144.56 82.96,145.22 82.74,145.6 82.77,146.04 84.63,152.6 85.25,159.4 85.25,161.5 85.27,161.53 85.3,161.55
GND on IN1 (solid shape): outline of 822 points within 145.13,172.45 162.72,179.88
GND on VCC (solid shape): outline of 1451 points within 1.02,92.89 21.49,121.38
GND on VCC (solid shape): outline of 1495 points within 1.02,21.64 20.54,78.73
GND on VCC (solid shape): outline of 30102 points within 40.73,57.65 184.18,112.26
GND on IN2 (solid shape): 159.99,191.46 159.99,189.36 159.67,189.04 153.57,189.04 153,189.61 153,191.52 153.25,191.77 159.67,191.77
GND on IN2 (solid shape): 12.35,58.11 12.35,55.44 11.9,54.99 10.19,54.99 10.13,55 10.07,55 0.3,55 0.27,55.02 0.25,55.05 0.25,58.55 0.27,58.58 0.3,58.6 10.07,58.6 10.13,58.6 10.19,58.61 11.85,58.61
GND on IN2 (solid shape): 12.35,24.77 12.35,23.24 10.76,21.66 0.25,21.66 0.25,23.3 0.27,23.34 0.3,23.35 7.12,23.35 7.85,23.96 7.4,24.8 7.38,24.82 7.37,24.85 7.37,25.34 11.78,25.34
GND on IN2 (solid shape): 11.78,97.22 11.78,94.17 12.25,93.7 12.5,93.7 13.24,93.46 13.7,92.82 13.15,92.82 12.87,93.1 12.5,93.19 0.3,93.19 0.27,93.21 0.25,93.24 0.25,97.6 0.27,97.63 0.3,97.65 11.35,97.65
GND on IN2 (solid shape): 13.73,76.9 13.5,76.39 13.07,76.03 12.54,75.5 12.54,73.03 11.52,72.01 10.81,72.01 10.54,72.44 10.07,72.6 0.3,72.6 0.27,72.62 0.25,72.65 0.25,76.36 0.27,76.39 0.3,76.41 12.5,76.41 12.93,76.54 13.21,76.9
GND on IN2 (solid shape): 12.41,40.52 12.41,37.15 11.27,36.01 8.17,36.01 8.07,35.88 7.96,35.76 7.37,35.76 7.37,35.96 7.38,35.99 7.4,36.01 7.85,36.85 7.12,37.46 0.3,37.46 0.27,37.47 0.25,37.51 0.25,40.95 0.27,40.98 0.3,41 10.07,41 10.15,41 10.23,41.01 11.91,41.01
GND on IN2 (solid shape): outline of 85 points within 112.42,141.15 119.41,147.36
GND on IN2 (solid shape): outline of 101 points within 137.57,149.85 146.71,161.53
GND on IN2 (solid shape): outline of 109 points within 151.16,12.5 164.43,21.77
GND on IN2 (solid shape): outline of 217 points within 174.53,171.28 184.37,177.06
GND on IN2 (solid shape): outline of 264 points within 200.63,62.92 218.21,79.55
GND on IN2 (solid shape): outline of 149 points within 115.98,64.52 237.15,192.85
GND on IN2 (solid shape): outline of 445 points within 209.96,12.7 220.25,29.09
GND on IN2 (solid shape): outline of 725 points within 0.25,110.18 91.34,161.55
GND on IN2 (solid shape): outline of 891 points within 16.22,0.25 230.15,43.37
GND on IN2 (solid shape): outline of 1007 points within 145.19,163.69 162.97,180.14
GND on IN3 (solid shape): 159.99,191.46 159.99,189.36 159.67,189.04 153.57,189.04 153,189.61 153,191.52 153.25,191.77 159.67,191.77
GND on IN3 (solid shape): 217.77,74.72 217.77,64 216.69,62.92 214.91,62.92 214.53,63.3 214.53,64.7 214.91,65.08 215.67,65.08 215.8,65.2 215.8,66.54 215.61,66.73 215.23,66.73 215.04,66.92 215.04,70.98 215.17,71.11 215.61,71.11 215.8,71.3 215.8,72.38 215.61,72.57 214.66,72.57 214.4,72.82 214.4,76.82 214.6,77.01 215.47,77.01
GND on IN3 (solid shape): 12.35,58.11 12.35,55.44 11.9,54.99 10.19,54.99 10.13,55 10.07,55 0.3,55 0.27,55.02 0.25,55.05 0.25,58.55 0.27,58.58 0.3,58.6 10.07,58.6 10.13,58.6 10.19,58.61 11.85,58.61
GND on IN3 (solid shape): 12.35,24.77 12.35,23.24 10.76,21.66 0.25,21.66 0.25,23.3 0.27,23.34 0.3,23.35 7.12,23.35 7.85,23.96 7.4,24.8 7.38,24.82 7.37,24.85 7.37,25.34 11.78,25.34
GND on IN3 (solid shape): 11.78,97.22 11.78,94.17 12.25,93.7 12.5,93.7 13.24,93.46 13.7,92.82 13.15,92.82 12.87,93.1 12.5,93.19 0.3,93.19 0.27,93.21 0.25,93.24 0.25,97.6 0.27,97.63 0.3,97.65 11.35,97.65
GND on IN3 (solid shape): 13.73,76.9 13.5,76.39 13.07,76.03 12.54,75.5 12.54,73.03 11.52,72.01 10.81,72.01 10.54,72.44 10.07,72.6 0.3,72.6 0.27,72.62 0.25,72.65 0.25,76.36 0.27,76.39 0.3,76.41 12.5,76.41 12.93,76.54 13.21,76.9
GND on IN3 (solid shape): 12.41,40.52 12.41,37.15 11.27,36.01 8.17,36.01 8.06,35.87 7.94,35.75 7.37,35.75 7.37,35.96 7.38,35.99 7.4,36.01 7.85,36.85 7.12,37.46 0.3,37.46 0.27,37.47 0.25,37.51 0.25,40.95 0.27,40.98 0.3,41 10.07,41 10.15,41 10.23,41.01 11.91,41.01
GND on IN3 (solid shape): 143.92,160.96 143.92,160.07 144.17,159.82 145.25,159.82 145.38,159.69 145.38,154.74 146.71,153.4 146.71,150.42 146.14,149.85 141.89,149.85 137.57,154.17 137.57,154.77 143.78,154.77 143.79,154.71 143.8,154.66 143.82,154.61 143.85,154.56 143.88,154.51 143.92,154.47 143.97,154.44 144.02,154.42 144.07,154.4 144.13,154.39 144.18,154.39 144.24,154.39 144.29,154.41 144.34,154.43 144.39,154.46 144.43,154.49 144.47,154.53 144.5,154.58 144.52,154.63 144.54,154.68 144.55,154.74 144.55,154.8 144.54,154.85 144.52,154.9 144.5,154.96 144.47,155 144.43,155.04 144.39,155.08 144.34,155.11 144.29,155.13 144.24,155.14 144.18,155.15 144.13,155.15 144.07,155.14 144.02,155.12 143.97,155.09 143.92,155.06 143.88,155.02 143.85,154.98 143.82,154.93 143.8,154.88 143.79,154.82 143.78,154.77 137.57,154.77 137.57,160.77 138.08,161.28 143.6,161.28
GND on IN3 (solid shape): outline of 85 points within 112.42,141.34 118.87,146.8
GND on IN3 (solid shape): outline of 100 points within 16.22,0.25 230.15,26.04
GND on IN3 (solid shape): outline of 329 points within 209.96,12.7 219.36,29.09
GND on IN3 (solid shape): outline of 141 points within 115.98,64.52 237.15,192.85
GND on IN3 (solid shape): outline of 721 points within 0.25,109.6 91.34,161.55
GND on IN3 (solid shape): outline of 1021 points within 145.13,166.99 163.29,179.06
